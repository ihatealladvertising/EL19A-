	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_modu_t1_acel_dt_modu
		"AJMOD table of time constant values when driveline is in modulation mode for vehicle acceleration"
		CURVE
		0x80059db0
		RSA_RecordLayout_CURVE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Ctp_ajs_modu_t1_acel_dt_modu 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_modu_t1_acel_dt_open
		"AJMOD table of time constant values when driveline is open for vehicle acceleration"
		CURVE
		0x80059da2
		RSA_RecordLayout_CURVE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Ctp_ajs_modu_t1_acel_dt_open 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_modu_t1_tkof_dt_open
		"AJMOD table for the filter time constant based on driver sportivity factor during takeoff state for vehicle acceleration"
		CURVE
		0x80059d98
		RSA_RecordLayout_CURVE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Ctp_ajs_modu_t1_tkof_dt_open 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_fac
			ltluECa_kDentwc_ulilrCa_roA_50a
			5
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_modu_tkof_spt_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_modu_td_acel_dt_modu
		"AJMOD table of gain values when driveline is in modulation mode for vehicle acceleration"
		CURVE
		0x80059d8a
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_ajs_modu_td_acel_dt_modu 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_modu_td_acel_dt_open
		"AJMOD table of gain values when driveline is in modulation mode for vehicle acceleration"
		CURVE
		0x80059d7c
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_ajs_modu_td_acel_dt_open 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_modu_td_tkof_dt_open
		"AJMOD table for the filter gain based on driver sportivity factor during takeoff state for vehicle acceleration"
		CURVE
		0x80059d72
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_ajs_modu_td_tkof_dt_open 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_tkof_spt_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_fac
			ltluECa_kDentwc_ulilrCa_roA_50a
			5
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_modu_tkof_spt_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_slk_tqe_off_acel
		"Torque high threshold to deactivate the slack effect for vehicle acceleration"
		CURVE
		0x8005a75c
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_ajs_slk_tqe_off_acel 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_slk_tqe_off_acel_spc
		"Specific torque high threshold to deactivate the slack effect for vehicle acceleration"
		CURVE
		0x800402da
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_ajs_slk_tqe_off_acel_spc 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_slk_tqe_off_decl
		"Torque high threshold to deactivate the slack effect for vehicle deceleration"
		CURVE
		0x8005a74c
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_ajs_slk_tqe_off_decl 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_slk_tqe_off_decl_spc
		"Specific torque high threshold to deactivate the slack effect for vehicle deceleration"
		CURVE
		0x800402ca
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_ajs_slk_tqe_off_decl_spc 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_slk_tqe_on_acel_spc
		"Specific torque low threshold to deactivate the slack effect for vehicle acceleration"
		CURVE
		0x800402ba
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_ajs_slk_tqe_on_acel_spc 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_slk_tqe_on_decl_spc
		"Specific torque low threshold to deactivate the slack effect for vehicle deceleration"
		CURVE
		0x800402aa
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_ajs_slk_tqe_on_decl_spc 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_spd_diff_thd_on_decl
		"Speed difference low threshold to deactivate the slack effect for vehicle deceleration"
		CURVE
		0x8005a73c
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Ctp_ajs_spd_diff_thd_on_decl 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_spv_driv_tq_drv
		"Cartography that converts the derivated driver torque into unit ratio [-1 ; 1]"
		CURVE
		0x8005a734
		RSA_RecordLayout_CURVE_UBYTE
		2
		hBghoxa_gdkcCwa_tEheqqb_n__1o0a
		-1.
		1.
    DISPLAY_IDENTIFIER Ctp_ajs_spv_driv_tq_drv 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_driv_tq_drv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_driv_tq_drv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_driv_tq_drv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_driv_tq_drv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_driv_tq_drv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_driv_tq_drv
			skzzggb_gryEsta_lpfamqd_n__420a
			7
			-5000.
			5000.
        AXIS_PTS_REF Ctb_ajs_driv_tq_drv 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_spv_fast_cor_dly_fac
		"Table for the modulation of the maximum time to enable the boost of the curative anti-jerk function."
		CURVE
		0x8005a724
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_ajs_spv_fast_cor_dly_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_t1_acel_tco_fac
		"Table of modulation factors for the specific AJMOD time constant based on engine coolant temperature during vehicle acceleration"
		CURVE
		0x800402a1
		RSA_RecordLayout_CURVE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_ajs_t1_acel_tco_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_t1_decl_tco_fac
		"Table of modulation factors for the specific AJMOD time constant based on engine coolant temperature during vehicle deceleration"
		CURVE
		0x80040298
		RSA_RecordLayout_CURVE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_ajs_t1_decl_tco_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_td_acel_tco_fac
		"Table of modulation factors for the specific AJMOD gain based on engine coolant temperature during vehicle acceleration"
		CURVE
		0x8004028f
		RSA_RecordLayout_CURVE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_ajs_td_acel_tco_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_td_decl_tco_fac
		"Table of modulation factors for the specific AJMOD gain based on engine coolant temperature during vehicle deceleration"
		CURVE
		0x80040286
		RSA_RecordLayout_CURVE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_ajs_td_decl_tco_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_alt_pow_fil_fac
		"filter factor for alternator power"
		CURVE
		0x8005898a
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_alt_pow_fil_fac 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_alt_n_fil_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_alt_n_fil_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_alt_n_fil_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_alt_n_fil_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_alt_n_fil_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_alt_n_fil_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_amp_spg_sp_cor_pr
		"Boost air pressure setpoint atmospheric pressure correction for regeneration operation"
		CURVE
		0x8005f0a2
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_amp_spg_sp_cor_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_amp_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_amp_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_amp_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_amp_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_amp_spg_sp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			7
			0.
			20000.
        AXIS_PTS_REF Ctb_x_amp_spg_sp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_amp_spg_sp_cor_rij
		"Boost air pressure setpoint atmospheric pressure correction in regular injection"
		CURVE
		0x8005f8a2
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_amp_spg_sp_cor_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_amp_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_amp_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_amp_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_amp_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_amp_spg_sp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			7
			0.
			20000.
        AXIS_PTS_REF Ctb_x_amp_spg_sp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_amp_vnt_ctl_pr
		"Atmospheric pressure correction curve for vnt control value for regeneration"
		CURVE
		0x8005d80a
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_amp_vnt_ctl_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			7
			0.
			20000.
        AXIS_PTS_REF Ctb_x_vnt_ctl_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_amp_vnt_ctl_rij
		"Atmospheric pressure correction curve for vnt control value"
		CURVE
		0x8005e070
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_amp_vnt_ctl_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			7
			0.
			20000.
        AXIS_PTS_REF Ctb_x_vnt_ctl_amp_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_amp_vnt_diag_tqi_cor
		"Correction factor for limited torque in case of negative regulation error for atmospheric pressure"
		CURVE
		0x8005b94a
		RSA_RecordLayout_CURVE_UWORD
		1
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_amp_vnt_diag_tqi_cor 
    FORMAT "%11.9" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_eng_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_eng_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_apmp_max_pow
		"Ctp_apmp_max_pow"
		CURVE
		0x80059218
		RSA_RecordLayout_CURVE_UWORD
		655350
		VA_F_10_m327680_8
		-327680
		327670
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_apmp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_apmp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_apmp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_apmp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_apmp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_gear
			VA_F_0v25_p0_7
			17
			0
			16383.75
        AXIS_PTS_REF Ctb_n_apmp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_engstxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_aut_eng_n_thd
		"Table of engine speed threshold used to declare the autonomous state"
		CURVE
		0x80041516
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_aut_eng_n_thd 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_brk_ass_fac
		"Ctp_brk_ass_fac"
		CURVE
		0x80059367
		RSA_RecordLayout_CURVE_UBYTE
		25.5
		VA_F_0v1_p0_9
		0
		25.5
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_patxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_cata_dp_pat
		"Catalyst pressure drop calculation map"
		MAP
		0x80057d12
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Ctp_cata_dp_pat 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_egaf_cor_pat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_egaf_cor_pat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_egaf_cor_pat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_egaf_cor_pat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_egaf_cor_pat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_egaf_cor
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			10
			0.
			2000.
        AXIS_PTS_REF Ctb_egaf_cor_pat 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_utp_pat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_utp_pat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_utp_pat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_utp_pat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_utp_pat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_utp
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			5
			-40.
			1200.
        AXIS_PTS_REF Ctb_pft_utp_pat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_conv_egr_it_psn
		"Curve of conversion for inlet throttle position command"
		CURVE
		0x80063b78
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctp_conv_egr_it_psn 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_conv_egr_it_psn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_conv_egr_it_psn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_conv_egr_it_psn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_conv_egr_it_psn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_conv_egr_it_psn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_it_wit_emtv_cmd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			16
			0.
			200.
        AXIS_PTS_REF Ctb_x_conv_egr_it_psn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_csm_vnt_ex_reg_max
		"Curve of maximum VNT governor pwm in the exhaust pressure limitation mode"
		CURVE
		0x8005d0b0
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctp_csm_vnt_ex_reg_max 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ex_reg_max */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ex_reg_max */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ex_reg_max */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ex_reg_max */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ex_reg_max */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm_cyl_comb
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_ex_reg_max 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_csm_vnt_ex_reg_min
		"Curve of minimum VNT governor pwm in the exhaust pressure limitation mode"
		CURVE
		0x8005d09c
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctp_csm_vnt_ex_reg_min 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ex_reg_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ex_reg_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ex_reg_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ex_reg_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ex_reg_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm_cyl_comb
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_ex_reg_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_csm_vnt_reg_min
		"Curve of minimum VNT governor pwm"
		CURVE
		0x8005d088
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctp_csm_vnt_reg_min 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm_cyl_comb
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_reg_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_cur_dly
		"Ctp_cur_dly"
		CURVE
		0x800592e3
		RSA_RecordLayout_CURVE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_cut_decl_dly
		"Delay table between the injection cut condition and the injection cut request in fonction of the gearbox"
		CURVE
		0x80043330
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_cut_decl_dly 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_damp_map_dif
		"Dampening factor on the adaptive difference manifold pressure"
		CURVE
		0x800577ba
		RSA_RecordLayout_CURVE_UWORD
		1
		mmvArna_CeqzsCd_pqnbneb_n__630a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_damp_map_dif 
    FORMAT "%11.9" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_damp_map_dif */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_damp_map_dif */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_damp_map_dif */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_damp_map_dif */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_damp_map_dif */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_mapc_hpf_map
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			14
			0.
			20000.
        AXIS_PTS_REF Ctb_damp_map_dif 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_dhil_n_up_shf_in_thd
		"Ctp_dhil_n_up_shf_in_thd"
		CURVE
		0x80059392
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		VA_F_0v25_p0_7
		0
		16383.75
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_dhil_n_up_shf_out_thd
		"Ctp_dhil_n_up_shf_out_thd"
		CURVE
		0x80059386
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		VA_F_0v25_p0_7
		0
		16383.75
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_dhil_vs_down_shf_thd
		"Ctp_dhil_vs_down_shf_thd"
		CURVE
		0x8005937a
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_dil_max_eva_kin_fac_cor
		"Correction on the evaporation kinetic factor depending on the maximum oil dilution stored"
		CURVE
		0x8005531a
		RSA_RecordLayout_CURVE_UWORD
		65.535
		RB_CONV_001_FACT
		0.0
		65.535
    DISPLAY_IDENTIFIER Ctp_dil_max_eva_kin_fac_cor 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_oil_dil_max_oil_eva */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_oil_dil_max_oil_eva */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_oil_dil_max_oil_eva */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_oil_dil_max_oil_eva */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_oil_dil_max_oil_eva */
	/begin AXIS_DESCR
			COM_AXIS
			ClLubWea_NVM.Vxx_pft_oil_dil_max_NVM
			RB_CONV_100_65535_Prc
			12
			0.0
			100.0
        AXIS_PTS_REF Ctb_oil_dil_max_oil_eva 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_dil_rgn_err_dist_min
		"Table giving the minimum distance since last regeneration failure  to allow regeneration"
		CURVE
		0x80046c3c
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_dil_rgn_err_dist_min 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_dil_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_dil_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_dil_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_dil_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_dil_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			Edjqxvd_mqsonha_pgCaqfb_f__6o0a
			8
			0.
			100.
        AXIS_PTS_REF Ctb_pft_dil_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_dil_rgn_min_t
		"Table giving the minimum time since last regeneration to allow regeneration"
		CURVE
		0x80046c2c
		RSA_RecordLayout_CURVE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_dil_rgn_min_t 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_dil_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_dil_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_dil_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_dil_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_dil_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			Edjqxvd_mqsonha_pgCaqfb_f__6o0a
			8
			0.
			100.
        AXIS_PTS_REF Ctb_pft_dil_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_dist_min_oil_dil_tgt_0
		"Minimum distance since last cold regeneration success to enable regeneration"
		CURVE
		0x80046c20
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_dist_min_oil_dil_tgt_0 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_dist_load_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			Edjqxvd_mqsonha_pgCaqfb_f__6o0a
			6
			0.
			100.
        AXIS_PTS_REF Ctb_pft_dist_load_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_dist_min_oil_dil_tgt_1
		"Minimum distance since last cold regeneration success to enable regeneration"
		CURVE
		0x80046c14
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_dist_min_oil_dil_tgt_1 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_dist_load_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			Edjqxvd_mqsonha_pgCaqfb_f__6o0a
			6
			0.
			100.
        AXIS_PTS_REF Ctb_pft_dist_load_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_dist_min_oil_dil_tgt_2
		"Minimum distance since last cold regeneration success to enable regeneration"
		CURVE
		0x80046c08
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_dist_min_oil_dil_tgt_2 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_dist_load_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			Edjqxvd_mqsonha_pgCaqfb_f__6o0a
			6
			0.
			100.
        AXIS_PTS_REF Ctb_pft_dist_load_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_doc1_cal_cpy_gaz
		"Calorific capacity of the gas before DOC"
		CURVE
		0x800581b4
		RSA_RecordLayout_CURVE_UWORD
		3276.75
		kujzEba_zFBxDqa_wAFgmib_Jp__20a
		0.
		3276.75
    DISPLAY_IDENTIFIER Ctp_doc1_cal_cpy_gaz 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_doc1_gaz_temp_mem
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			10
			233.
			1473.
        AXIS_PTS_REF Ctb_doc1_cal_cpy_gaz 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_doc1_cal_cpy_gaz_doc
		"Calorific capacity of the gas before DOC"
		CURVE
		0x800581a0
		RSA_RecordLayout_CURVE_UWORD
		3276.75
		kujzEba_zFBxDqa_wAFgmib_Jp__20a
		0.
		3276.75
    DISPLAY_IDENTIFIER Ctp_doc1_cal_cpy_gaz_doc 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_doc1_cal_cpy_gaz */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_doc1_gaz_temp_mem
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			10
			233.
			1473.
        AXIS_PTS_REF Ctb_doc1_cal_cpy_gaz 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_doc1_cal_cpy_tbn
		"Calorific capacity of the material"
		CURVE
		0x8005819c
		RSA_RecordLayout_CURVE_UWORD
		655.35
		msaFcCa_agEEzEd_bfCiAsb_Jp__1a0
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_doc1_cal_cpy_tbn 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_doc1_cal_cpy_tbn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_doc1_cal_cpy_tbn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_doc1_cal_cpy_tbn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_doc1_cal_cpy_tbn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_doc1_cal_cpy_tbn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_doc1_temp_esti_dly
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			2
			233.
			1473.
        AXIS_PTS_REF Ctb_doc1_cal_cpy_tbn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_doc1_dyn_visc_gaz
		"Dynamic viscosity of gas"
		CURVE
		0x80058188
		RSA_RecordLayout_CURVE_UWORD
		0.00065535
		Czkjnqd_nosBBxb_uAyCyyd_Ns_a0o0
		0.
		0.00065535
    DISPLAY_IDENTIFIER Ctp_doc1_dyn_visc_gaz 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_doc1_dyn_visc_gaz */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_doc1_dyn_visc_gaz */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_doc1_dyn_visc_gaz */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_doc1_dyn_visc_gaz */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_doc1_dyn_visc_gaz */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tbt_conv
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			10
			233.
			1473.
        AXIS_PTS_REF Ctb_doc1_dyn_visc_gaz 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_doc1_ext_cnvt_cur
		"Externe convection curve"
		CURVE
		0x80058176
		RSA_RecordLayout_CURVE_UWORD
		655.35
		lFmDDfb_EFFzjta_ysimAea_W__000a
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_doc1_ext_cnvt_cur 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_doc1_ext_cnvt_cur */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_doc1_ext_cnvt_cur */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_doc1_ext_cnvt_cur */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_doc1_ext_cnvt_cur */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_doc1_ext_cnvt_cur */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			9
			0.
			655.35
        AXIS_PTS_REF Ctb_doc1_ext_cnvt_cur 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_doc1_itl_cnvt_cur
		"Nusselt Internal convection curve"
		CURVE
		0x80058162
		RSA_RecordLayout_CURVE_UWORD
		8191
		nsFDDzd_bbvtgna_EqfAxwb_m_R0ooa
		0.
		8191.
    DISPLAY_IDENTIFIER Ctp_doc1_itl_cnvt_cur 
    FORMAT "%8.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_doc1_itl_cnvt_cur */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_doc1_itl_cnvt_cur */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_doc1_itl_cnvt_cur */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_doc1_itl_cnvt_cur */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_doc1_itl_cnvt_cur */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_doc1_itl_cnvt_cur
			ykmzBoa_nqupBma_Ffvbarc_m_R0ooa
			10
			0.
			6553.5
        AXIS_PTS_REF Ctb_doc1_itl_cnvt_cur 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_doc1_tbn_vol_th_loss
		"Turbine Volumetric thermal loss"
		CURVE
		0x80058150
		RSA_RecordLayout_CURVE_UWORD
		655350
		ardBnwb_nuseFmc_fvuFqsa_J__0a60
		-327680.
		327670.
    DISPLAY_IDENTIFIER Ctp_doc1_tbn_vol_th_loss 
    FORMAT "%7.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_doc1_tbn_vol_th_loss */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_doc1_tbn_vol_th_loss */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_doc1_tbn_vol_th_loss */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_doc1_tbn_vol_th_loss */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_doc1_tbn_vol_th_loss */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_doc1_dif_prs_cpr
			BhendBa_Bnmgqnd_blgaFzd_hCRa10a
			9
			-10000.
			10000.
        AXIS_PTS_REF Ctb_doc1_tbn_vol_th_loss 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_doc1_th_trsm_gaz
		"Thermal transmission of gas"
		CURVE
		0x8005813c
		RSA_RecordLayout_CURVE_UWORD
		6.5535
		Eyamixb_yerjCqa_owzAdmc_WKA_0a0
		0.
		6.5535
    DISPLAY_IDENTIFIER Ctp_doc1_th_trsm_gaz 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_doc1_th_trsm_gaz */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_doc1_th_trsm_gaz */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_doc1_th_trsm_gaz */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_doc1_th_trsm_gaz */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_doc1_th_trsm_gaz */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tbt_conv
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			10
			233.
			1473.
        AXIS_PTS_REF Ctb_doc1_th_trsm_gaz 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_atissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_drag_tco_min_is_n
		"Idle speed setpoint which depends of the coolant temperature in case of drag reduction"
		CURVE
		0x8005ada6
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_drag_tco_min_is_n 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_driv_sp_grd_ref
		"Driver activity reference value (vehicle speed dependent tuning factor)"
		CURVE
		0x80059199
		RSA_RecordLayout_CURVE_UBYTE
		2.55
		xrnmuaa_rEFCrod_vifAgta_roCR1a0
		0.
		2.55
    DISPLAY_IDENTIFIER Ctp_driv_sp_grd_ref 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_driv_sp_grd_ref_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_driv_sp_grd_ref_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_driv_sp_grd_ref_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_driv_sp_grd_ref_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_driv_sp_grd_ref_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			5
			0.
			655.35
        AXIS_PTS_REF Ctb_driv_sp_grd_ref_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_dt1_exp
		""
		CURVE
		0x8004347c
		RSA_RecordLayout_CURVE_UWORD
		1
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_dt1_exp 
    FORMAT "%6.4" 
    READ_ONLY 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_dt1_exp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_dt1_exp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_dt1_exp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_dt1_exp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_dt1_exp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_dt1_exp
			kybEEsb_fcjzqub_saFowBd_n_ao66a
			16
			0.
			9.
        AXIS_PTS_REF Ctb_dt1_exp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_dyn_forc
		"Cartography of resistive effort function of vehicle speed"
		CURVE
		0x80040183
		RSA_RecordLayout_CURVE_UBYTE
		6375
		llaAkia_mlcicDa_bdBfbsd_N__400a
		0.
		6375.
    DISPLAY_IDENTIFIER Ctp_dyn_forc 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_cru_sl_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_cru_sl_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_cru_sl_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_cru_sl_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_cru_sl_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			FfBqnda_Bdvwydd_aAwtuCb_khA_10a
			17
			0.
			255.
        AXIS_PTS_REF Ctb_cru_sl_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_efi_ff_pwm_ff
		"Table of mass flow bkpts map for the cycling opening percentage of the fuel injector in exhaust"
		CURVE
		0x80058df6
		RSA_RecordLayout_CURVE_UWORD
		655.35
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_efi_ff_pwm_ff 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_efi_ff_pwm_ff */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_efi_ff_pwm_ff */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_efi_ff_pwm_ff */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_efi_ff_pwm_ff */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_efi_ff_pwm_ff */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efi_pwm_prct_ind_cor
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			8
			0.
			200.
        AXIS_PTS_REF Ctb_efi_ff_pwm_ff 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_efi_ff_pwm_prct
		"Table of efi injector cycling opening percentage (in standard ond pres) depending on efi mass flow"
		CURVE
		0x80058de6
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctp_efi_ff_pwm_prct 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_efi_ff_pwm */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_efi_ff_pwm */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_efi_ff_pwm */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_efi_ff_pwm */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_efi_ff_pwm */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efi_efv_ff_clc
			cdvfnAa_yxaetBd_njakqtd_gnA_00a
			8
			0.
			655.35
        AXIS_PTS_REF Ctb_efi_ff_pwm 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_efi_fuel_prs_n
		"Table of exhaust fuel line pressure estimation depending on engine spped"
		CURVE
		0x80058dde
		RSA_RecordLayout_CURVE_UBYTE
		25
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		25.
    DISPLAY_IDENTIFIER Ctp_efi_fuel_prs_n 
    FORMAT "%4.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_efi_fuel_prs_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_efi_fuel_prs_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_efi_fuel_prs_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_efi_fuel_prs_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_efi_fuel_prs_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_efi_fuel_prs_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_egaf_efi_purg_msf
		"Table of mass fraction to compute purge fuel flow"
		CURVE
		0x80058f3e
		RSA_RecordLayout_CURVE_UWORD
		0.1
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		0.1
    DISPLAY_IDENTIFIER Ctp_egaf_efi_purg_msf 
    FORMAT "%5.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_efi_purg_msf_egaf */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_efi_purg_msf_egaf */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_efi_purg_msf_egaf */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_efi_purg_msf_egaf */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_efi_purg_msf_egaf */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_egaf
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			8
			0.
			2000.
        AXIS_PTS_REF Ctb_efi_purg_msf_egaf 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_egb_dri_drag_red_dly_temp
		"Temporization between the transition Drive - > drag reduction"
		CURVE
		0x8005863e
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_egb_dri_drag_red_dly_temp 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_egb_dri_neut_dly_temp
		"Temporization between the transition Drive -> neutral"
		CURVE
		0x8005861e
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_egb_dri_neut_dly_temp 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_egr_cut_dly_aftr_sta
		"Curve for the cutting time of EGR after start"
		CURVE
		0x80062889
		RSA_RecordLayout_CURVE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctp_egr_cut_dly_aftr_sta 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_egr_cut_dly_aftr_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_egr_cut_dly_aftr_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_egr_cut_dly_aftr_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_egr_cut_dly_aftr_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_egr_cut_dly_aftr_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_x_egr_cut_dly_aftr_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_egr_cut_tqi_tco_pr
		"Curve based on tco to correct the torque threshold in fast accel determination in pr mode"
		CURVE
		0x80061518
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_egr_cut_tqi_tco_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_egr_cut_tqi_tco_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_egr_cut_tqi_tco_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_egr_cut_tqi_tco_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_egr_cut_tqi_tco_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_egr_cut_tqi_tco_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_x_egr_cut_tqi_tco_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_egr_cut_tqi_tco_rij_pp
		"Curve based on tco to correct the torque threshold in fast accel determination in rij and pp modes"
		CURVE
		0x80061510
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_egr_cut_tqi_tco_rij_pp 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_egr_cut_tqi_tco_rij_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_egr_cut_tqi_tco_rij_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_egr_cut_tqi_tco_rij_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_egr_cut_tqi_tco_rij_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_egr_cut_tqi_tco_rij_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_x_egr_cut_tqi_tco_rij_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_el_csm_n_sp_ofs
		"interpolation table used for the calculation of the electric balance protection idle setpoint offset"
		CURVE
		0x8005ae48
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_el_csm_n_sp_ofs 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_el_csm_n_sp_ofs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_el_csm_n_sp_ofs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_el_csm_n_sp_ofs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_el_csm_n_sp_ofs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_el_csm_n_sp_ofs */
	/begin AXIS_DESCR
			COM_AXIS
			SmIsrSpt_NVM.Vxx_el_csm_ctr_NVM
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			9
			0.
			255.
        AXIS_PTS_REF Ctb_el_csm_n_sp_ofs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_emtv_psn_ofs_disp_last_1
		"Curve for the dispersion of the last offset."
		CURVE
		0x80058b3c
		RSA_RecordLayout_CURVE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_emtv_psn_ofs_disp_last_1 
    FORMAT "%12.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_emtv_psn_ofs_disp_last_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_emtv_psn_ofs_disp_last_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_emtv_psn_ofs_disp_last_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_emtv_psn_ofs_disp_last_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_emtv_psn_ofs_disp_last_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_emtv_psn_ofs_disp_last_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_emtv_psn_ofs_disp_last_2
		"Curve for the dispersion of the last offset value for OBD purpose."
		CURVE
		0x80058b2c
		RSA_RecordLayout_CURVE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_emtv_psn_ofs_disp_last_2 
    FORMAT "%12.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_emtv_psn_ofs_disp_last_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_emtv_psn_ofs_disp_last_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_emtv_psn_ofs_disp_last_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_emtv_psn_ofs_disp_last_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_emtv_psn_ofs_disp_last_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_emtv_psn_ofs_disp_last_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_emtv_pwl_act
		"Cartography of the position setpoints sent during the PWL."
		CURVE
		0x80058ba0
		RSA_RecordLayout_CURVE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_emtv_pwl_act 
    FORMAT "%12.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_emtv_pwl_act */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_emtv_pwl_act */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_emtv_pwl_act */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_emtv_pwl_act */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_emtv_pwl_act */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_emtv_t_pwl
			nCcfksc_mngycBb_hCDnnsa_s__a00a
			16
			0.
			65.535
        AXIS_PTS_REF Ctb_emtv_pwl_act 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_emtv_sens_cor
		"Cartography to convert the read position to a normalized position"
		CURVE
		0x80056fa6
		RSA_RecordLayout_CURVE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_emtv_sens_cor 
    FORMAT "%8.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_emtv_sens_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_emtv_sens_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_emtv_sens_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_emtv_sens_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_emtv_sens_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_emtv_psn_chr
			xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
			4
			0.
			100.
        AXIS_PTS_REF Ctb_emtv_sens_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ex_cor_ena_off_thd_rij
		"Low threshold of exhaust pressure setpoints correction hysteresis activation in regular injection mode"
		CURVE
		0x80060bfc
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_ex_cor_ena_off_thd_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ex_cor_ena_off_thd_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ex_cor_ena_off_thd_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ex_cor_ena_off_thd_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ex_cor_ena_off_thd_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ex_cor_ena_off_thd_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_ex_cor_ena_off_thd_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ex_cor_ena_on_thd_rij
		"Exhaust pressure setpoints correction curve depending on a particulate filter upstream pressure in regular injection mode"
		CURVE
		0x80060bdc
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_ex_cor_ena_on_thd_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ex_cor_ena_on_thd_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ex_cor_ena_on_thd_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ex_cor_ena_on_thd_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ex_cor_ena_on_thd_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ex_cor_ena_on_thd_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_ex_cor_ena_on_thd_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ex_df_spg_sp_cor_pr
		"Boost air pressure setpoint intake temperature correction in case of exhaust pressure sensor limphome in particule filter regeneration"
		CURVE
		0x8005f094
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_ex_df_spg_sp_cor_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_ex_df_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_ex_df_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_ex_df_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_ex_df_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_ex_df_spg_sp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_spg_sp_pr
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			7
			-40.
			200.
        AXIS_PTS_REF Ctb_x_ex_df_spg_sp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ex_df_spg_sp_cor_rij
		"Boost air pressure setpoint intake temperature correction in case of exhaust pressure sensor limphome in regular injection mode."
		CURVE
		0x8005f894
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_ex_df_spg_sp_cor_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_ex_df_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_ex_df_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_ex_df_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_ex_df_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_ex_df_spg_sp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_spg_sp_rij
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			7
			-40.
			200.
        AXIS_PTS_REF Ctb_x_ex_df_spg_sp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ex_prs_cor_ena_off_thd_pr
		"Low threshold of exhaust pressure setpoints correction hysteresis activation in pft regeneration mode"
		CURVE
		0x80060328
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_ex_prs_cor_ena_off_thd_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ex_prs_cor_ena_off_thd_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ex_prs_cor_ena_off_thd_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ex_prs_cor_ena_off_thd_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ex_prs_cor_ena_off_thd_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ex_prs_cor_ena_off_thd_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_ex_prs_cor_ena_off_thd_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ex_prs_cor_ena_on_thd_pr
		"Exhaust pressure setpoint correction curve depending on particulate filter upstream pressure in pft regeneration mode"
		CURVE
		0x80060308
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_ex_prs_cor_ena_on_thd_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ex_prs_cor_ena_on_thd_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ex_prs_cor_ena_on_thd_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ex_prs_cor_ena_on_thd_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ex_prs_cor_ena_on_thd_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ex_prs_cor_ena_on_thd_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_ex_prs_cor_ena_on_thd_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ex_prs_sp_pft_cor_pr
		"Exhaust pressure setpoint correction curve depending on particulate filter upstream pressure in pft regeneration mode"
		CURVE
		0x800602f4
		RSA_RecordLayout_CURVE_UWORD
		2
		umakcCa_opladyb_qkxtEDd_BC_1o00
		-1.
		1.
    DISPLAY_IDENTIFIER Ctp_ex_prs_sp_pft_cor_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ex_prs_sp_pft_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_dp
			BhendBa_Bnmgqnd_blgaFzd_hCRa10a
			10
			-10000.
			10000.
        AXIS_PTS_REF Ctb_ex_prs_sp_pft_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ex_prs_sp_pft_cor_rij
		"Exhaust pressure setpoint correction curve depending on particulate filter upstream pressure in regular injection mode"
		CURVE
		0x80060bc8
		RSA_RecordLayout_CURVE_UWORD
		2
		umakcCa_opladyb_qkxtEDd_BC_1o00
		-1.
		1.
    DISPLAY_IDENTIFIER Ctp_ex_prs_sp_pft_cor_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ex_prs_sp_pft_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_dp
			BhendBa_Bnmgqnd_blgaFzd_hCRa10a
			10
			-10000.
			10000.
        AXIS_PTS_REF Ctb_ex_prs_sp_pft_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ex_prs_thd_h
		"High thresholds values depending on exhaust pressure setpoint to activate ex_ press_ limitation"
		CURVE
		0x80043b0a
		RSA_RecordLayout_CURVE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Ctp_ex_prs_thd_h 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ex_prs_thd_h */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ex_prs_thd_h */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ex_prs_thd_h */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ex_prs_thd_h */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ex_prs_thd_h */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ex_prs_lim_sp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			10
			0.
			20000.
        AXIS_PTS_REF Ctb_ex_prs_thd_h 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_fast_off_kd_n_thd
		"Ctp_fast_off_kd_n_thd"
		CURVE
		0x80059336
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		VA_F_0v25_p0_7
		0
		16383.75
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_fast_off_no_pdl_dly
		"Ctp_fast_off_no_pdl_dly"
		CURVE
		0x80059309
		RSA_RecordLayout_CURVE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_fct_tco_dly
		"Table of starter time out function of the water temperature"
		CURVE
		0x8005cef4
		RSA_RecordLayout_CURVE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Ctp_fct_tco_dly 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fct_tco_crkm */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fct_tco_crkm */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fct_tco_crkm */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fct_tco_crkm */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fct_tco_crkm */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_fct_tco_crkm 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_adv_amp_fac_pr
		"main advance's factor of coolant temperature during pr"
		CURVE
		0x80069e30
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_adv_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_fms_adv_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_fms_adv_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_fms_adv_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_fms_adv_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_fms_adv_amp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_fms_adv_amp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainsta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_adv_amp_fac_sta
		"Atmospheric pressure dependant factor for main advance correction during Starting combustion mode"
		CURVE
		0x8006ade2
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_adv_amp_fac_sta 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_adv_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_adv_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_adv_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_adv_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_adv_amp_fac_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_adv_amp_fac_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_adv_dp_map_fac_rij
		"Delta mass air pressure factor for main advance during rij"
		CURVE
		0x8004f3b0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_adv_dp_map_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_dp_fms_adv_dp_map_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_dp_fms_adv_dp_map_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_dp_fms_adv_dp_map_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_dp_fms_adv_dp_map_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_dp_fms_adv_dp_map_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_reg_spg_err
			BhendBa_Bnmgqnd_blgaFzd_hCRa10a
			8
			-10000.
			10000.
        AXIS_PTS_REF Ctb_dp_fms_adv_dp_map_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_adv_dp_rps_fac_pr
		"Delta rail pressure factor for main advance during pr"
		CURVE
		0x80069e20
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_adv_dp_rps_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_rps_dp_rail_prs
			AhCDoja_prbvulb_dammzgc_b__0a0a
			8
			-2000.
			2000.
        AXIS_PTS_REF Ctb_dp_fms_adv_dp_rps_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_adv_dp_rps_fac_rij
		"Delta rail pressure factor for main advance during rij"
		CURVE
		0x8004f3a0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_adv_dp_rps_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_dp_fms_adv_dp_rps_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_rps_dp_rail_prs
			AhCDoja_prbvulb_dammzgc_b__0a0a
			8
			-2000.
			2000.
        AXIS_PTS_REF Ctb_dp_fms_adv_dp_rps_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_adv_ms_dp_fac_pr
		"Partilculate filter soot mass factor for main advance during pr"
		CURVE
		0x80069e10
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_adv_ms_dp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ms_fms_adv_ms_dp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ms_fms_adv_ms_dp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ms_fms_adv_ms_dp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ms_fms_adv_ms_dp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ms_fms_adv_ms_dp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			8
			0.
			100.
        AXIS_PTS_REF Ctb_ms_fms_adv_ms_dp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_adv_tco_fac_pr
		"main advance's factor of coolant temperature during pr"
		CURVE
		0x80069e00
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_adv_tco_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_adv_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_adv_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_adv_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_adv_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_adv_tco_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_adv_tco_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_adv_tco_fac_rij
		"main advance's factor of coolant temperature for 3D interpolation"
		CURVE
		0x8004f390
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_adv_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_adv_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_adv_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_adv_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_adv_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_adv_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_adv_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_adv_tia_fac_pr
		"main advance's factor of coolant temperature during pr"
		CURVE
		0x80069df0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_adv_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_fms_adv_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_fms_adv_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_fms_adv_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_fms_adv_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_fms_adv_tia_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_fms_adv_tia_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_amp_fac_pr
		"Table of factor of atmospheric pressure interpolation for quantity of global injection during pft rgn"
		CURVE
		0x80043dc0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_amp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp_reg
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_amp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_dyn_phi_ofs_nxt_cyl
		"Map for maximum variation of angle of first injection on next cylinder, depending on n."
		CURVE
		0x80069196
		RSA_RecordLayout_CURVE_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Ctp_fms_dyn_phi_ofs_nxt_cyl 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_dyn_phi_ofs_nxt_cyl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_dyn_phi_ofs_nxt_cyl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_dyn_phi_ofs_nxt_cyl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_dyn_phi_ofs_nxt_cyl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_dyn_phi_ofs_nxt_cyl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_dyn_phi_ofs_nxt_cyl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_faf_tco_fac_rij
		"Factor of coolant temperature interpolation for quantity of after injection factor during rij"
		CURVE
		0x800681a8
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_faf_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_faf_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_faf_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_faf_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_faf_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_faf_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_faf_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp1_amp_fac_pr
		"Factor of atmospheric pressure interpolation for quantity of pre-injection 1 during pft regeneration"
		CURVE
		0x8004b44c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp1_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp1_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp1_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp1_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp1_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp1_amp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_fp1_amp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp1_amp_fac_sta
		"Atmospheric pressure dependant factor for pilote 1 quantity correction during Starting combustion mode"
		CURVE
		0x80068c46
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp1_amp_fac_sta 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp1_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp1_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp1_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp1_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp1_amp_fac_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_fp1_amp_fac_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp1_tco_fac_pr
		"Factor of coolant temperature interpolation for quantity of pre-injection 1 during pft regeneration"
		CURVE
		0x8004b43c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp1_tco_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp1_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp1_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp1_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp1_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp1_tco_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_fp1_tco_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp1_tco_fac_rij
		"Factor of coolant temperature interpolation for quantity of pre-injection 1 during regular injection"
		CURVE
		0x800498ba
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp1_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp1_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp1_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp1_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp1_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp1_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_fp1_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp1_tia_fac_pr
		"Factor of intake air temperature interpolation for quantity of pre-injection 1 during pft rgn"
		CURVE
		0x8004b42c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp1_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp1_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp1_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp1_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp1_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp1_tia_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_fp1_tia_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp2_amp_fac_pr
		"Factor of atmospheric pressure interpolation for quantity of pre-injection 2 during pft regeneration"
		CURVE
		0x8004be2c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp2_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp2_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp2_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp2_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp2_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp2_amp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_fp2_amp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp2_amp_fac_sta
		"Atmospheric pressure dependant factor for pilote 2 quantity correction during Starting combustion mode"
		CURVE
		0x80068d28
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp2_amp_fac_sta 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp2_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp2_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp2_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp2_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp2_amp_fac_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_fp2_amp_fac_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp2_tco_fac_pr
		"Factor of coolant temperature interpolation for quantity of pre-injection 2 during pft regeneration"
		CURVE
		0x8004be1c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp2_tco_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp2_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp2_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp2_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp2_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp2_tco_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_fp2_tco_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp2_tco_fac_rij
		"Factor of coolant temperature interpolation for quantity of pre-injection 2 during regular injection"
		CURVE
		0x8004a994
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp2_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp2_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp2_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp2_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp2_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp2_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_fp2_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fp2_tia_fac_pr
		"Factor of intake air temperature interpolation for quantity of pre-injection 2 during pft rgn"
		CURVE
		0x8004be0c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fp2_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fp2_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fp2_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fp2_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fp2_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fp2_tia_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_fp2_tia_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fpo_amp_fac_pr
		"Factor of atmospheric pressure interpolation for quantity of post injection during pft rgn"
		CURVE
		0x8004ca6c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fpo_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fpo_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fpo_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fpo_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fpo_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fpo_amp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_fpo_amp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fpo_tco_fac_pr
		"Factor of coolant temperature interpolation for quantity of post injection during pft regeneration"
		CURVE
		0x8004ca5c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fpo_tco_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fpo_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fpo_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fpo_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fpo_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fpo_tco_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_fpo_tco_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_fpo_tia_fac_pr
		"Factor of intake air temperature interpolation for quantity of post injection during pft rgn"
		CURVE
		0x8004ca4c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_fpo_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_fpo_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_fpo_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_fpo_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_fpo_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_fpo_tia_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_fpo_tia_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_ms_dp_fac_pr
		"Table of factor of CSF equivalent load interpolation for quantity of global injection during pft rgn"
		CURVE
		0x80043db0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_ms_dp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_ms_dp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_ms_dp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_ms_dp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_ms_dp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_ms_dp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_ms_dp_reg
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			8
			0.
			100.
        AXIS_PTS_REF Ctb_fms_ms_dp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_taf_tco_fac_rij
		"Factor of coolant temperature interpolation for separation of after injection factor during rij"
		CURVE
		0x80069260
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_taf_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_taf_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_taf_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_taf_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_taf_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_taf_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_taf_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tia_fac_pr
		"Table of factor of intake air temperature interpolation for quantity of global injection during pft rgn"
		CURVE
		0x80043da0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tia_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_reg
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_tia_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tlp_amp_fac_pr
		""
		CURVE
		0x8004eb20
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tlp_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_fms_tlp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_fms_tlp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tlp_tco_fac_pr
		""
		CURVE
		0x8004eb10
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tlp_tco_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_tlp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_tlp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tlp_tia_fac_pr
		""
		CURVE
		0x8004eb00
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tlp_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_fms_tlp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_fms_tlp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_fms_tlp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tp1_amp_fac_pr
		"Factor of atmospheric pressure interpolation for separation of pre-injection 1 during pft regenerati"
		CURVE
		0x80053430
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tp1_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tp1_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tp1_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tp1_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tp1_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tp1_amp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_tp1_amp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tp1_tco_fac_pr
		"Factor of coolant temperature interpolation for separation of pre-injection 1 during pft regeneratio"
		CURVE
		0x80053420
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tp1_tco_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tp1_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tp1_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tp1_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tp1_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tp1_tco_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_tp1_tco_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tp1_tco_fac_rij
		"Factor of coolant temperature interpolation for separation of pre-injection 1 during regular injecti"
		CURVE
		0x80050fbe
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tp1_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tp1_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tp1_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tp1_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tp1_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tp1_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_tp1_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tp1_tia_fac_pr
		"Factor of intake air temperature interpolation for separation of pre-injection 1 during pft rgn"
		CURVE
		0x80053410
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tp1_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tp1_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tp1_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tp1_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tp1_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tp1_tia_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_tp1_tia_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tp2_amp_fac_pr
		"Factor of atmospheric pressure interpolation for separation of pre-injection 2 during pft regenerati"
		CURVE
		0x80053f08
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tp2_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tp2_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tp2_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tp2_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tp2_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tp2_amp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_tp2_amp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tp2_tco_fac_pr
		"Factor of atmospheric pressure interpolation for separation of pre-injection 2 during pft regenerati"
		CURVE
		0x80053ef8
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tp2_tco_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tp2_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tp2_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tp2_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tp2_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tp2_tco_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_tp2_tco_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tp2_tco_fac_rij
		"Factor of coolant temperature interpolation for separation of pre-injection 2 during regular injecti"
		CURVE
		0x80052240
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tp2_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_tp2_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_tp2_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_tp2_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_tp2_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_tp2_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_tp2_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tp2_tia_fac_pr
		"Factor of atmospheric pressure interpolation for separation of pre-injection 2 during pft regenerati"
		CURVE
		0x80053ee8
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tp2_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tp2_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tp2_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tp2_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tp2_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tp2_tia_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_tp2_tia_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tpo_amp_fac_pr
		""
		CURVE
		0x800549e0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tpo_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tpo_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tpo_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tpo_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tpo_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tpo_amp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_tpo_amp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tpo_tco_fac_pr
		""
		CURVE
		0x800549d0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tpo_tco_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tpo_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tpo_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tpo_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tpo_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tpo_tco_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_tpo_tco_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_fms_tpo_tia_fac_pr
		""
		CURVE
		0x800549c0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_fms_tpo_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_tpo_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_tpo_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_tpo_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_tpo_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_tpo_tia_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_tpo_tia_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_gbxlixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_gear_lim_tq
		"gearbox torque limitation"
		CURVE
		0x8005b218
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_gear_lim_tq 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_filspxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_gear_n_mv_ftc
		"filtering time constant for engine speed"
		CURVE
		0x80058916
		RSA_RecordLayout_CURVE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Ctp_gear_n_mv_ftc 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_gear_pdl_no_seq_dly
		"Ctp_gear_pdl_no_seq_dly"
		CURVE
		0x800592ff
		RSA_RecordLayout_CURVE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_hpf_fac_rich_clc
		"Time constant for filtering upstream proprtional richness"
		CURVE
		0x80058386
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_hpf_fac_rich_clc 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_maf_dyn_hpf_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_maf_dyn_hpf_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_maf_dyn_hpf_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_maf_dyn_hpf_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_maf_dyn_hpf_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			11
			0.
			5000.
        AXIS_PTS_REF Ctb_maf_dyn_hpf_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_ast_ofs
		"Offset (depending coolant temperature) about idle speed setpoint to create after start state threshold"
		CURVE
		0x8005ae26
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Ctp_is_ast_ofs 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_d_err_fac
		"Derivative correction factor table dependent on static error"
		CURVE
		0x8005aa28
		RSA_RecordLayout_CURVE_UWORD
		2
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_is_d_err_fac 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_n_d_dif */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_n_d_dif */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_n_d_dif */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_n_d_dif */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_n_d_dif */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_dif_n_sp
			cvxuqsa_qeEanfd_gyuanCd_rCRa38a
			8
			-8192.
			8191.75
        AXIS_PTS_REF Ctb_is_n_d_dif 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_d_gear_fac
		"Derivative correction factor table dependent on gear ratio"
		CURVE
		0x8005aa18
		RSA_RecordLayout_CURVE_UWORD
		2
		uBFsuAd_hvfAplb_zlBDusd_NrC_1a0
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_is_d_gear_fac 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_d_max
		"Idle speed table used to determine the maximum limitation of derivative correction function Tco"
		CURVE
		0x8005aa06
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_is_d_max 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_d_min
		"Idle speed table used to determine the minimum limitation of derivative correction function Tco"
		CURVE
		0x8005a9f4
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_is_d_min 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_d_tco_fac
		"Derivative correction factor table dependent on coolant temperature"
		CURVE
		0x8005a9e2
		RSA_RecordLayout_CURVE_UWORD
		2
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_is_d_tco_fac 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_i_gear_fac
		"Integral correction factor table dependent on gear ratio"
		CURVE
		0x8005ab6c
		RSA_RecordLayout_CURVE_UWORD
		2
		afehFbd_BkiipFd_DFrgCuc_Nrj_ao0
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_is_i_gear_fac 
    FORMAT "%7.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_in_tco_ofs
		"Offset function coolant temperature to modify the threshold of entry to ISR"
		CURVE
		0x8005aad4
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Ctp_is_in_tco_ofs 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_out_sta_dly
		"Delay to exit of start state to condition state directly (function coolant temperature)"
		CURVE
		0x8005aac4
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_is_out_sta_dly 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_p_gear_fac
		"Proportionnal correction factor table dependant on gear ratio"
		CURVE
		0x8005acee
		RSA_RecordLayout_CURVE_UWORD
		2
		FhjEdpd_murFlfd_zlheCCb_Np__0a0
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_is_p_gear_fac 
    FORMAT "%11.9" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_p_max
		"Maximum proportionnal torque correction Table dependent on coolant temperature"
		CURVE
		0x8005acdc
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_is_p_max 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_p_min
		"Minimum proportionnal torque correction Table dependent on coolant temperature"
		CURVE
		0x8005acca
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_is_p_min 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_is_p_sta_fac
		"Proportionnal Starting correction factor table dependent on Gear ratio and regulator (IS) static er"
		CURVE
		0x8005acba
		RSA_RecordLayout_CURVE_UWORD
		7.9990234375
		afehFbd_BkiipFd_DFrgCuc_Nrj_ao0
		0.
		7.9990234375
    DISPLAY_IDENTIFIER Ctp_is_p_sta_fac 
    FORMAT "%7.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_frst_ofs_act
		"Cartography to adapt the position reference to the component driving convention"
		CURVE
		0x80058cf8
		RSA_RecordLayout_CURVE_UWORD
		200
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_it_frst_ofs_act 
    FORMAT "%9.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_it_frst_ofs_act */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_it_frst_ofs_act */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_it_frst_ofs_act */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_it_frst_ofs_act */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_it_frst_ofs_act */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_it_t_frst_ofs
			nCcfksc_mngycBb_hCDnnsa_s__a00a
			16
			0.
			65.535
        AXIS_PTS_REF Ctb_it_frst_ofs_act 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_pwl_act
		"Cartography of the position setpoints sent during the PWL."
		CURVE
		0x80058cd8
		RSA_RecordLayout_CURVE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_it_pwl_act 
    FORMAT "%8.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_it_pwl_act */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_it_pwl_act */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_it_pwl_act */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_it_pwl_act */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_it_pwl_act */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_it_t_pwl_act
			nCcfksc_mngycBb_hCDnnsa_s__a00a
			16
			0.
			65.535
        AXIS_PTS_REF Ctb_it_pwl_act 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sat_cor_amp_pp
		"Curve of correction for thr sat depending on amp if rgn_prmt mode is on"
		CURVE
		0x800628d0
		RSA_RecordLayout_CURVE_UBYTE
		5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctp_it_sat_cor_amp_pp 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_cor_amp_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			16
			0.
			20000.
        AXIS_PTS_REF Ctb_x_it_sat_cor_amp_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sat_cor_amp_pr
		"Curve of correction for thr sat depending on amp if rgn mode is on"
		CURVE
		0x80062f06
		RSA_RecordLayout_CURVE_UBYTE
		5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctp_it_sat_cor_amp_pr 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			16
			0.
			20000.
        AXIS_PTS_REF Ctb_x_it_sat_cor_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sat_cor_amp_rij
		"Curve of correction for thr sat depending on amp in regular injection mode"
		CURVE
		0x8006353e
		RSA_RecordLayout_CURVE_UBYTE
		5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctp_it_sat_cor_amp_rij 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_cor_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			16
			0.
			20000.
        AXIS_PTS_REF Ctb_x_it_sat_cor_amp_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sat_cor_tco_pp
		"Curve of correction for thr sat depending on tco if rgn_prmt mode is on"
		CURVE
		0x800628c8
		RSA_RecordLayout_CURVE_UBYTE
		5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctp_it_sat_cor_tco_pp 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_cor_tco_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_x_it_sat_cor_tco_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sat_cor_tco_pr
		"Curve of correction for thr sat depending on tco if rgn mode is on"
		CURVE
		0x80062efe
		RSA_RecordLayout_CURVE_UBYTE
		5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctp_it_sat_cor_tco_pr 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_cor_tco_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_x_it_sat_cor_tco_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sat_cor_tco_rij
		"Curve of correction for thr sat depending on tco in regular injection mode"
		CURVE
		0x80063536
		RSA_RecordLayout_CURVE_UBYTE
		5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctp_it_sat_cor_tco_rij 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_cor_tco_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_x_it_sat_cor_tco_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sat_cor_tia_pp
		"Curve of corrector factor for thr sat depending of tia if rgn_prmt mode is on"
		CURVE
		0x800628c0
		RSA_RecordLayout_CURVE_UBYTE
		5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctp_it_sat_cor_tia_pp 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_cor_tia_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_x_it_sat_cor_tia_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sat_cor_tia_pr
		"Curve of corrector factor for thr sat depending of tia if rgn mode is on"
		CURVE
		0x80062ef6
		RSA_RecordLayout_CURVE_UBYTE
		5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctp_it_sat_cor_tia_pr 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_cor
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_x_it_sat_cor_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sat_cor_tia_rij
		"Curve of corrector factor for thr sat depending on tia in regular injection mode"
		CURVE
		0x8006352e
		RSA_RecordLayout_CURVE_UBYTE
		5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctp_it_sat_cor_tia_rij 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_cor_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_x_it_sat_cor_tia_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sens_cor
		"Cartography to convert the read position to a normalized position."
		CURVE
		0x80057d00
		RSA_RecordLayout_CURVE_UWORD
		100
		wmkbkad_wwidqld_lsCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_it_sens_cor 
    FORMAT "%12.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_it_sens_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_it_sens_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_it_sens_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_it_sens_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_it_sens_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_it_chr_psn
			wmkbkad_wwidqld_lsCArsa_f__a40a
			4
			0.
			100.
        AXIS_PTS_REF Ctb_it_sens_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_it_sp_cor
		"Cartography to adapt the position reference to the component driving convention"
		CURVE
		0x80058cb8
		RSA_RecordLayout_CURVE_UWORD
		200
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_it_sp_cor 
    FORMAT "%9.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_it_sp_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_it_sp_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_it_sp_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_it_sp_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_it_sp_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_it_psn_sp_3
			zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
			16
			-100.
			100.
        AXIS_PTS_REF Ctb_it_sp_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_1_2
		"Ctp_law_eco_1_2"
		CURVE
		0x80059738
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_2_1
		"Ctp_law_eco_2_1"
		CURVE
		0x80059722
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_2_3
		"Ctp_law_eco_2_3"
		CURVE
		0x8005970c
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_3_2
		"Ctp_law_eco_3_2"
		CURVE
		0x800596f6
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_3_4
		"Ctp_law_eco_3_4"
		CURVE
		0x800596e0
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_4_3
		"Ctp_law_eco_4_3"
		CURVE
		0x800596ca
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_4_5
		"Ctp_law_eco_4_5"
		CURVE
		0x800596b4
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_5_4
		"Ctp_law_eco_5_4"
		CURVE
		0x8005969e
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_5_6
		"Ctp_law_eco_5_6"
		CURVE
		0x80059688
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_eco_6_5
		"Ctp_law_eco_6_5"
		CURVE
		0x80059672
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_1_2
		"Ctp_law_uhil_1_2"
		CURVE
		0x8005965c
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_2_1
		"Ctp_law_uhil_2_1"
		CURVE
		0x80059646
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_2_3
		"Ctp_law_uhil_2_3"
		CURVE
		0x80059630
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_3_2
		"Ctp_law_uhil_3_2"
		CURVE
		0x8005961a
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_3_4
		"Ctp_law_uhil_3_4"
		CURVE
		0x80059604
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_4_3
		"Ctp_law_uhil_4_3"
		CURVE
		0x800595ee
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_4_5
		"Ctp_law_uhil_4_5"
		CURVE
		0x800595d8
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_5_4
		"Ctp_law_uhil_5_4"
		CURVE
		0x800595c2
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_5_6
		"Ctp_law_uhil_5_6"
		CURVE
		0x800595ac
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_uhil_6_5
		"Ctp_law_uhil_6_5"
		CURVE
		0x80059596
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_1_2
		"Ctp_law_wup_cata_1_2"
		CURVE
		0x80059580
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_2_1
		"Ctp_law_wup_cata_2_1"
		CURVE
		0x8005956a
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_2_3
		"Ctp_law_wup_cata_2_3"
		CURVE
		0x80059554
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_3_2
		"Ctp_law_wup_cata_3_2"
		CURVE
		0x8005953e
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_3_4
		"Ctp_law_wup_cata_3_4"
		CURVE
		0x80059528
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_4_3
		"Ctp_law_wup_cata_4_3"
		CURVE
		0x80059512
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_4_5
		"Ctp_law_wup_cata_4_5"
		CURVE
		0x800594fc
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_5_4
		"Ctp_law_wup_cata_5_4"
		CURVE
		0x800594e6
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_5_6
		"Ctp_law_wup_cata_5_6"
		CURVE
		0x800594d0
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_wup_cata_6_5
		"Ctp_law_wup_cata_6_5"
		CURVE
		0x800594ba
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_1_2
		"Ctp_law_xurb_1_2"
		CURVE
		0x800594a4
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_2_1
		"Ctp_law_xurb_2_1"
		CURVE
		0x8005948e
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_2_3
		"Ctp_law_xurb_2_3"
		CURVE
		0x80059478
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_3_2
		"Ctp_law_xurb_3_2"
		CURVE
		0x80059462
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_3_4
		"Ctp_law_xurb_3_4"
		CURVE
		0x8005944c
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_4_3
		"Ctp_law_xurb_4_3"
		CURVE
		0x80059436
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_4_5
		"Ctp_law_xurb_4_5"
		CURVE
		0x80059420
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_5_4
		"Ctp_law_xurb_5_4"
		CURVE
		0x8005940a
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_5_6
		"Ctp_law_xurb_5_6"
		CURVE
		0x800593f4
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_up_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_up_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_up_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_law_xurb_6_5
		"Ctp_law_xurb_6_5"
		CURVE
		0x800593de
		RSA_RecordLayout_CURVE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_down_shf_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_down_shf_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_free_shf_pdl
			VA_F_0v125_p0_6
			11
			0
			100
        AXIS_PTS_REF Ctb_down_shf_pdl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_loop_dev_fms_dg_add_cor
		"Table of correction of derivative gain depending of the TBF loop deviation"
		CURVE
		0x80044dd0
		RSA_RecordLayout_CURVE_UWORD
		6.5535
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Ctp_loop_dev_fms_dg_add_cor 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_loop_dev_fms_dg_add_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_loop_dev_fms_dg_add_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_loop_dev_fms_dg_add_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_loop_dev_fms_dg_add_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_loop_dev_fms_dg_add_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_utp_reg_loop_dev
			dFBFEab_bkAlFtb_ewgpawa_q__110a
			8
			-1200.
			1200.
        AXIS_PTS_REF Ctb_loop_dev_fms_dg_add_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_loop_dev_fms_ig_add_cor
		"Table of correction of integral gain depending of the TBF loop deviation"
		CURVE
		0x80044dc0
		RSA_RecordLayout_CURVE_UWORD
		6.5535
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Ctp_loop_dev_fms_ig_add_cor 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_loop_dev_fms_ig_add_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_loop_dev_fms_ig_add_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_loop_dev_fms_ig_add_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_loop_dev_fms_ig_add_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_loop_dev_fms_ig_add_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_utp_reg_loop_dev
			dFBFEab_bkAlFtb_ewgpawa_q__110a
			8
			-1200.
			1200.
        AXIS_PTS_REF Ctb_loop_dev_fms_ig_add_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_loop_dev_fms_pg_add_cor
		"Table of correction of proportionnal gain depending of the TBF loop deviation"
		CURVE
		0x80044db0
		RSA_RecordLayout_CURVE_UWORD
		6.5535
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Ctp_loop_dev_fms_pg_add_cor 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_loop_dev_fms_pg_add_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_loop_dev_fms_pg_add_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_loop_dev_fms_pg_add_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_loop_dev_fms_pg_add_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_loop_dev_fms_pg_add_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_utp_reg_loop_dev
			dFBFEab_bkAlFtb_ewgpawa_q__110a
			8
			-1200.
			1200.
        AXIS_PTS_REF Ctb_loop_dev_fms_pg_add_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_amp_pp
		"Curve of correction for maf depending on amp if pp mode is on"
		CURVE
		0x8006426a
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_amp_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_amp_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			16
			0.
			20000.
        AXIS_PTS_REF Ctb_x_maf_cor_amp_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_amp_pr
		"Curve of correction for maf depending on amp if pr mode is on"
		CURVE
		0x80065a86
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_amp_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			16
			0.
			20000.
        AXIS_PTS_REF Ctb_x_maf_cor_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_amp_rij
		"Curve of correction for maf depending on amp in rij mode"
		CURVE
		0x800666f4
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_amp_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			16
			0.
			20000.
        AXIS_PTS_REF Ctb_x_maf_cor_amp_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_prs_ratio_pp
		"Curve for corrective factor as a function of the back-pressure ratio in pp mode"
		CURVE
		0x8006424a
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_prs_ratio_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_prs_ratio_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_prs_ratio_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_prs_ratio_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_prs_ratio_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_prs_ratio_pp */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			16
			0.
			100.
        AXIS_PTS_REF Ctb_x_maf_cor_prs_ratio_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_prs_ratio_pr
		"Curve of corrector factor for maf depending of tia if pr mode is on"
		CURVE
		0x80065a66
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_prs_ratio_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_prs_ratio_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_prs_ratio_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_prs_ratio_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_prs_ratio_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_prs_ratio_pr */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			16
			0.
			100.
        AXIS_PTS_REF Ctb_x_maf_cor_prs_ratio_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_prs_ratio_rij
		"Curve for corrective factor as a function of the back-pressure ratio"
		CURVE
		0x800666d4
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_prs_ratio_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_prs_ratio_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_prs_ratio_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_prs_ratio_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_prs_ratio_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_prs_ratio_rij */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			16
			0.
			100.
        AXIS_PTS_REF Ctb_x_maf_cor_prs_ratio_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_tco_pp
		"Curve of correction for maf depending on tco if pp mode is on"
		CURVE
		0x8006422a
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_tco_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_tco_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_x_maf_cor_tco_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_tco_pr
		"Curve of correction for maf depending on tco if pr mode is on"
		CURVE
		0x80065a46
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_tco_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_tco_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_x_maf_cor_tco_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_tco_rij
		"Curve of correction for maf depending on tco in rij mode"
		CURVE
		0x800666b4
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_tco_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_tco_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_x_maf_cor_tco_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_tia_pp
		"Curve of corrector factor for maf depending of tia if pp mode is on"
		CURVE
		0x8006420a
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_tia_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_tia_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_cor
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_x_maf_cor_tia_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_tia_pr
		"Curve of corrector factor for maf depending of tia if pr mode is on"
		CURVE
		0x80065a26
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_tia_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_cor
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_x_maf_cor_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_tia_rij
		"Curve of corrector factor for maf depending on tia in rij mode"
		CURVE
		0x80066694
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_tia_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_cor
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_x_maf_cor_tia_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_tkof_pp
		"Curve of corrector factor for maf depending of tkof in pp mode"
		CURVE
		0x800641fe
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_tkof_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_tkof_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_fac
			ecqiCpc_DaDmwla_yczccca_n_Ra5oa
			6
			0.
			1.
        AXIS_PTS_REF Ctb_x_maf_cor_tkof_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_cor_tkof_rij
		"Curve of correction for maf depending on take off in rij mode."
		CURVE
		0x80066688
		RSA_RecordLayout_CURVE_UWORD
		10
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_maf_cor_tkof_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_fac
			ecqiCpc_DaDmwla_yczccca_n_Ra5oa
			6
			0.
			1.
        AXIS_PTS_REF Ctb_x_maf_cor_tkof_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_pft_utp_max_sp
		"Curve of upstream temp maximum setpoint value depending on mass air flow"
		CURVE
		0x8004590a
		RSA_RecordLayout_CURVE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Ctp_maf_pft_utp_max_sp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_maf_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_maf_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_maf_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_maf_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_maf_pft_utp_sp_max */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			8
			0.
			5000.
        AXIS_PTS_REF Ctb_maf_pft_utp_sp_max 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_reg_fac_pft_cor
		"Curve for corrective factor as a function of the CSF equivalent load"
		CURVE
		0x80063c2c
		RSA_RecordLayout_CURVE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_maf_reg_fac_pft_cor 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_reg_fac_pft_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_reg_fac_pft_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_reg_fac_pft_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_reg_fac_pft_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_reg_fac_pft_cor */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			16
			0.
			100.
        AXIS_PTS_REF Ctb_x_maf_reg_fac_pft_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_maf_reg_fac_tia_tco_cor
		"Curve for corrective factor as a function of tia or tco"
		CURVE
		0x80063c1c
		RSA_RecordLayout_CURVE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_maf_reg_fac_tia_tco_cor 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_reg_fac_tia_tco_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_reg_fac_tia_tco_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_reg_fac_tia_tco_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_reg_fac_tia_tco_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_reg_fac_tia_tco_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_reg_fac_tia_tco_cor
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_x_maf_reg_fac_tia_tco_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_map_fail_val_cor
		"Table for manifold air pressure fail value correction calculation"
		CURVE
		0x800576c2
		RSA_RecordLayout_CURVE_UWORD
		2
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_map_fail_val_cor 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_map_fail_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_map_fail_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_map_fail_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_map_fail_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_map_fail_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_map_fail_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_max_forc
		"Max force table for force => powertrain setpoint conversion"
		CURVE
		0x8004025c
		RSA_RecordLayout_CURVE_UWORD
		131068
		mbowslc_inojbha_jnBnagc_N__010a
		-20000.
		111068.
    DISPLAY_IDENTIFIER Ctp_max_forc 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_min_max_forc_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_min_max_forc_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_min_max_forc_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_min_max_forc_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_min_max_forc_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			9
			0.
			655.35
        AXIS_PTS_REF Ctb_min_max_forc_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_max_ftc_dyn_is_sp
		"Maximal limitation allowing to saturate the constant of time according to the gera ratio"
		CURVE
		0x8005ae16
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_max_ftc_dyn_is_sp 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_max_n_gear
		"Maximum engine speed depending on gearbox ratio"
		CURVE
		0x8005afa6
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_max_n_gear 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_max_n_tco
		"Maximum engine speed depending on coolant temperature"
		CURVE
		0x8005af86
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_max_n_tco 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_max_n_toil
		"Maximum engine speed depending on oil temperature"
		CURVE
		0x8005af66
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_max_n_toil 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nramsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_max_rams_n_dec
		"Engine speed decreasing for the safety engine speed  limitation function of the gear ratio"
		CURVE
		0x8005afca
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_max_rams_n_dec 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_max_rams_tqe_3
		"Level 3 (strong) maximum effective torque allowed function of the vehicle speed"
		CURVE
		0x800431f0
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_max_rams_tqe_3 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_max_rams_tqe_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_max_rams_tqe_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_max_rams_tqe_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_max_rams_tqe_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_max_rams_tqe_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			FfBqnda_Bdvwydd_aAwtuCb_khA_10a
			12
			0.
			255.
        AXIS_PTS_REF Ctb_max_rams_tqe_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_max_rams_tqi_1
		"Level 1 (low) maximum indicated torque allowed function of engine speed"
		CURVE
		0x800431d8
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_max_rams_tqi_1 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_max_rams_tqi_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_max_rams_tqi_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_max_rams_tqi_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_max_rams_tqi_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_max_rams_tqi_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_max_rams_tqi_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_max_rams_tqi_2
		"Level 2 (mean) maximum indicated torque allowed function of engine speed"
		CURVE
		0x800431c0
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_max_rams_tqi_2 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_max_rams_tqi_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_max_rams_tqi_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_max_rams_tqi_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_max_rams_tqi_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_max_rams_tqi_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_max_rams_tqi_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_min_forc
		"Min force table for force => powertrain setpoint conversion"
		CURVE
		0x8004024a
		RSA_RecordLayout_CURVE_UWORD
		131068
		mbowslc_inojbha_jnBnagc_N__010a
		-20000.
		111068.
    DISPLAY_IDENTIFIER Ctp_min_forc 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_min_max_forc_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_min_max_forc_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_min_max_forc_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_min_max_forc_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_min_max_forc_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			9
			0.
			655.35
        AXIS_PTS_REF Ctb_min_max_forc_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_min_tq_tco_ofs
		"Torque offset to estimate the minimum torque in idle speed zone depending of the coolant temperature."
		CURVE
		0x8005b002
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_min_tq_tco_ofs 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_min_vs_decl
		"Ctp_min_vs_decl"
		CURVE
		0x8005936e
		RSA_RecordLayout_CURVE_SWORD
		510
		VA_F_0v01_p0_10
		-255
		255
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ms_cor_inj_dist_wait_cdn
		"Table (dep of injectors distance) of soot mass correction on threshold for waiting conditions."
		CURVE
		0x80046d30
		RSA_RecordLayout_CURVE_UWORD
		500
		tupwpzd_utsbzzc_twxawbc_g__1a0a
		-250.
		250.
    DISPLAY_IDENTIFIER Ctp_ms_cor_inj_dist_wait_cdn 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_inj_dist_wait_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_inj_dist_wait_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_inj_dist_wait_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_inj_dist_wait_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_inj_dist_wait_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_inj_dist_wait_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_ex_prs_sp_max_pr
		"Exhaust pressure setpoint max limitation in pft regeneration mode"
		CURVE
		0x800602e0
		RSA_RecordLayout_CURVE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Ctp_n_ex_prs_sp_max_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_ex_prs_sp_max_rij
		"Exhaust pressure setpoint max limitation in regular injection mode"
		CURVE
		0x80060bb4
		RSA_RecordLayout_CURVE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Ctp_n_ex_prs_sp_max_rij 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_gear_tqe_max_h
		"Maximum effective torque for the high ratio"
		CURVE
		0x8004195c
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_n_gear_tqe_max_h 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_gear_tqe_max_l
		"Maximum effective torque for the low ratio"
		CURVE
		0x80041934
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_n_gear_tqe_max_l 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_n_lim_apmp_down_shf
		"Table of engine speed beyond a downshift can't be forced"
		CURVE
		0x8005923a
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		VA_F_0v25_p0_3
		0
		16383.75
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_max_tqi_pr
		"Maximum indicated torque in regeneration mode"
		CURVE
		0x8005b234
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_max_tqi_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_max_tqi_rij
		"Maximum indicated torque in normal mode"
		CURVE
		0x8005b4f6
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_max_tqi_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_n_ovh_tq_fac
		"overheat protection factor versus engine speed"
		CURVE
		0x8005b8d0
		RSA_RecordLayout_CURVE_UWORD
		0.99609375
		DmCFBja_Dhbdrld_ykkccca__A_aooa
		0.00390625
		1.
    DISPLAY_IDENTIFIER Ctp_n_ovh_tq_fac 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ovh_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ovh_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ovh_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ovh_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ovh_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			5
			0.
			16383.75
        AXIS_PTS_REF Ctb_ovh_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_diag_stt_off_pr
		"Torque threshold to switch of regulation in pft regeneration mode."
		CURVE
		0x8005ea50
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_vnt_diag_stt_off_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_diag_stt_off_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_diag_stt_off_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_diag_stt_off_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_diag_stt_off_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_diag_stt_off_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_diag_stt_off_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_diag_stt_off_rij
		"Torque threshold to switch of regulation in regular injection mode."
		CURVE
		0x8005eba2
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_vnt_diag_stt_off_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_diag_stt_off_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_diag_stt_off_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_diag_stt_off_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_diag_stt_off_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_diag_stt_off_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_diag_stt_off_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_diag_stt_on_pr
		"Torque threshold to switch on regulation in pft regeneration mode."
		CURVE
		0x8005ea3c
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_vnt_diag_stt_on_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_diag_stt_on_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_diag_stt_on_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_diag_stt_on_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_diag_stt_on_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_diag_stt_on_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_diag_stt_on_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_diag_stt_on_rij
		"Torque threshold to switch on regulation in regular injection mode"
		CURVE
		0x8005eb8e
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_vnt_diag_stt_on_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_diag_stt_on_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_diag_stt_on_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_diag_stt_on_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_diag_stt_on_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_diag_stt_on_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_diag_stt_on_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_sge_emtv_req_pp
		"Curve for VNT antisurge request value of emtv position in pp mode"
		CURVE
		0x800618ca
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctp_n_vnt_sge_emtv_req_pp 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_sge_emtv_req_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_sge_emtv_req_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_sge_emtv_req_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_sge_emtv_req_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_sge_emtv_req_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_sge_emtv_req_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_sge_emtv_req_pr
		"Curve for VNT antisurge request value of emtv position in pr mode"
		CURVE
		0x80061bba
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctp_n_vnt_sge_emtv_req_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_sge_emtv_req_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_sge_emtv_req_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_sge_emtv_req_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_sge_emtv_req_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_sge_emtv_req_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_sge_emtv_req_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_sge_emtv_req_rij
		"Curve for VNT antisurge request value of emtv position in rij mode"
		CURVE
		0x80061eaa
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctp_n_vnt_sge_emtv_req_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_sge_emtv_req_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_sge_emtv_req_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_sge_emtv_req_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_sge_emtv_req_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_sge_emtv_req_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_sge_emtv_req_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_sge_on_h_thd_pr
		"High threshold of anti-surge strategy hysteresis in pr mode"
		CURVE
		0x8005d2bc
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_vnt_sge_on_h_thd_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_n_vnt_sge_on_h_thd_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_sge_on_h_thd_rij
		"High threshold of anti-surge strategy hysteresis in rij mode"
		CURVE
		0x8005d57a
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_vnt_sge_on_h_thd_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_n_vnt_sge_on_h_thd_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_n_vnt_sge_on_h_thd_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_sge_on_l_thd_pr
		"Low threshold of anti-surge strategy hysteresis in pr mode"
		CURVE
		0x8005d2a8
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_vnt_sge_on_l_thd_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_n_vnt_sge_on_l_thd_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_n_vnt_sge_on_l_thd_rij
		"Low threshold of anti-surge strategy hysteresis in rij mode"
		CURVE
		0x8005d566
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_n_vnt_sge_on_l_thd_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_n_vnt_sge_on_l_thd_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_n_vnt_sge_on_l_thd_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ocd_dly_fct_egaf
		"Map for inert DOC model delay calculation"
		CURVE
		0x80043b92
		RSA_RecordLayout_CURVE_UBYTE
		255
		RB_CONV_AtCatDgn_Time_1s
		0.
		255.
    DISPLAY_IDENTIFIER Ctp_ocd_dly_fct_egaf 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ocd_dly_fct_egaf */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ocd_dly_fct_egaf */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ocd_dly_fct_egaf */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ocd_dly_fct_egaf */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ocd_dly_fct_egaf */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_sys_egaf
			RB_CONV_AtCatDgn_Kg_s_00001
			9
			0.
			0.65535
        AXIS_PTS_REF Ctb_ocd_dly_fct_egaf 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_ocd_t_fct_egaf
		"Map for time constant calculation in filtering of pre catalyst exhaust gas temperature"
		CURVE
		0x80043b87
		RSA_RecordLayout_CURVE_UBYTE
		255
		RB_CONV_AtCatDgn_Time_1s
		0.
		255.
    DISPLAY_IDENTIFIER Ctp_ocd_t_fct_egaf 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ocd_t_fct_egaf */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ocd_t_fct_egaf */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ocd_t_fct_egaf */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ocd_t_fct_egaf */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ocd_t_fct_egaf */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_sys_egaf
			RB_CONV_AtCatDgn_Kg_s_00001
			11
			0.
			0.65535
        AXIS_PTS_REF Ctb_ocd_t_fct_egaf 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ovn_tq_cor_ena
		"Choose to enable soft engine speed limitation for each engaged gearbox ratio"
		CURVE
		0x8005af5d
		RSA_RecordLayout_CURVE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_ovn_tq_cor_ena 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_owe_dil
		"Oil dilution effect table"
		CURVE
		0x8006b10e
		RSA_RecordLayout_CURVE_UWORD
		10
		RB_CONV_Res_001
		0
		10
    DISPLAY_IDENTIFIER Ctp_owe_dil 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_owe_oil_dil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_owe_oil_dil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_owe_oil_dil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_owe_oil_dil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_owe_oil_dil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			RB_CONV_100_65535_Prc
			8
			0.0
			100.0
        AXIS_PTS_REF Ctb_owe_oil_dil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_owe_toil
		"PWM to oil temperature conversion table"
		CURVE
		0x8006b0fe
		RSA_RecordLayout_CURVE_UWORD
		240
		RB_CONV_DegC
		-40
		200
    DISPLAY_IDENTIFIER Ctp_owe_toil 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_owe_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_owe_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_owe_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_owe_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_owe_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_owe_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_owe_toil_fac
		"Oil temperature effect table"
		CURVE
		0x8006b0ee
		RSA_RecordLayout_CURVE_UWORD
		10
		RB_CONV_Res_001
		0
		10
    DISPLAY_IDENTIFIER Ctp_owe_toil_fac 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_owe_toil_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_owe_toil_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_owe_toil_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_owe_toil_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_owe_toil_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_owe_toil_tco
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_owe_toil_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fspfzxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_pdl_cru_max_lim
		"Ctp_pdl_cru_max_lim"
		CURVE
		0x8005976e
		RSA_RecordLayout_CURVE_UWORD
		100
		VA_F_0v125_p0_6
		0
		100
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_perf_acs_dsb_max_avl_tqe
		"Cartography to compute the maximum value of maximum available torque to request accessories deactivation in performance restitution strategy"
		CURVE
		0x8005ce22
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_perf_acs_dsb_max_avl_tqe 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_amp_egaf_cor
		"Table of volumic exhaust flow correction depending on atmospheric pressure"
		CURVE
		0x80057e06
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_amp_egaf_cor 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ms_dp_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ms_dp_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ms_dp_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ms_dp_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ms_dp_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_ms_dp_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_asd_cool_n_is
		"Table of engine speed dependent on the ratio of time spent and the maximum time"
		CURVE
		0x80045d32
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		RB_CONV_rpm
		0.0
		16383.75
    DISPLAY_IDENTIFIER Ctp_pft_asd_cool_n_is 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_asd_n_is_prct */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_asd_n_is_prct */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_asd_n_is_prct */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_asd_n_is_prct */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_asd_n_is_prct */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			RB_CONV_100_255_Prc
			8
			0.0
			100.0
        AXIS_PTS_REF Ctb_pft_asd_n_is_prct 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_asd_rgn_n_is
		"Map of engine speed dependent on the ratio of time spent and the maximum time"
		CURVE
		0x80045d22
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		RB_CONV_rpm
		0.0
		16383.75
    DISPLAY_IDENTIFIER Ctp_pft_asd_rgn_n_is 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_asd_n_is_prct */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_asd_n_is_prct */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_asd_n_is_prct */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_asd_n_is_prct */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_asd_n_is_prct */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			RB_CONV_100_255_Prc
			8
			0.0
			100.0
        AXIS_PTS_REF Ctb_pft_asd_n_is_prct 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_csm_max_rgn_t
		"Maximum regeneration time depending on fuel consumption"
		CURVE
		0x80067fdc
		RSA_RecordLayout_CURVE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Ctp_pft_csm_max_rgn_t 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_max_rgn_t_csm */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_max_rgn_t_csm */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_max_rgn_t_csm */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_max_rgn_t_csm */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_max_rgn_t_csm */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm_sum_sta_drv_fil_rgn
			jnmsFhb_uzcgAAb_akuvuka_msA_10a
			6
			0.
			65535.
        AXIS_PTS_REF Ctb_pft_max_rgn_t_csm 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_csm_ms_esti
		"Table of soot mass combustion speed depending of fuel consumption"
		CURVE
		0x800468ca
		RSA_RecordLayout_CURVE_UWORD
		0.65535
		lvbmsEd_FDwmfxd_cgBjbwc_gCRa0a0
		0.
		0.65535
    DISPLAY_IDENTIFIER Ctp_pft_csm_ms_esti 
    FORMAT "%7.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_csm_sum_sta_drv_esti */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_csm_sum_sta_drv_esti */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_csm_sum_sta_drv_esti */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_csm_sum_sta_drv_esti */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_csm_sum_sta_drv_esti */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm_sum_sta_drv_ms
			jnmsFhb_uzcgAAb_akuvuka_msA_10a
			6
			0.
			65535.
        AXIS_PTS_REF Ctb_csm_sum_sta_drv_esti 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_diag_dp_min
		"Map of minimum value of differential pressure for broken diagnosis"
		CURVE
		0x80045db4
		RSA_RecordLayout_CURVE_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Ctp_pft_diag_dp_min 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_egaf_fil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_egaf_fil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_egaf_fil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_egaf_fil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_egaf_fil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_diag_egaf_fil
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			6
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_diag_egaf_fil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_diag_dp_vrnc_err_max
		"Map of maximum variance for diagnosis of broken filter"
		CURVE
		0x80045da0
		RSA_RecordLayout_CURVE_UWORD
		1
		rErCnwa_xcoFdya_Bqeaoqb_n__400a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_pft_diag_dp_vrnc_err_max 
    FORMAT "%8.6" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_diag_egaf_fil3
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			10
			0.
			255.
        AXIS_PTS_REF Ctb_pft_diag_egaf_fil3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_diag_err_step
		"Map of step value curve for broken filter detection"
		CURVE
		0x80045d8c
		RSA_RecordLayout_CURVE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_diag_err_step 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_diag_egaf_fil3
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			10
			0.
			255.
        AXIS_PTS_REF Ctb_pft_diag_egaf_fil3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_diag_ovl_step
		"Map of step value curve for overload filter detection"
		CURVE
		0x80046438
		RSA_RecordLayout_CURVE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_diag_ovl_step 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf_ind_lkg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf_ind_lkg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf_ind_lkg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf_ind_lkg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf_ind_lkg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_egaf_ind_lkg
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			10
			0.
			10.
        AXIS_PTS_REF Ctb_pft_egaf_ind_lkg 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_inj_dist_1
		"Table (dep of injectors distance) of distance correction on threshold for hot conditions."
		CURVE
		0x80047036
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_inj_dist_1 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_inj_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_inj_dist_2
		"Table (dep of injectors distance) of distance correction on threshold for cold conditions."
		CURVE
		0x8004702a
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_inj_dist_2 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_inj_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_inj_dist_3
		"Table (dep of injectors distance) of distance correction on threshold for mini conditions."
		CURVE
		0x8004701e
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_inj_dist_3 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_inj_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_inj_dist_4
		"Table (dep of injectors distance) of distance correction on threshold for medium conditions."
		CURVE
		0x80047012
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_inj_dist_4 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_inj_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_inj_dist_5
		"Table (dep of injectors distance) of distance correction on threshold for limp home conditions."
		CURVE
		0x80047006
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_inj_dist_5 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_inj_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_tia_mv_1
		"Table (dep of intake temp average value) of distance correction for hot conditions"
		CURVE
		0x80046ff6
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_tia_mv_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_tia_mv_2
		"Table (dep of intake temp average value) of distance correction for cold conditions"
		CURVE
		0x80046fe6
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_tia_mv_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_tia_mv_3
		"Table (dep of intake temp average value) of distance correction for max conditions"
		CURVE
		0x80046fd6
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_tia_mv_3 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_tia_mv_4
		"Table (dep of intake temp average value) of distance correction for medium conditions"
		CURVE
		0x80046fc6
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_tia_mv_4 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_tia_mv_5
		"Table (dep of intake temp average value) of distance correction for limp home conditions"
		CURVE
		0x80046fb6
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_tia_mv_5 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_vh_dist_1
		"Table (dep of vehicle distance) of distance correction on threshold for hot conditions."
		CURVE
		0x80046faa
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_vh_dist_1 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_vh_dist_2
		"Table (dep of vehicle distance) of distance correction on threshold for cold conditions."
		CURVE
		0x80046f9e
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_vh_dist_2 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_vh_dist_3
		"Table (dep of vehicle distance) of distance correction on threshold for mini conditions."
		CURVE
		0x80046f92
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_vh_dist_3 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_vh_dist_4
		"Table (dep of vehicle distance) of distance correction on threshold for medium conditions."
		CURVE
		0x80046f86
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_vh_dist_4 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_cor_vh_dist_5
		"Table (dep of vehicle distance) of distance correction on threshold for limp home conditions."
		CURVE
		0x80046f7a
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_cor_vh_dist_5 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_ctr_err_inj_dist
		"Table (dep on injector's distance) of distance correction to enable cold regeneration"
		CURVE
		0x80046f6e
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_ctr_err_inj_dist 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_inj_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_ctr_err_tia
		"Table (dep on average intake air temperature) of distance correction to enable cold regeneration"
		CURVE
		0x80046f5e
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_ctr_err_tia 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_err_dist_cold
		"Table (dep on vehicle mileage) of distance correction to enable cold regeneration"
		CURVE
		0x80046f52
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_err_dist_cold 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_err_dist_hot
		"Table (dep on vehicle mileage) of distance correction to enable hot regeneration"
		CURVE
		0x80046f46
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_err_dist_hot 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_err_dist_med
		"Table (dep on vehicle mileage) of distance correction to enable medium regeneration"
		CURVE
		0x80046f3a
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_err_dist_med 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_err_oil_dil_cold
		"Minimum distance since last regeneration failure in cold condition to enable regeneration in cold condition"
		CURVE
		0x80046f2a
		RSA_RecordLayout_CURVE_UWORD
		65534
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65534.
    DISPLAY_IDENTIFIER Ctp_pft_dist_err_oil_dil_cold 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_oil_dil_dist_rgn_cold */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_oil_dil_dist_rgn_cold */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_oil_dil_dist_rgn_cold */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_oil_dil_dist_rgn_cold */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_oil_dil_dist_rgn_cold */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			Edjqxvd_mqsonha_pgCaqfb_f__6o0a
			8
			0.
			100.
        AXIS_PTS_REF Ctb_pft_oil_dil_dist_rgn_cold 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_err_oil_dil_hot
		"Minimum distance since last regeneration failure in hot condition to enable regeneration in hot condition"
		CURVE
		0x80046f1a
		RSA_RecordLayout_CURVE_UWORD
		65534
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65534.
    DISPLAY_IDENTIFIER Ctp_pft_dist_err_oil_dil_hot 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_oil_dil_dist_rgn_hot */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_oil_dil_dist_rgn_hot */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_oil_dil_dist_rgn_hot */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_oil_dil_dist_rgn_hot */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_oil_dil_dist_rgn_hot */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			Edjqxvd_mqsonha_pgCaqfb_f__6o0a
			8
			0.
			100.
        AXIS_PTS_REF Ctb_pft_oil_dil_dist_rgn_hot 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_err_oil_dil_med
		"Minimum distance since last regeneration failure in medium condition to enable regeneration in medium condition"
		CURVE
		0x80046f0a
		RSA_RecordLayout_CURVE_UWORD
		65534
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65534.
    DISPLAY_IDENTIFIER Ctp_pft_dist_err_oil_dil_med 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_oil_dil_dist_rgn_med */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_oil_dil_dist_rgn_med */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_oil_dil_dist_rgn_med */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_oil_dil_dist_rgn_med */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_oil_dil_dist_rgn_med */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			Edjqxvd_mqsonha_pgCaqfb_f__6o0a
			8
			0.
			100.
        AXIS_PTS_REF Ctb_pft_oil_dil_dist_rgn_med 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_load_spd_dft_cor
		"Calibration of the multiplicative correction depending on vehicle mileage for default soot load speed"
		CURVE
		0x80046ce0
		RSA_RecordLayout_CURVE_UBYTE
		12.75
		yuEqExb_buwnyAb_Fbvbdrc_n_R0ooa
		0.
		12.75
    DISPLAY_IDENTIFIER Ctp_pft_dist_load_spd_dft_cor 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_min_inj_dist
		"Table (dep of injectors distance) of distance correction  for regeneration authorization in case of cold regeneration success."
		CURVE
		0x80046bfc
		RSA_RecordLayout_CURVE_UWORD
		65535
		jgsctCa_keuEisb_frxaDlc_kCRa37a
		-32767.
		32768.
    DISPLAY_IDENTIFIER Ctp_pft_dist_min_inj_dist 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_inj_dist_min_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_inj_dist_min_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_inj_dist_min_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_inj_dist_min_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_inj_dist_min_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_inj_dist_min_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_min_rgn_err_tia
		"Table of correction on minimum distance after last regeneration (depend. of corrected air temp)"
		CURVE
		0x80046bf0
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_min_rgn_err_tia 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_lh
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_min_tia_mv
		"Table (dep of intake temp average value) of distance correction for regeneration authorisation in case of cold regeneration success"
		CURVE
		0x80046be4
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_min_tia_mv 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_lh
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_min_vh_dist
		"Table (dep of vehicle distance) of distance correction for regeneration authorization in case of cold regeneration succes"
		CURVE
		0x80046bd8
		RSA_RecordLayout_CURVE_UWORD
		65535
		jgsctCa_keuEisb_frxaDlc_kCRa37a
		-32767.
		32768.
    DISPLAY_IDENTIFIER Ctp_pft_dist_min_vh_dist 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_vh_dist_dist_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_vh_dist_dist_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_vh_dist_dist_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_vh_dist_dist_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_vh_dist_dist_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_vh_dist_dist_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_ms_new_pft_ofs
		"Breakpoint of green effect mass offset"
		CURVE
		0x8004668e
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_dist_ms_new_pft_ofs 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_dist_ms_new_pft_ofs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_dist_ms_new_pft_ofs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_dist_ms_new_pft_ofs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_dist_ms_new_pft_ofs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_dist_ms_new_pft_ofs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			8
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_dist_ms_new_pft_ofs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_1
		"Table (dep of CSF efficacity) of distance threshold for hot conditions"
		CURVE
		0x80046efe
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_1 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_2
		"Table (dep of CSF efficacity) of distance threshold for cold conditions"
		CURVE
		0x80046ef2
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_2 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_3
		"Table (dep of CSF efficacity) of distance threshold for mini conditions"
		CURVE
		0x80046ee6
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_3 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_4
		"Table (dep of CSF efficacity) of distance threshold for medium thermal regeneration conditions"
		CURVE
		0x80046eda
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_4 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_5
		"Table of distance threshold  in case of failures to calculate the soot mass."
		CURVE
		0x80046ece
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_5 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_6
		"Table of distance threshold  in case of failures to calculate the soot mass."
		CURVE
		0x80046ec2
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_6 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_7
		"Table of distance threshold  in case of failures to calculate the soot mass."
		CURVE
		0x80046eb6
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_7 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_err_forc
		"Table (dep of CSF efficacity) of distance threshold for forced regeneration"
		CURVE
		0x80046eaa
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_err_forc 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_err_forc_inj
		"Table (dep on injector's distance) of distance correction for forced regeneration"
		CURVE
		0x80046e9e
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_err_forc_inj 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_inj_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_err_forc_tia
		"Table (dep of intake temp average value) of distance correction for forced regeneration"
		CURVE
		0x80046e8e
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_err_forc_tia 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_thd */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_rgn_err_forc_vh
		"Table (dep of vehicle distance) of distance correction on threshold for forced regeneration"
		CURVE
		0x80046e82
		RSA_RecordLayout_CURVE_UWORD
		65535
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Ctp_pft_dist_rgn_err_forc_vh 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_spd_req_inj_dist
		"Table (dep of vehicle distance) of distance correction for regeneration authorization in case of cold regeneration succes"
		CURVE
		0x80046bcc
		RSA_RecordLayout_CURVE_UWORD
		65535
		jgsctCa_keuEisb_frxaDlc_kCRa37a
		-32767.
		32768.
    DISPLAY_IDENTIFIER Ctp_pft_dist_spd_req_inj_dist 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_inj_dist_min_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_inj_dist_min_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_inj_dist_min_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_inj_dist_min_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_inj_dist_min_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_inj_dist_min_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_spd_req_oil_dil
		"Minimum distance betwen two regeneration success to activate speed request"
		CURVE
		0x80046bc0
		RSA_RecordLayout_CURVE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_dist_spd_req_oil_dil 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_dist_load_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_dist_load_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil
			Edjqxvd_mqsonha_pgCaqfb_f__6o0a
			6
			0.
			100.
        AXIS_PTS_REF Ctb_pft_dist_load_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_spd_req_tia
		"Table (dep of intake temp average value) of distance correction for speed request authorization"
		CURVE
		0x80046bb4
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_dist_spd_req_tia 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_lh
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_spd_req_vh_dist
		"Table (dep of vehicle distance) of distance correction for speed request authorization"
		CURVE
		0x80046ba8
		RSA_RecordLayout_CURVE_UWORD
		65535
		jgsctCa_keuEisb_frxaDlc_kCRa37a
		-32767.
		32768.
    DISPLAY_IDENTIFIER Ctp_pft_dist_spd_req_vh_dist 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_vh_dist_dist_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_vh_dist_dist_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_vh_dist_dist_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_vh_dist_dist_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_vh_dist_dist_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_vh_dist_dist_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_dist_wait_req_min_ms
		"Calibration of minimum soot mass necessary to enable wait mode activation request (depending on vehicle distance)"
		CURVE
		0x800470e8
		RSA_RecordLayout_CURVE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_pft_dist_wait_req_min_ms 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_efi_itl_cp
		"Material calorific capacity"
		CURVE
		0x800582ae
		RSA_RecordLayout_CURVE_UWORD
		6553.5
		AdDehAb_CvnCEyd_wAFgpib_Jp__10a
		0.
		6553.5
    DISPLAY_IDENTIFIER Ctp_pft_efi_itl_cp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efi_itl_cp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efi_itl_cp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efi_itl_cp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efi_itl_cp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efi_itl_cp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_efi_itl_ar_temp
			dFjxvqb_bnBujga_oeusmlb_K__an3a
			6
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_efi_itl_cp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_efi_pwm_cor
		"Table of correction for efi injector cycling opening percentage depending on efi fuel relative pres"
		CURVE
		0x80058dce
		RSA_RecordLayout_CURVE_UWORD
		655.35
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_efi_pwm_cor 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efi_prs_pwm_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efi_prs_pwm_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efi_prs_pwm_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efi_prs_pwm_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efi_prs_pwm_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efi_fuel_rel_prs
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_pft_efi_prs_pwm_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_efy_driv_dist_prct
		"Table of particulate filter efficiencies due to driven distance"
		CURVE
		0x80058070
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctp_pft_efy_driv_dist_prct 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_efy_driv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_efy_driv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_efy_driv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_efy_driv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_efy_driv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			8
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_efy_driv 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_efy_max_ms_sta_swi
		"Table of maximum soot mass in the filter at the exit of charging state to activate variable setpoint"
		CURVE
		0x800458fe
		RSA_RecordLayout_CURVE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_pft_efy_max_ms_sta_swi 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_reg
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_egaf_tt_efi_int
		"Table of internal thermal convection for exhaust fuel injector enthalpy calculation depending on exhaust gas air flow and temperature"
		CURVE
		0x8005829a
		RSA_RecordLayout_CURVE_UWORD
		65535
		ydcnqBd_xAtpyCa_aAbyxwb_1_A_1oa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_egaf_tt_efi_int 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf_tt_efi_int */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf_tt_efi_int */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf_tt_efi_int */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf_tt_efi_int */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf_tt_efi_int */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_egaf_tt_efi_int
			ykmzBoa_nqupBma_Ffvbarc_m_R0ooa
			10
			0.
			6553.5
        AXIS_PTS_REF Ctb_pft_egaf_tt_efi_int 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ehr_cal_cpy1
		"Table of pft ehr substratum calorific capacity depending on ehr substratum temperature"
		CURVE
		0x80046a66
		RSA_RecordLayout_CURVE_UWORD
		65535
		Bchijab_hrievac_jkutjFc_JgCRa0a
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_ehr_cal_cpy1 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			8
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_cal_cpy_ehr_itl_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ehr_cal_cpy2
		"Table of pft ehr substratum calorific capacity depending on ehr substratum temperature"
		CURVE
		0x80046a56
		RSA_RecordLayout_CURVE_UWORD
		65535
		Bchijab_hrievac_jkutjFc_JgCRa0a
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_ehr_cal_cpy2 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			8
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_cal_cpy_ehr_itl_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ehr_cal_cpy3
		"Table of pft ehr substratum calorific capacity depending on ehr substratum temperature"
		CURVE
		0x80046a46
		RSA_RecordLayout_CURVE_UWORD
		65535
		Bchijab_hrievac_jkutjFc_JgCRa0a
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_ehr_cal_cpy3 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			8
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_cal_cpy_ehr_itl_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ehr_rgn_spd1
		"Table of pft ehr of soot combustion speed 1."
		CURVE
		0x80046a0a
		RSA_RecordLayout_CURVE_UWORD
		0.65535
		apzCdoc_Baddesb_cgxmbwc_1CRa0a0
		0.
		0.65535
    DISPLAY_IDENTIFIER Ctp_pft_ehr_rgn_spd1 
    FORMAT "%7.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ehr_clc_dtp_dly1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ehr_clc_dtp_dly1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ehr_clc_dtp_dly1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ehr_clc_dtp_dly1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ehr_clc_dtp_dly1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_ehr_clc_dtp1_dly
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			30
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_ehr_clc_dtp_dly1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ehr_rgn_spd2
		"Table of pft ehr of soot combustion speed 2."
		CURVE
		0x800469ce
		RSA_RecordLayout_CURVE_UWORD
		0.65535
		apzCdoc_Baddesb_cgxmbwc_1CRa0a0
		0.
		0.65535
    DISPLAY_IDENTIFIER Ctp_pft_ehr_rgn_spd2 
    FORMAT "%7.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ehr_clc_dtp_dly2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ehr_clc_dtp_dly2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ehr_clc_dtp_dly2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ehr_clc_dtp_dly2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ehr_clc_dtp_dly2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_ehr_clc_dtp2_dly
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			30
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_ehr_clc_dtp_dly2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ehr_rgn_spd3
		"Table of pft ehr of soot combustion speed 3."
		CURVE
		0x80046992
		RSA_RecordLayout_CURVE_UWORD
		0.65535
		apzCdoc_Baddesb_cgxmbwc_1CRa0a0
		0.
		0.65535
    DISPLAY_IDENTIFIER Ctp_pft_ehr_rgn_spd3 
    FORMAT "%7.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ehr_clc_dtp_dly3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ehr_clc_dtp_dly3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ehr_clc_dtp_dly3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ehr_clc_dtp_dly3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ehr_clc_dtp_dly3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_ehr_clc_dtp3_dly
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			30
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_ehr_clc_dtp_dly3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ex_gaz_cal_cpy1
		"Table of pft ehr gas calorific capacity depending on ehr upstream gas temperature"
		CURVE
		0x80046982
		RSA_RecordLayout_CURVE_UWORD
		65535
		Bchijab_hrievac_jkutjFc_JgCRa0a
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_ex_gaz_cal_cpy1 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			8
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_cal_cpy_ehr_itl_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ex_gaz_cal_cpy2
		"Table of pft ehr gas calorific capacity depending on ehr upstream gas temperature"
		CURVE
		0x80046972
		RSA_RecordLayout_CURVE_UWORD
		65535
		Bchijab_hrievac_jkutjFc_JgCRa0a
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_ex_gaz_cal_cpy2 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			8
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_cal_cpy_ehr_itl_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ex_gaz_cal_cpy3
		"Table of pft ehr gas calorific capacity depending on ehr upstream gas temperature"
		CURVE
		0x80046962
		RSA_RecordLayout_CURVE_UWORD
		65535
		Bchijab_hrievac_jkutjFc_JgCRa0a
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_pft_ex_gaz_cal_cpy3 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_cal_cpy_ehr_itl_temp */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			8
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_cal_cpy_ehr_itl_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ext_cnvt_fac
		"Table of pft ehr external convection coefficient depending on vehicle speed"
		CURVE
		0x80046952
		RSA_RecordLayout_CURVE_UWORD
		6553.5
		awthFuc_dFDnrqd_ufrCFpb_Js__aa0
		0.
		6553.5
    DISPLAY_IDENTIFIER Ctp_pft_ext_cnvt_fac 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ext_cnvt_fac_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ext_cnvt_fac_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ext_cnvt_fac_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ext_cnvt_fac_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ext_cnvt_fac_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			8
			0.
			655.35
        AXIS_PTS_REF Ctb_pft_ext_cnvt_fac_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_fac_egaf_sot_esti
		"Table of volumic flow correction for soot estimation"
		CURVE
		0x80057dd9
		RSA_RecordLayout_CURVE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Ctp_pft_fac_egaf_sot_esti 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_sot_esti */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_sot_esti */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_sot_esti */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_sot_esti */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_sot_esti */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_sot_esti 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_fac_sot_esti
		"Table of factors to apply on CSF internal temperature for soot mass combustion speed estimation"
		CURVE
		0x800468c2
		RSA_RecordLayout_CURVE_UBYTE
		2.54
		yxobnfa_FlrsAhb_sEheatb_n__1o7a
		-1.27
		1.27
    DISPLAY_IDENTIFIER Ctp_pft_fac_sot_esti 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_delta_temp_fil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_delta_temp_fil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_delta_temp_fil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_delta_temp_fil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_delta_temp_fil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_delta_temp_fil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			7
			-40.
			1200.
        AXIS_PTS_REF Ctb_pft_delta_temp_fil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_inj_dist_load_spd_dft
		"calibration of default soot load speed depending on injectors distance"
		CURVE
		0x80046cda
		RSA_RecordLayout_CURVE_UBYTE
		0.348
		tqfnykb_zrjpzpb_cvihkvb_gC_o00a
		0.002
		0.35
    DISPLAY_IDENTIFIER Ctp_pft_inj_dist_load_spd_dft 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_inj_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_min_ms_spd_req_err
		"Table of particulate filter minimum soot mass to activate the speed request if rgn failure exceeded"
		CURVE
		0x80046e76
		RSA_RecordLayout_CURVE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_pft_min_ms_spd_req_err 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_min_rgn_df_val_t
		"Maximum regeneration time"
		CURVE
		0x80067fd0
		RSA_RecordLayout_CURVE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Ctp_pft_min_rgn_df_val_t 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_min_rgn_df_val_t */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_min_rgn_df_val_t */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_min_rgn_df_val_t */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_min_rgn_df_val_t */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_min_rgn_df_val_t */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_vs_fil
			uEardjb_BFoibqb_vkamstb_khA_00a
			6
			0.
			655.35
        AXIS_PTS_REF Ctb_pft_min_rgn_df_val_t 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_comb
		"Soot mass threshold for status of combusted soot mass."
		CURVE
		0x80067fc4
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_ms_comb 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_ms_comb */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_ms_comb */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_ms_comb */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_ms_comb */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_ms_comb */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_comb
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_ms_comb 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_dist_rgn_forc
		"Table (dep of vehicle distance) of soot mass correction on threshold for forced regeneration"
		CURVE
		0x80046e6a
		RSA_RecordLayout_CURVE_UWORD
		500
		tupwpzd_utsbzzc_twxawbc_g__1a0a
		-250.
		250.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_dist_rgn_forc 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
