		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007340 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_pump_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007340 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_virt_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_virt_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_virt_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_virt_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_wire_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_wire_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_wire_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_wire_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_wire_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_wire_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_wire_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_wire_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_wfl_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_wfl_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_wfl_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_wfl_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_clc_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_clc_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_clc_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_clc_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_fail.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007352 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_fail.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007352 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_fail.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007352 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_fail.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007352 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_supl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007332 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_supl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007332 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_supl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007332 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sfty_tq_supl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007332 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_cmd_blk_clos.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007354 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_cmd_blk_clos.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007354 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_cmd_blk_clos.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007354 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_cmd_blk_clos.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007354 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_reg_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_reg_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_reg_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_reg_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_reg_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_reg_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_reg_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_spg_reg_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbf_fct_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbf_fct_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbf_fct_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbf_fct_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbf_fct_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbf_fct_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbf_fct_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbf_fct_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007210 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007210 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007210 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007210 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007212 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007212 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007212 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007212 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007214 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007214 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007214 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007214 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_reg_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_reg_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_reg_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_reg_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_reg_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007216 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_reg_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007216 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_reg_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007216 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tbt_reg_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007216 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007218 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007218 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007218 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007218 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd1_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000721e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007220 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007220 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007220 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007220 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007222 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007222 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007222 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd2_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007222 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007224 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007224 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007224 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007224 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007226 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007226 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007226 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007226 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007228 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007228 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007228 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_thpl_cmd3_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007228 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tqi_cor_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007312 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tqi_cor_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007312 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tqi_cor_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007312 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_tqi_cor_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007312 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl1_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl1_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl1_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl1_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl2_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl2_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl2_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl2_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl3_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl3_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl3_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl3_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000728e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl4_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007290 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl4_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007290 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl4_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007290 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl4_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007290 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007288 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007288 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007288 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_unk_thpl_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007288 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000733a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_itl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007338 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_itl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007338 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_itl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007338 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_itl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007338 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007336 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007336 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007336 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ecu_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007336 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ro2_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007324 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ro2_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007324 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ro2_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007324 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ro2_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007324 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007326 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007326 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007326 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007326 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_tip_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007328 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_tip_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007328 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_tip_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007328 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_tip_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007328 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_uo2_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007334 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_uo2_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007334 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_uo2_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007334 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ups_uo2_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007334 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_rly_oc_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_rly_oc_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_rly_oc_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_rly_oc_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000722e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_rly_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007230 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_rly_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007230 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_rly_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007230 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vb_rly_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007230 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vnt_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vnt_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vnt_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vnt_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vnt_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vnt_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vnt_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_vnt_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007292 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007292 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007292 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007292 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007294 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007294 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007294 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007294 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007296 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007296 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007296 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_wpmp_tcr_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007296 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c4f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_seq_ctr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_seq_ctr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c55 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_seq_ctr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_no_frm.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_no_frm.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c5b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_no_frm.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_no_frm.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_no_frm.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_no_frm.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_no_frm.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_esp_no_frm.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_no_lk.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_no_lk.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c61 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_no_lk.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c67 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_clos.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_clos.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e59 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_clos.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_open.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_open.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e5f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_open.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_down.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_down.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_down.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_up.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_up.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e65 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_up.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_ovh.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_ovh.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_ovh.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007094 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007099 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007096 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007098 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007098 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007098 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007098 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007098 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_h_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_h_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e6b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_h_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_l_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_l_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e71 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_l_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_neg_err.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_neg_err.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e77 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_neg_err.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_pos_err.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_pos_err.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e7d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_pos_err.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_clos.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_clos.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e83 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_clos.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_open.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_open.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e89 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_open.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_down.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_down.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_down.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_up.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_up.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e8f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_up.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_ovh.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_ovh.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070db 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_ovh.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f7f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_dirt_lkg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_dirt_lkg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_dirt_lkg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_h_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_h_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_h_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_l_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_l_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_l_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_neg_err.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_neg_err.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_neg_err.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_pos_err.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ea8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_pos_err.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ead 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_pos_err.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eaa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_down.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007082 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_down.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007087 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_down.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007084 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007086 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007086 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007086 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007086 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007086 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_up.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007088 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_up.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000708d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_up.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000708a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000708c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000708c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000708c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000708c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000708c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_h_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000708e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_h_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007093 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_h_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007090 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007092 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007092 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007092 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007092 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007092 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ddc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_fail.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_fail.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_fail.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f1f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_crk_cmp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_crk_cmp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f25 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_crk_cmp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_cyc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007046 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_cyc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000704b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_cyc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007048 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000704a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000704a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000704a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000704a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000704a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_no_sig.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_no_sig.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f2b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_no_sig.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007040 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007045 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007042 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007044 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007044 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007044 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007044 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_in_cam_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007044 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_chk_sum.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_chk_sum.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_chk_sum.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_crt_intv.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_crt_intv.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_crt_intv.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_puls.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_puls.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_puls.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_puls.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006faa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_puls.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006faf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_puls.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c7f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_shp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_shp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fbb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_shp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_shp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_shp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_shp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj1_shp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_chk_sum.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_chk_sum.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ebf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_chk_sum.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ebc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ebe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ebe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ebe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ebe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ebe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_crt_intv.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_crt_intv.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_crt_intv.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_puls.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_puls.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_puls.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fcd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_puls.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_puls.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_puls.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c85 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_shp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_shp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fdf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_shp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_shp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_shp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_shp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj2_shp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_chk_sum.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_chk_sum.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ecb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_chk_sum.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ec8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_crt_intv.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ecc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_crt_intv.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_crt_intv.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ece 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_puls.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_puls.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006feb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_puls.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fe8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006fee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_puls.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_puls.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_puls.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ff8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ffd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ffa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ffc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ffc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ffc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ffc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ffc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_shp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ffe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_shp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007003 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_shp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007000 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_shp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007002 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_shp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007002 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_shp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007002 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007002 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj3_shp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007002 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_chk_sum.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_chk_sum.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_chk_sum.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
