/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_dirt.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056674
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_emtv_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_esp_data_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056669
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_esp_data_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_esp_data_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056668
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_esp_data_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_esp_data_seq_ctr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005665d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_esp_data_seq_ctr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_esp_data_seq_ctr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005665c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_esp_data_seq_ctr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_esp_no_frm.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056651
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_esp_no_frm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_esp_no_frm.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056650
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_esp_no_frm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_no_lk.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056645
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ex_prs_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_no_lk.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056642
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ex_prs_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_no_lk.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056646
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ex_prs_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_no_lk.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056644
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ex_prs_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_no_lk.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056644
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ex_prs_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_no_lk.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056644
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ex_prs_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056639
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ex_prs_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056636
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ex_prs_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005663a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ex_prs_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056638
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ex_prs_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056638
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ex_prs_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ex_prs_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056638
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ex_prs_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_clos.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056255
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_clos.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056252
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_clos.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056256
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_clos.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056254
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_clos.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056254
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_clos.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056254
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_open.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056249
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_open.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056246
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_open.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005624a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056248
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_open.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056248
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056248
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_down.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056021
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_down.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005601e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_down.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056022
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_down.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056020
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_down.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056020
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_down.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056020
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_up.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005623d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_up.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005623a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_up.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005623e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_up.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005623c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_up.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005623c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_crt_up.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005623c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_ovh.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d5d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_ovh.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d5a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_ovh.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d5e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d5c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_ovh.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d5c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_actr_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d5c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055dd5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055dd2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055dd6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055dd4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055dd4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055dd4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_h_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056231
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_h_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005622e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_h_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056232
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056230
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_h_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056230
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056230
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_l_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056225
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_l_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056222
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_l_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056226
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056224
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_l_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056224
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056224
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_neg_err.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056219
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_neg_err.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056216
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_neg_err.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005621a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_neg_err.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056218
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_neg_err.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056218
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056218
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_pos_err.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005620d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ff_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_pos_err.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005620a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ff_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_pos_err.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005620e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ff_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_pos_err.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005620c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ff_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_pos_err.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005620c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ff_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ff_fct_pos_err.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005620c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ff_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_clos.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056201
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_clos.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800561fe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_clos.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056202
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_clos.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056200
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_clos.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056200
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_clos.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056200
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_actr_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_open.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800561f5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_open.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800561f2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_open.Cxx_obd_dc_xxx
		""
		VALUE
		0x800561f6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800561f4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_open.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800561f4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800561f4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_actr_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_down.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056015
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_down.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056012
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_down.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056016
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_down.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056014
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_down.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056014
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_down.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056014
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_actr_crt_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_up.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800561e9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_up.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800561e6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_up.Cxx_obd_dc_xxx
		""
		VALUE
		0x800561ea
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_up.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800561e8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_up.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800561e8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_crt_up.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800561e8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_actr_crt_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_ovh.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d51
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_ovh.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d4e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_ovh.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d52
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d50
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_ovh.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d50
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_actr_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d50
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_actr_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056009
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056006
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005600a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056008
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056008
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056008
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_fct_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_dirt_lkg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800561dd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_dirt_lkg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800561da
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_dirt_lkg.Cxx_obd_dc_xxx
		""
		VALUE
		0x800561de
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800561dc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800561dc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800561dc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_h_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800561d1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_h_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800561ce
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_h_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x800561d2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800561d0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_h_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800561d0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800561d0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_fct_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_l_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800561c5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_l_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800561c2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_l_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x800561c6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800561c4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_l_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800561c4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800561c4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_fct_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_neg_err.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800561b9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_neg_err.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800561b6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_neg_err.Cxx_obd_dc_xxx
		""
		VALUE
		0x800561ba
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_neg_err.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800561b8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_neg_err.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800561b8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800561b8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_fct_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_pos_err.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800561ad
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fprs_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_pos_err.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800561aa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fprs_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_pos_err.Cxx_obd_dc_xxx
		""
		VALUE
		0x800561ae
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fprs_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_pos_err.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800561ac
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fprs_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_pos_err.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800561ac
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fprs_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fprs_fct_pos_err.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800561ac
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fprs_fct_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_down.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055df9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fsys_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_down.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055df6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fsys_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_down.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055dfa
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fsys_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_down.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055df8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fsys_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_down.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055df8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fsys_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055df8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fsys_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_up.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ded
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fsys_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_up.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055dea
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fsys_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_up.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055dee
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fsys_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_up.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055dec
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fsys_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_up.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055dec
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fsys_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055dec
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fsys_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_h_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055de1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fsys_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_h_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055dde
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fsys_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_h_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055de2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fsys_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055de0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fsys_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_h_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055de0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fsys_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fsys_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055de0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fsys_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056339
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fuel_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056336
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fuel_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005633a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fuel_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056338
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fuel_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056338
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fuel_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056338
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fuel_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056345
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fuel_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056342
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_fuel_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056346
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_fuel_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056344
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_fuel_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056344
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_fuel_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_fuel_temp_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056344
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_fuel_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_fail.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055fd9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_glow_cmd_fail 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_fail.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055fd6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_glow_cmd_fail 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_fail.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055fda
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_glow_cmd_fail 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_fail.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055fd8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_glow_cmd_fail 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_fail.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055fd8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_glow_cmd_fail 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_fail.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055fd8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_glow_cmd_fail 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005662d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_glow_cmd_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005662a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_glow_cmd_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005662e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_glow_cmd_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005662c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_glow_cmd_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005662c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_glow_cmd_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005662c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_glow_cmd_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056621
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_glow_cmd_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005661e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_glow_cmd_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056622
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_glow_cmd_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056620
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_glow_cmd_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056620
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_glow_cmd_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056620
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_glow_cmd_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056615
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_glow_cmd_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056612
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_glow_cmd_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056616
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_glow_cmd_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056614
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_glow_cmd_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056614
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_glow_cmd_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_glow_cmd_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056614
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_glow_cmd_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800560c9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_in_cam_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800560c6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_in_cam_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x800560ca
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_in_cam_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800560c8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_in_cam_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800560c8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_in_cam_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800560c8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_in_cam_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_crk_cmp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800560bd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_in_cam_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_crk_cmp.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800560ba
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_in_cam_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_crk_cmp.Cxx_obd_dc_xxx
		""
		VALUE
		0x800560be
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_in_cam_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_crk_cmp.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800560bc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_in_cam_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_crk_cmp.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800560bc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_in_cam_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_crk_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800560bc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_in_cam_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_cyc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e71
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_in_cam_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_cyc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e6e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_in_cam_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_cyc.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e72
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_in_cam_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_cyc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e70
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_in_cam_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_cyc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e70
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_in_cam_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_cyc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e70
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_in_cam_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_no_sig.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800560b1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_in_cam_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_no_sig.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800560ae
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_in_cam_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_no_sig.Cxx_obd_dc_xxx
		""
		VALUE
		0x800560b2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_in_cam_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_no_sig.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800560b0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_in_cam_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_no_sig.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800560b0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_in_cam_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_no_sig.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800560b0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_in_cam_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e7d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_in_cam_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e7a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_in_cam_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e7e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_in_cam_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e7c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_in_cam_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e7c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_in_cam_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_in_cam_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e7c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_in_cam_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_chk_sum.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800561a1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj1_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_chk_sum.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005619e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj1_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_chk_sum.Cxx_obd_dc_xxx
		""
		VALUE
		0x800561a2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj1_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_chk_sum.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800561a0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj1_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_chk_sum.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800561a0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj1_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_chk_sum.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800561a0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj1_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_crt_intv.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056195
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj1_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_crt_intv.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056192
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj1_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_crt_intv.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056196
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj1_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_crt_intv.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056194
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj1_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_crt_intv.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056194
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj1_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_crt_intv.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056194
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj1_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055fcd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj1_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055fca
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj1_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055fce
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj1_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055fcc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj1_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055fcc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj1_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055fcc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj1_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_puls.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055fc1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj1_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_puls.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055fbe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj1_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_puls.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055fc2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj1_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_puls.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055fc0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj1_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_puls.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055fc0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj1_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_h_puls.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055fc0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj1_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055fb5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj1_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055fb2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj1_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055fb6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj1_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055fb4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj1_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055fb4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj1_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055fb4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj1_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_puls.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055fa9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj1_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_puls.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055fa6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj1_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_puls.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055faa
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj1_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_puls.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055fa8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj1_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_puls.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055fa8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj1_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055fa8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj1_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f9d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj1_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f9a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj1_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f9e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj1_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f9c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj1_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f9c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj1_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f9c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj1_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056609
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056606
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005660a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056608
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056608
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056608
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_shp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f91
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj1_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_shp.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f8e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj1_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_shp.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f92
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj1_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_shp.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f90
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj1_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_shp.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f90
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj1_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj1_shp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f90
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj1_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_chk_sum.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056189
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj2_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_chk_sum.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056186
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj2_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_chk_sum.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005618a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj2_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_chk_sum.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056188
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj2_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_chk_sum.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056188
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj2_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_chk_sum.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056188
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj2_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_crt_intv.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005617d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj2_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_crt_intv.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005617a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj2_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_crt_intv.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005617e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj2_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_crt_intv.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005617c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj2_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_crt_intv.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005617c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj2_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_crt_intv.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005617c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj2_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f85
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj2_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f82
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj2_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f86
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj2_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f84
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj2_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f84
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj2_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f84
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj2_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_puls.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f79
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj2_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_puls.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f76
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj2_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_puls.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f7a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj2_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_puls.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f78
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj2_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_puls.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f78
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj2_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_h_puls.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f78
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj2_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f6d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj2_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f6a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj2_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f6e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj2_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f6c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj2_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f6c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj2_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f6c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj2_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_puls.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f61
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj2_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_puls.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f5e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj2_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_puls.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f62
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj2_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_puls.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f60
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj2_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_puls.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f60
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj2_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f60
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj2_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f55
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj2_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f52
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj2_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f56
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj2_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f54
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj2_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f54
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj2_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f54
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj2_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800565fd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800565fa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x800565fe
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800565fc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800565fc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800565fc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_shp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f49
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj2_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_shp.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f46
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj2_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_shp.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f4a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj2_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_shp.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f48
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj2_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_shp.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f48
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj2_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj2_shp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f48
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj2_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_chk_sum.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056171
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj3_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_chk_sum.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005616e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj3_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_chk_sum.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056172
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj3_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_chk_sum.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056170
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj3_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_chk_sum.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056170
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj3_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_chk_sum.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056170
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj3_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_crt_intv.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056165
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj3_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_crt_intv.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056162
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj3_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_crt_intv.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056166
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj3_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_crt_intv.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056164
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj3_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_crt_intv.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056164
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj3_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_crt_intv.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056164
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj3_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f3d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj3_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f3a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj3_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f3e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj3_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f3c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj3_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f3c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj3_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f3c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj3_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_puls.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f31
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj3_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_puls.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f2e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj3_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_puls.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f32
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj3_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_puls.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f30
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj3_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_puls.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f30
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj3_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_h_puls.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f30
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj3_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f25
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj3_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f22
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj3_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f26
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj3_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f24
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj3_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f24
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj3_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f24
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj3_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_puls.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f19
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj3_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_puls.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f16
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj3_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_puls.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f1a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj3_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_puls.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f18
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj3_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_puls.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f18
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj3_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f18
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj3_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f0d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj3_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055f0a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj3_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f0e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj3_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f0c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj3_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f0c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj3_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f0c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj3_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800565f1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800565ee
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x800565f2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800565f0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800565f0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800565f0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_shp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055f01
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj3_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_shp.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055efe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj3_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_shp.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055f02
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj3_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_shp.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055f00
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj3_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_shp.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055f00
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj3_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj3_shp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055f00
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj3_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_chk_sum.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056159
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj4_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_chk_sum.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056156
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj4_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_chk_sum.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005615a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj4_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_chk_sum.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056158
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj4_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_chk_sum.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056158
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj4_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_chk_sum.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056158
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj4_chk_sum 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_crt_intv.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005614d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj4_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_crt_intv.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005614a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj4_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_crt_intv.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005614e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj4_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_crt_intv.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005614c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj4_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_crt_intv.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005614c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj4_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_crt_intv.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005614c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj4_crt_intv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ef5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj4_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055ef2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj4_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055ef6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj4_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ef4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj4_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ef4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj4_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ef4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj4_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_puls.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ee9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj4_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_puls.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055ee6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj4_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_puls.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055eea
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj4_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_puls.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ee8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj4_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_puls.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ee8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj4_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_h_puls.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ee8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj4_h_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055edd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj4_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055eda
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj4_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055ede
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj4_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055edc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj4_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055edc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj4_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055edc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj4_l_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_puls.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ed1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj4_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_puls.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055ece
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj4_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_puls.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055ed2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj4_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_puls.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ed0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj4_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_puls.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ed0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj4_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ed0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj4_l_puls 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ec5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj4_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055ec2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj4_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055ec6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj4_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ec4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj4_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ec4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj4_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ec4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj4_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800565e5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj4_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800565e2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj4_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x800565e6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj4_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800565e4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj4_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800565e4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj4_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800565e4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj4_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_shp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055eb9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj4_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_shp.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055eb6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj4_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_shp.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055eba
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj4_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_shp.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055eb8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj4_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_shp.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055eb8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj4_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj4_shp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055eb8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj4_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_cpt_blk.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d69
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_cpt_blk.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d66
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_cpt_blk.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d6a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_cpt_blk.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d68
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_cpt_blk.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d68
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_cpt_blk.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d68
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_oor.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e41
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_inj_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_oor.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e3e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_inj_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_oor.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e42
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_inj_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_oor.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e40
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_inj_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_oor.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e40
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_inj_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_inj_oor.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e40
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_inj_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ip_lght_tco_ovh.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ead
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ip_lght_tco_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ip_lght_tco_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055eac
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ip_lght_tco_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_el.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800565d9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_it_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_el.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800565d6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_it_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_el.Cxx_obd_dc_xxx
		""
		VALUE
		0x800565da
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_it_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_el.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800565d8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_it_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_el.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800565d8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_it_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_el.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800565d8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_it_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_ovh.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800565cd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_it_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_ovh.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800565ca
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_it_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_ovh.Cxx_obd_dc_xxx
		""
		VALUE
		0x800565ce
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_it_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800565cc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_it_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_ovh.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800565cc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_it_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_hbdg_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800565cc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_it_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_ofs_no_norm.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800565c1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_it_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_ofs_no_norm.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800565be
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_it_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_ofs_no_norm.Cxx_obd_dc_xxx
		""
		VALUE
		0x800565c2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_it_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_ofs_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800565c0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_it_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_ofs_no_norm.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800565c0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_it_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_ofs_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800565c0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_it_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800565b5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_it_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800565b2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_it_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk.Cxx_obd_dc_xxx
		""
		VALUE
		0x800565b6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_it_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800565b4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_it_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800565b4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_it_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800565b4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_it_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_clos.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800565a9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_it_reg_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_clos.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800565a6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_it_reg_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_clos.Cxx_obd_dc_xxx
		""
		VALUE
		0x800565aa
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_it_reg_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_clos.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800565a8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_it_reg_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_clos.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800565a8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_it_reg_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_clos.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800565a8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_it_reg_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_open.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005659d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_it_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_open.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005659a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_it_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_open.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005659e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_it_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005659c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_it_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_open.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005659c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_it_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005659c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_it_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_dirt.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056591
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_it_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_dirt.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005658e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_it_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_dirt.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056592
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_it_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_dirt.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056590
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_it_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_dirt.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056590
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_it_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_it_reg_dirt.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056590
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_it_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_maf_reg_neg_err.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056585
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_maf_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_maf_reg_neg_err.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056582
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_maf_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_maf_reg_neg_err.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056586
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_maf_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_maf_reg_neg_err.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056584
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_maf_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_maf_reg_neg_err.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056584
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_maf_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_maf_reg_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056584
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_maf_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_down.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c55
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_mafs_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_down.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055c52
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_mafs_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_down.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055c56
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_mafs_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_down.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055c54
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_mafs_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_down.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055c54
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_mafs_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c54
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_mafs_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_up.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c49
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_mafs_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_up.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055c46
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_mafs_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_up.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055c4a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_mafs_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_up.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055c48
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_mafs_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_up.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055c48
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_mafs_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_mafs_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c48
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_mafs_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_map_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ea1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_map_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_map_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e9e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_map_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_map_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055ea2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_map_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_map_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ea0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_map_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_map_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ea0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_map_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_map_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ea0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_map_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_oil_dil_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c3d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_oil_dil_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_oil_dil_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c3c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_oil_dil_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056579
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056576
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pft_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005657a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pft_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056578
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pft_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056578
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pft_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056578
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt_lkg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005656d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt_lkg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005656a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pft_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt_lkg.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005656e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pft_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005656c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pft_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005656c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pft_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005656c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_no_lk.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056561
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_no_lk.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005655e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pft_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_no_lk.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056562
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pft_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_no_lk.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056560
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pft_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_no_lk.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056560
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pft_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_no_lk.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056560
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_no_lk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_nok_cge.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e11
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_nok_cge.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e0e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pft_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_nok_cge.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e12
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pft_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_nok_cge.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e10
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pft_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_nok_cge.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e10
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pft_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_nok_cge.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e10
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_rgn_dirt.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c31
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_rgn_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_rgn_dirt.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c30
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_rgn_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056555
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056552
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pft_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056556
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pft_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056554
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pft_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056554
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pft_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056554
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056549
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056546
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pft_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005654a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pft_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056548
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pft_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056548
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pft_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056548
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005653d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005653a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pft_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005653e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pft_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005653c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pft_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005653c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pft_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005653c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_neg_err.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056531
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_utp_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056530
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_utp_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_pos_err.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056525
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pft_utp_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pft_utp_pos_err.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056524
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pft_utp_pos_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056519
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pws_1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056516
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pws_1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005651a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pws_1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056518
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pws_1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056518
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pws_1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056518
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pws_1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005650d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pws_1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005650a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pws_1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005650e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pws_1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005650c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pws_1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005650c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pws_1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_1_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005650c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pws_1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056501
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pws_2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800564fe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pws_2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056502
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pws_2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056500
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pws_2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056500
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pws_2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056500
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pws_2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800564f5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pws_2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800564f2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pws_2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x800564f6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pws_2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800564f4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pws_2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800564f4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pws_2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_2_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800564f4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pws_2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800564e9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pws_3_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800564e6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pws_3_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x800564ea
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pws_3_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800564e8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pws_3_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800564e8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pws_3_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800564e8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pws_3_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800564dd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_pws_3_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800564da
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_pws_3_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x800564de
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_pws_3_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800564dc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_pws_3_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800564dc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_pws_3_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_pws_3_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800564dc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_pws_3_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056309
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_rail_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056306
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_rail_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005630a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_rail_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056308
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_rail_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056308
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_rail_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056308
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_rail_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h_lvl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056321
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_rail_prs_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h_lvl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005631e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_rail_prs_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h_lvl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056322
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_rail_prs_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056320
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_rail_prs_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h_lvl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056320
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_rail_prs_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056320
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_rail_prs_h_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056315
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_rail_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056312
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_rail_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056316
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_rail_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056314
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_rail_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056314
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_rail_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056314
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_rail_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_plaus.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005632d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_rail_prs_plaus 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_plaus.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005632a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_rail_prs_plaus 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_plaus.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005632e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_rail_prs_plaus 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_plaus.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005632c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_rail_prs_plaus 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_plaus.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005632c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_rail_prs_plaus 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_plaus.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005632c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_rail_prs_plaus 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_sig_mcut.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800562fd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_rail_prs_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_sig_mcut.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800562fa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_rail_prs_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_sig_mcut.Cxx_obd_dc_xxx
		""
		VALUE
		0x800562fe
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_rail_prs_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_sig_mcut.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800562fc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_rail_prs_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_sig_mcut.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800562fc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_rail_prs_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rail_prs_sig_mcut.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800562fc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_rail_prs_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_dirt_lkg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056051
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_rup_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_dirt_lkg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005604e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_rup_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_dirt_lkg.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056052
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_rup_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056050
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_rup_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056050
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_rup_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056050
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_rup_dirt_lkg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056045
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_rup_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056042
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_rup_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056046
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_rup_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056044
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_rup_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056044
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_rup_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_rup_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056044
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_rup_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800564d1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_amp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800564ce
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_amp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x800564d2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_amp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800564d0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_amp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800564d0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_amp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800564d0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_amp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800564c5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_amp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800564c2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_amp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x800564c6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_amp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800564c4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_amp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800564c4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_amp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_amp_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800564c4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_amp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c6d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_egr_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055c6a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_egr_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055c6e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_egr_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055c6c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_egr_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055c6c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_egr_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c6c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_egr_temp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c61
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_egr_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055c5e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_egr_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055c62
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_egr_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055c60
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_egr_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055c60
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_egr_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_egr_temp_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c60
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_egr_temp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_emtv_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800564b9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_emtv_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_emtv_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800564b6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_emtv_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_emtv_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x800564ba
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_emtv_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_emtv_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800564b8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_emtv_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_emtv_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800564b8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_emtv_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_emtv_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800564b8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_emtv_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800564ad
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ex_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800564aa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ex_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x800564ae
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ex_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800564ac
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ex_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800564ac
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ex_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800564ac
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ex_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800564a1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ex_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005649e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ex_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x800564a2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ex_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800564a0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ex_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800564a0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ex_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ex_prs_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800564a0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ex_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_it_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056495
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_it_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_it_nok.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056492
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_it_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_it_nok.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056496
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_it_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_it_nok.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056494
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_it_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_it_nok.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056494
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_it_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_it_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056494
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_it_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056489
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_maf_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056486
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_maf_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005648a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_maf_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056488
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_maf_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056488
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_maf_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056488
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_maf_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005647d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_maf_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005647a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_maf_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005647e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_maf_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005647c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_maf_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005647c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_maf_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_maf_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005647c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_maf_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056471
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_map_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005646e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_map_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056472
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_map_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056470
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_map_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056470
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_map_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056470
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_map_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056465
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_map_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056462
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_map_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056466
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_map_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056464
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_map_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056464
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_map_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_map_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056464
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_map_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005605d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_rup_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005605a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_rup_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005605e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_rup_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005605c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_rup_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005605c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_rup_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005605c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_rup_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056069
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_rup_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056066
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_rup_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005606a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_rup_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056068
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_rup_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056068
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_rup_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_rup_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056068
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_rup_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056459
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_tco_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056456
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_tco_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005645a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_tco_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056458
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_tco_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056458
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_tco_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056458
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_tco_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005644d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_tco_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005644a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_tco_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005644e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_tco_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005644c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_tco_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005644c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_tco_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005644c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_tco_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_sig_mcut.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d75
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_tco_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_sig_mcut.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d72
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_tco_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_sig_mcut.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d76
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_tco_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_sig_mcut.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d74
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_tco_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_sig_mcut.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d74
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_tco_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tco_sig_mcut.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d74
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_tco_sig_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056441
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_tia_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005643e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_tia_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056442
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_tia_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056440
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_tia_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056440
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_tia_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056440
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_tia_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056435
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_tia_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056432
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_tia_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056436
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_tia_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056434
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_tia_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056434
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_tia_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_tia_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056434
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_tia_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055cd9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ups_heat_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055cd6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ups_heat_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055cda
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ups_heat_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055cd8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ups_heat_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055cd8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ups_heat_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055cd8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ups_heat_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_ovh.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ccd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ups_heat_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_ovh.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055cca
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ups_heat_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_ovh.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055cce
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ups_heat_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ccc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ups_heat_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_ovh.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ccc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ups_heat_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ccc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ups_heat_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055cc1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ups_heat_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055cbe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ups_heat_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055cc2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ups_heat_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055cc0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ups_heat_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055cc0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ups_heat_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055cc0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ups_heat_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055cb5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
