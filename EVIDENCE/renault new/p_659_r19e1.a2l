      DDRC_DurDeb.IVActr_numVltgSRCMinDebOk_C DDRC_DurDeb.IVActr_numVltgSRCMinDebDef_C DDRC_DurDeb.LSU_numDynChkMinDebOk_C DDRC_DurDeb.LSU_numDynChkMinDebDef_C DDRC_DurDeb.IVActr_numEnrgNplDebOk_C DDRC_DurDeb.IVActr_numEnrgNplDebDef_C
      DDRC_DurDeb.LSU_numO2PlausMaxFLdDebOk_C DDRC_DurDeb.LSU_numO2PlausMaxFLdDebDef_C DDRC_DurDeb.LSU_numO2PlausMinPartLdDebOk_C DDRC_DurDeb.LSU_numO2PlausMinPartLdDebDef_C DDRC_DurDeb.LSU_numO2ClbMinDebOk_C DDRC_DurDeb.LSU_numO2ClbMinDebDef_C
      DDRC_DurDeb.LSU_numRiClbMinDebOk_C DDRC_DurDeb.LSU_numRiClbMinDebDef_C DDRC_DurDeb.IVDia_numCylShCirDebOk_C DDRC_DurDeb.IVDia_numCylShCirDebDef_C DDRC_DurDeb.IVDia_numBnkShCirDebOk_C DDRC_DurDeb.IVDia_numBnkShCirDebDef_C
      DDRC_DurDeb.IVCtl_numTiDiffOBDDebOk_C DDRC_DurDeb.IVCtl_numTiDiffOBDDebDef_C DDRC_DurDeb.IVActr_numUChSRCMaxDebOk_C DDRC_DurDeb.IVActr_numUChSRCMaxDebDef_C DDRC_DurDeb.LSU_numO2PlausMaxPartLdDebOk_C DDRC_DurDeb.LSU_numO2PlausMaxPartLdDebDef_C
      DDRC_DurDeb.IVCtl_numUUpOBDDebOk_C DDRC_DurDeb.IVCtl_numUUpOBDDebDef_C DDRC_DurDeb.LSU_numTempCompMinDebOk_C DDRC_DurDeb.LSU_numTempCompMinDebDef_C DDRC_DurDeb.IVDia_numCylNoClsDebOk_C DDRC_DurDeb.IVDia_numCylNoClsDebDef_C
      DDRC_DurDeb.LSU_numPresCompMaxDebOk_C DDRC_DurDeb.LSU_numPresCompMaxDebDef_C DDRC_DurDeb.IVActr_numVltgSRCMaxDebOk_C DDRC_DurDeb.IVActr_numVltgSRCMaxDebDef_C DDRC_DurDeb.LSU_numO2PlausMaxOvrRunDebOk_C DDRC_DurDeb.LSU_numO2PlausMaxOvrRunDebDef_C
      DDRC_DurDeb.LSU_numWireIPSigDebOk_C DDRC_DurDeb.LSU_numWireIPSigDebDef_C DDRC_DurDeb.IVDia_numCylShCirHSLSDebOk_C DDRC_DurDeb.IVDia_numCylShCirHSLSDebDef_C DDRC_DurDeb.LSU_numDynChkDIUMPRMinDebOk_C DDRC_DurDeb.LSU_numDynChkDIUMPRMinDebDef_C
      DDRC_DurDeb.PCV_numNoStrtDebOk_C DDRC_DurDeb.PCV_numNoStrtDebDef_C DDRC_DurDeb.IVActr_numUChSRCMinDebOk_C DDRC_DurDeb.IVActr_numUChSRCMinDebDef_C DDRC_DurDeb.LSU_numO2PlausMinFLdDebOk_C DDRC_DurDeb.LSU_numO2PlausMinFLdDebDef_C
      DDRC_DurDeb.IVDia_numBnkShCirChSwtDebOk_C DDRC_DurDeb.IVDia_numBnkShCirChSwtDebDef_C DDRC_DurDeb.LSU_numO2PlausMinOvrRunDebOk_C DDRC_DurDeb.LSU_numO2PlausMinOvrRunDebDef_C DDRC_DurDeb.LSU_numRiClbMaxDebOk_C DDRC_DurDeb.LSU_numRiClbMaxDebDef_C
      DDRC_DurDeb.IVCtl_numUDiffUpOBDDebOk_C DDRC_DurDeb.IVCtl_numUDiffUpOBDDebDef_C DDRC_DurDeb.IVDia_numChpDebOk_C DDRC_DurDeb.IVDia_numChpDebDef_C DDRC_DurDeb.Rail_tiMeUn2DebOk_C DDRC_DurDeb.Rail_tiMeUn2DebDef_C
      DDRC_DurDeb.Rail_tiMeUn4DebOk_C DDRC_DurDeb.Rail_tiMeUn4DebDef_C DDRC_DurDeb.R2S2_tiCommErrorDebOk_C DDRC_DurDeb.R2S2_tiCommErrorDebDef_C DDRC_DurDeb.Rail_tiMeUn0DebOk_C DDRC_DurDeb.Rail_tiMeUn0DebDef_C
      DDRC_DurDeb.MonUMaxSupply1DebOk_C DDRC_DurDeb.MonUMaxSupply1DebDef_C DDRC_DurDeb.SSpMon2DebOk_C DDRC_DurDeb.SSpMon2DebDef_C DDRC_DurDeb.Rail_tiMeUn3DebOk_C DDRC_DurDeb.Rail_tiMeUn3DebDef_C
      DDRC_DurDeb.Rail_tiPCV4DebOk_C DDRC_DurDeb.Rail_tiPCV4DebDef_C DDRC_DurDeb.SSpMon3DebOk_C DDRC_DurDeb.SSpMon3DebDef_C DDRC_DurDeb.Rail_tiPCV1DebOk_C DDRC_DurDeb.Rail_tiPCV1DebDef_C
      DDRC_DurDeb.Rail_tiMeUn1DebOk_C DDRC_DurDeb.Rail_tiMeUn1DebDef_C DDRC_DurDeb.CY320_tiSpiCommErrorDebOk_C DDRC_DurDeb.CY320_tiSpiCommErrorDebDef_C DDRC_DurDeb.Rail_tiPCV3DebOk_C DDRC_DurDeb.Rail_tiPCV3DebDef_C
      DDRC_DurDeb.Rail_tiCPC4DebOk_C DDRC_DurDeb.Rail_tiCPC4DebDef_C DDRC_DurDeb.Rail_tiPCV2DebOk_C DDRC_DurDeb.Rail_tiPCV2DebDef_C DDRC_DurDeb.Rail_tiCPC3DebOk_C DDRC_DurDeb.Rail_tiCPC3DebDef_C
      DDRC_DurDeb.SSpMon1DebOk_C DDRC_DurDeb.SSpMon1DebDef_C DDRC_DurDeb.Rail_tiPCV0DebOk_C DDRC_DurDeb.Rail_tiPCV0DebDef_C DDRC_DurDeb.MonUMinSupply1DebOk_C DDRC_DurDeb.MonUMinSupply1DebDef_C
      DDRC_DurDeb.Rail_tiCPC1DebOk_C DDRC_DurDeb.Rail_tiCPC1DebDef_C DDRC_DurDeb.ETClb_numETFltMinDebOk_C DDRC_DurDeb.ETClb_numETFltMinDebDef_C DDRC_DurDeb.ETClb_numETFltMaxDebOk_C DDRC_DurDeb.ETClb_numETFltMaxDebDef_C
      DDRC_DurDeb.LSU_numHtCoupSigDebOk_C DDRC_DurDeb.LSU_numHtCoupSigDebDef_C
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    DDVlv_DD
    ""

    /begin DEF_CHARACTERISTIC
      HCIVlv_Pwm.tiPer_C HCIVlv_Pwm.stLvl_C HCIVlv_Pwm.rMaxDty_C HCIVlv_Pwm.rPerUn_C HCIVlv_Pwm.tiPh_C HCIVlv_PwmOut.rMin_C
      HCIVlv_PwmOut.rMax_C HCIVlv_PwmOut.tiBtwTstSCB_C HCIVlv_PwmOut.tiBtwTstOT_C HCIVlv_PwmOut.numTstMax_C HCIVlv_PwmOut.swtBattCor_C HCIVlv_PwmOut.swtPsInv_C
      HCIVlv_stPsDiaDisbl_C HCIVlv_stPsDisbl_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_facCor DevLib_stPwrStgEnaCond HCIVlv_r
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      HCIVlv_rPs
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DevLib_4WinDia
    ""


/end FUNCTION

/begin FUNCTION

    DevLib_ActrPrt
    ""

    /begin DEF_CHARACTERISTIC
      DevLib_nActrRls_C DevLib_tiActrPrt_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st Epm_nEng GlwCtl_stGlw
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      DevLib_stMonActrPrt
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DevLib_DiaCtlLine
    ""


/end FUNCTION

/begin FUNCTION

    DevLib_DigOut
    ""


/end FUNCTION

/begin FUNCTION

    DevLib_DigOutErrHndlr
    ""

    /begin DEF_CHARACTERISTIC
      DevLib_DigOutDbgSig_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      DevLib_stDigOutErr_mp DevLib_stDigOutPrevTst_mp DevLib_stDigOutTstImp_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DevLib_HBrg
    ""


/end FUNCTION

/begin FUNCTION

    DevLib_MacroDef
    ""


/end FUNCTION

/begin FUNCTION

    DevLib_PhysRngChk
    ""


/end FUNCTION

/begin FUNCTION

    DevLib_PsDiag
    ""


/end FUNCTION

/begin FUNCTION

    DevLib_PwmOut
    ""


/end FUNCTION

/begin FUNCTION

    DevLib_PWMOutErrHndlr
    ""

    /begin DEF_CHARACTERISTIC
      DevLib_PWMOutDbgSig_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      DevLib_stPWMOutErr_mp DevLib_stPWMOutPrevTst_mp DevLib_stPWMOutTstImp_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DevLib_PwrStgState
    ""

    /begin DEF_CHARACTERISTIC
      Devlib_PsDisbl.facLowHysLo_C Devlib_PsDisbl.facLowHysHi_C Devlib_PsDisbl.facHighHysLo_C Devlib_PsDisbl.facHighHysHi_C Devlib_PwrStg.BattLoHysLo_C Devlib_PwrStg.BattLoHysHi_C
      Devlib_PwrStg.BattHiHysLo_C Devlib_PwrStg.BattHiHysHi_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_facCor BattU_u MoCSOP_stRdy MoCSOP_stRdyMsg SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      DevLib_stPwrStgEnaCond
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DevLib_SRC
    ""


/end FUNCTION

/begin FUNCTION

    DevLib_TransStage
    ""


/end FUNCTION

/begin FUNCTION

    DewDet_HtrRls
    ""

    /begin DEF_CHARACTERISTIC
      DewDet_cpGs_C DewDet_dmPlsThresLSUSrvTst_CA DewDet_dmPlsThresLSU_CA DewDet_facCldStrtLSU0_CUR DewDet_facPlsLSUSrvTst_CA DewDet_facPlsLSU_CA
      DewDet_facPlsThresLSU_CA DewDet_facThresNoSftyFac_CA DewDet_numEngTempStrt_C DewDet_numLSU_CA DewDet_numMaxCldStrt_CA DewDet_numPipeIdx1_CA
      DewDet_numPipeIdx2_CA DewDet_numPlsSrvTst_CA DewDet_swtDewDetShOff_CA DewDet_tiDebLSU_CA DewDet_tiDebRunTransOk_C DewDet_tiHtgDelLSU_CA
      DewDet_tIntegIniSrvTst_CA DewDet_tIntegIni_CA DewDet_tiPlsLSUSrvTst_CA DewDet_tiPlsLSU_CA DewDet_tThresLSUActSrvTst_CA DewDet_tThresLSUAct_CA
      DewDet_tWtEquiv_CA DewDet_wLSUIKi_CA DewDet_wThresLSU0_MAP
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      ASMod_dmEGFld ASMod_tEGFld ASMod_tPipeStrt ASMod_tWallFld CoEng_st CoES_stAVSCoLSU
      EngDa_tFld
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      DewDet_ctCldStrtLSU_mp DewDet_ctPlsLSUSrvTst_mp DewDet_dmEG_mp DewDet_dwLSU_mp DewDet_facCldStrtLSU_mp DewDet_stDewDetTstDem_mp
      DewDet_stEEPWrite_mp DewDet_stHtgLSULstTrp_mp DewDet_stHtgThresLSUHit_mp DewDet_stIntegIni_mp DewDet_stPlsLSU_mp DewDet_stShOff_mp
      DewDet_tEG_mp DewDet_tEngStrt_mp DewDet_tIntegIniSel_mp DewDet_tPipeMinIdx_mp DewDet_tPipeMin_mp DewDet_tWallLSUInpCrv0_mp
      DewDet_tWall_mp DewDet_wLSU_mp DewDet_wThresLSUAct_mp DewDet_wThresLSUNoPls_mp DewDet_wThresLSUPls_mp DewDet_wThresLSU_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DE_Adapt
    ""

    /begin DEF_CHARACTERISTIC
      GlbDa_lDrvWhlCirc_C HCUn_dqDem_C HCUn_stInjOn_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      AirC_rClgDem CACDsT_t GlbDa_lDrvWhlCirc
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    dfc_auto
    ""


/end FUNCTION

/begin FUNCTION

    DgDgtDas_Msgdiag
    ""

    /begin IN_MEASUREMENT
      Epm_numCyl
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      DgDgtDas_DIDFD00 DgDgtDas_DIDFD20 DgDgtDas_DIDFD40 DgDgtDas_DIDFD60 DgDgtDas_DIDFD80 DgDgtDas_DIDFDA0
      DgDgtDas_DIDFDC0 DgDgtDas_DIDFDE0 DgDgtDas_DIDFE00 DgDgtDas_DIDFE20
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DgDgtDas_Schxxxx
    ""

    /begin SUB_FUNCTION
      DgDgtDas_Msgdiag
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    DgDgtMos_Tacmngx
    ""

    /begin DEF_CHARACTERISTIC
      Tac_cal_set_rb_22.Cxx_tac_tini_io_xx Tac_cal_set_rb_22.Cxx_tac_ton_io_xx Tac_cal_set_rb_22.Cxx_tac_toff_io_xx Tac_cal_set_rb_22.Cxx_tac_tini_stac_xx Tac_cal_set_rb_22.Cxx_tac_ton_stac_xx Tac_cal_set_rb_22.Cxx_tac_toff_stac_xx
      Tac_cal_set_rb_22.Cxx_tac_dcycon_io_xx Tac_cal_set_rb_22.Cxx_tac_dcycoff_io_xx Tac_cal_set_rb_22.Cxx_tac_dcycon_stac_xx Tac_cal_set_rb_22.Cxx_tac_dcycoff_stac_xx Tac_cal_set_rb_22.Cxx_tac_nc_io_xx Tac_cal_set_rb_23.Cxx_tac_tini_io_xx
      Tac_cal_set_rb_23.Cxx_tac_ton_io_xx Tac_cal_set_rb_23.Cxx_tac_toff_io_xx Tac_cal_set_rb_23.Cxx_tac_tini_stac_xx Tac_cal_set_rb_23.Cxx_tac_ton_stac_xx Tac_cal_set_rb_23.Cxx_tac_toff_stac_xx Tac_cal_set_rb_23.Cxx_tac_dcycon_io_xx
      Tac_cal_set_rb_23.Cxx_tac_dcycoff_io_xx Tac_cal_set_rb_23.Cxx_tac_dcycon_stac_xx Tac_cal_set_rb_23.Cxx_tac_dcycoff_stac_xx Tac_cal_set_rb_23.Cxx_tac_nc_io_xx
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      SyC_stSub
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DgDgtRpg_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_prg_appl_key_stt
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DgDgtRpg_Mngerxx
    ""

    /begin OUT_MEASUREMENT
      Vbx_prg_appl_key_stt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vxx_prg_appl_key
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DgDgtRpg_Schxxxx
    ""

    /begin SUB_FUNCTION
      DgDgtRpg_Mngerxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    DgEcuDft_Ecuhwfm
    ""

    /begin OUT_MEASUREMENT
      Vsx_ecm_inj_2_vld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_ecm_err_itl Vbx_df_ecm_err_no_norm Vbx_df_ecm_inj_cpt_blk Vbx_df_ecm_inj_no_norm
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DgEcuDft_Ex
    ""

    /begin IN_MEASUREMENT
      Vsx_ecm_inj_2_vld
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DgEcuDft_Schxxxx
    ""

    /begin SUB_FUNCTION
      DgEcuDft_Ecuhwfm
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    DgEcuSaf_Dataxxx
    ""

    /begin IN_MEASUREMENT
      Mo_stICODiagMsg Mo_stRstDiagMsg
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_df_ecm_mon_secu_1
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_ecm_mon_secu_2
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DgEcuSaf_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_ecm_mon_secu_1 Vbx_df_ecm_mon_secu_2 Vsx_ecm_mon_vld
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DgEcuSaf_Resetxx
    ""

    /begin LOC_MEASUREMENT
      MoFRST_stRstMsg
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DgEcuSaf_Schxxxx
    ""

    /begin SUB_FUNCTION
      DgEcuSaf_Dataxxx DgEcuSaf_Resetxx DgEcuSaf_Sfthwfm
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    DgEcuSaf_Sfthwfm
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_dfdec_ecm_mon_secu_1 Cxx_dfdec_ecm_mon_secu_2 Cxx_dfinc_ecm_mon_secu_1 Cxx_dfinc_ecm_mon_secu_2
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Mo_stICOMsg
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vsx_ecm_mon_vld
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    diagapplinf_chkmemaccess
    ""


/end FUNCTION

/begin FUNCTION

    diagapplinf_clcchecksum
    ""


/end FUNCTION

/begin FUNCTION

    diagapplinf_prog
    ""

    /begin DEF_CHARACTERISTIC
      DiagApplInf_tPrgThres_C DiagApplInf_vPrgThres_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng VehV_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    diagapplinf_readecuid
    ""

    /begin DEF_CHARACTERISTIC
      DiagApplInf_ECUId.dMRP_CA DiagApplInf_ECUId.dDIC_CA DiagApplInf_ECUId.dSuppITG_CA DiagApplInf_ECUId.dHWNo_CA DiagApplInf_ECUId.dSWNo_CA DiagApplInf_ECUId.dEdNo_CA
      DiagApplInf_ECUId.dCalNo_CA DiagApplInf_ECUId.dOthSys_CA
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    diagapplinf_traceability
    ""


/end FUNCTION

/begin FUNCTION

    DiagAppl_Std
    ""

    /begin DEF_CHARACTERISTIC
      Diag_stOBDPtcol_C
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    DiagComAppl_Std
    ""


/end FUNCTION

/begin FUNCTION

    DiagCom_Distrib
    ""


/end FUNCTION

/begin FUNCTION

    Diag_Session
    ""


/end FUNCTION

/begin FUNCTION

    Diag_Util
    ""


/end FUNCTION

/begin FUNCTION

    dinh_auto
    ""

    /begin DEF_CHARACTERISTIC
      DINH_DSQ.FId_InhibitAlways_CA DINH_DSQ.FId_CoordALS_CA DINH_DSQ.FId_CoordFBC_CA DINH_DSQ.FId_CoordTAA_CA DINH_DSQ.FId_CoordZFC_CA DINH_DSQ.FId_IVPlausRunUpTstActv_CA
      DINH_DSQ.FId_RailHpTstActv_CA DINH_DSQ.FId_AFSPlOffsDrft_CA DINH_DSQ.FId_AFSSRC_CA DINH_DSQ.FId_AFSTPer_CA DINH_DSQ.FId_APP1SigPath_CA DINH_DSQ.FId_APP2SigPath_CA
      DINH_DSQ.FId_ASModPipe_CA DINH_DSQ.FId_ASModPipeSlw_CA DINH_DSQ.FId_ASModPresCalc_CA DINH_DSQ.FId_ASModStrt_CA DINH_DSQ.FId_ASModSwtOffEng_CA DINH_DSQ.FId_ASModTrbn_CA
      DINH_DSQ.FId_AdcIADC0_CA DINH_DSQ.FId_Cic751Dev1_CA DINH_DSQ.FId_CoEngNrml2Strt_CA DINH_DSQ.FId_CoEngPthClsEGR_CA DINH_DSQ.FId_CoEngPthClsThr_CA DINH_DSQ.FId_CoEngPthCylOff_CA
      DINH_DSQ.FId_CoEngPthETZr_CA DINH_DSQ.FId_CoEngPthFlQnt_CA DINH_DSQ.FId_CoEngPthInjVlvOff_CA DINH_DSQ.FId_CoEngPthLpSysOff_CA DINH_DSQ.FId_CoEngPthRPMin_CA DINH_DSQ.FId_CoEngPthTrqZr_CA
      DINH_DSQ.FId_CoEngSoftShOff_CA DINH_DSQ.FId_DevLibActrPrt_CA DINH_DSQ.FId_DewDetHtgDel_CA DINH_DSQ.FId_DewDetstSrvTstDem_CA DINH_DSQ.FId_EGRVlvJamVlv_CA DINH_DSQ.FId_ETClbCorActv_CA
      DINH_DSQ.FId_EpmBCr_CA DINH_DSQ.FId_EpmCaSAdapCaSI1_CA DINH_DSQ.FId_EpmCaSDiag_CA DINH_DSQ.FId_EpmCaSOfsDiagCaSI1_CA DINH_DSQ.FId_EpmCaSOfsErrCaSI1_CA DINH_DSQ.FId_EpmCaSSegCor_CA
      DINH_DSQ.FId_EpmCrSDiag_CA DINH_DSQ.FId_EpmCrSDiagVeh_CA DINH_DSQ.FId_EpmOpMode_InjLock_CA DINH_DSQ.FId_FBC_CA DINH_DSQ.FId_FMALamO2Valid_CA DINH_DSQ.FId_FMASwtOff1_CA
      DINH_DSQ.FId_FMASwtOff3_CA DINH_DSQ.FId_FlSysDens_CA DINH_DSQ.FId_FlSysTnkLoEEP_CA DINH_DSQ.FId_FlSysTnkLoInfo_CA DINH_DSQ.FId_FuelTCTS_CA DINH_DSQ.FId_FuelTFlSys_CA
      DINH_DSQ.FId_FuelTFrzVal_CA DINH_DSQ.FId_FuelTFrzValB1_CA DINH_DSQ.FId_FuelTReplVal_CA DINH_DSQ.FId_GlwCtl1_CA DINH_DSQ.FId_GlwCtl2_CA DINH_DSQ.FId_GlwCtl3_CA
      DINH_DSQ.FId_GlwPlgCod_CA DINH_DSQ.FId_GlwPlgGCUTDia_CA DINH_DSQ.FId_IVActrTempRplVal_CA DINH_DSQ.FId_IVAdjNVCEna_CA DINH_DSQ.FId_IVDiaCylOKTst_CA DINH_DSQ.FId_IVDiaTst_CA
      DINH_DSQ.FId_IVPSplyDCDCOff_CA DINH_DSQ.FId_IVPlausComprTst_CA DINH_DSQ.FId_IVPlausRunUpTst_CA DINH_DSQ.FId_InhibitNever_CA DINH_DSQ.FId_InjUnStrtPlsBlk_CA DINH_DSQ.FId_InjVlvBnk0ShutOff_CA
      DINH_DSQ.FId_InjVlvCyl0ShutOff_CA DINH_DSQ.FId_InjVlvCyl1ShutOff_CA DINH_DSQ.FId_InjVlvCyl2ShutOff_CA DINH_DSQ.FId_InjVlvCyl3ShutOff_CA DINH_DSQ.FId_InjVlvCyl4ShutOff_CA DINH_DSQ.FId_InjVlvCyl5ShutOff_CA
      DINH_DSQ.FId_InjVlvPrep_CA DINH_DSQ.FId_InjVlvPresMin_CA DINH_DSQ.FId_InjVlvPresMinRun_CA DINH_DSQ.FId_InjVlvPresMinStrt_CA DINH_DSQ.FId_LSUAdap0_CA DINH_DSQ.FId_LSUClbSched_CA
      DINH_DSQ.FId_LSUCmpChk0_CA DINH_DSQ.FId_LSUCtl0_CA DINH_DSQ.FId_LSUDewRls0_CA DINH_DSQ.FId_LSUDynChk0_CA DINH_DSQ.FId_LSUHtCoup0_CA DINH_DSQ.FId_LSUHtrPS0_CA
      DINH_DSQ.FId_LSUIPOpnLdTst0_CA DINH_DSQ.FId_LSUIsolChk0_CA DINH_DSQ.FId_LSULoBatt0_CA DINH_DSQ.FId_LSUMon0_CA DINH_DSQ.FId_LSUO20_CA DINH_DSQ.FId_LSUO2Clb0_CA
      DINH_DSQ.FId_LSUO2SRC0_CA DINH_DSQ.FId_LSUPlausChk0_CA DINH_DSQ.FId_LSUPresComp0_CA DINH_DSQ.FId_LSUPresCompAdap0_CA DINH_DSQ.FId_LSURi0_CA DINH_DSQ.FId_LSURiClb0_CA
      DINH_DSQ.FId_LSUShCir0_CA DINH_DSQ.FId_LSUUNVGOpnLdTst0_CA DINH_DSQ.FId_LSUlsu0_CA DINH_DSQ.FId_MeUnActrTst_CA DINH_DSQ.FId_MeUnFrzI_CA DINH_DSQ.FId_MeUnRot_CA
      DINH_DSQ.FId_MeUnSetPTst_CA DINH_DSQ.FId_PCVActrTst_CA DINH_DSQ.FId_PCVFrzI_CA DINH_DSQ.FId_PCVNoStrt_CA DINH_DSQ.FId_PCVPwrStgTst_CA DINH_DSQ.FId_PCVSetPTst_CA
      DINH_DSQ.FId_QWCCTSDef_CA DINH_DSQ.FId_QWCFTSDef_CA DINH_DSQ.FId_QWCOff_CA DINH_DSQ.FId_RailCPCtlMeUnMode_CA DINH_DSQ.FId_RailCPCtlPCVMode_CA DINH_DSQ.FId_RailCtlMode_CA
      DINH_DSQ.FId_RailHpTst_CA DINH_DSQ.FId_RailMeUn0Blk_CA DINH_DSQ.FId_RailMeUn0Rls_CA DINH_DSQ.FId_RailMeUn1Blk_CA DINH_DSQ.FId_RailMeUn1Rls_CA DINH_DSQ.FId_RailMeUn22Rls_CA
      DINH_DSQ.FId_RailMeUn2Blk_CA DINH_DSQ.FId_RailMeUn2Rls_CA DINH_DSQ.FId_RailMeUn3Blk_CA DINH_DSQ.FId_RailMeUn3Rls_CA DINH_DSQ.FId_RailMeUn4Blk_CA DINH_DSQ.FId_RailMeUn4Rls_CA
      DINH_DSQ.FId_RailMeUnClsdShutOff_CA DINH_DSQ.FId_RailMeUnCtlMode_CA DINH_DSQ.FId_RailMeUnCtlUpLim_CA DINH_DSQ.FId_RailPCV0Blk_CA DINH_DSQ.FId_RailPCV0Rls_CA DINH_DSQ.FId_RailPCV1Blk_CA
      DINH_DSQ.FId_RailPCV1Rls_CA DINH_DSQ.FId_RailPCV2Blk_CA DINH_DSQ.FId_RailPCV2Rls_CA DINH_DSQ.FId_RailPCV3Blk_CA DINH_DSQ.FId_RailPCV3Rls_CA DINH_DSQ.FId_RailPCV4Blk_CA
      DINH_DSQ.FId_RailPCV4Rls_CA DINH_DSQ.FId_RailPCVCtlMode_CA DINH_DSQ.FId_RailPCVCtlUpLim_CA DINH_DSQ.FId_RailPSS_CA DINH_DSQ.FId_RailPSubsVal_CA DINH_DSQ.FId_RailSetPointLim_CA
      DINH_DSQ.FId_RailSetPointRed_CA DINH_DSQ.FId_RailSetPointTst_CA DINH_DSQ.FId_RailTnkLo_CA DINH_DSQ.FId_SSTEGRClrDs_CA DINH_DSQ.FId_TAA_CA DINH_DSQ.FId_TEGRClrDsFrzVal_CA
      DINH_DSQ.FId_TEGRClrDsRplVal_CA DINH_DSQ.FId_ThrVlvOpnLd_CA DINH_DSQ.FId_TrbChPmp_CA DINH_DSQ.FId_ZFCClbActv_CA DINH_DSQ.FId_ZFCCldCmbCham_CA DINH_DSQ.FId_ZFCPCLClbActv_CA
      DINH_DSQ.FId_stAVSCoESLSU_CA DINH_SbxCf.FId_InhibitAlways_CA DINH_SbxCf.FId_CoordALS_CA DINH_SbxCf.FId_CoordFBC_CA DINH_SbxCf.FId_CoordTAA_CA DINH_SbxCf.FId_CoordZFC_CA
      DINH_SbxCf.FId_IVPlausRunUpTstActv_CA DINH_SbxCf.FId_RailHpTstActv_CA DINH_SbxCf.FId_AFSPlOffsDrft_CA DINH_SbxCf.FId_AFSSRC_CA DINH_SbxCf.FId_AFSTPer_CA DINH_SbxCf.FId_APP1SigPath_CA
      DINH_SbxCf.FId_APP2SigPath_CA DINH_SbxCf.FId_ASModPipe_CA DINH_SbxCf.FId_ASModPipeSlw_CA DINH_SbxCf.FId_ASModPresCalc_CA DINH_SbxCf.FId_ASModStrt_CA DINH_SbxCf.FId_ASModSwtOffEng_CA
      DINH_SbxCf.FId_ASModTrbn_CA DINH_SbxCf.FId_AdcIADC0_CA DINH_SbxCf.FId_Cic751Dev1_CA DINH_SbxCf.FId_CoEngNrml2Strt_CA DINH_SbxCf.FId_CoEngPthClsEGR_CA DINH_SbxCf.FId_CoEngPthClsThr_CA
      DINH_SbxCf.FId_CoEngPthCylOff_CA DINH_SbxCf.FId_CoEngPthETZr_CA DINH_SbxCf.FId_CoEngPthFlQnt_CA DINH_SbxCf.FId_CoEngPthInjVlvOff_CA DINH_SbxCf.FId_CoEngPthLpSysOff_CA DINH_SbxCf.FId_CoEngPthRPMin_CA
      DINH_SbxCf.FId_CoEngPthTrqZr_CA DINH_SbxCf.FId_CoEngSoftShOff_CA DINH_SbxCf.FId_DevLibActrPrt_CA DINH_SbxCf.FId_DewDetHtgDel_CA DINH_SbxCf.FId_DewDetstSrvTstDem_CA DINH_SbxCf.FId_EGRVlvJamVlv_CA
      DINH_SbxCf.FId_ETClbCorActv_CA DINH_SbxCf.FId_EpmBCr_CA DINH_SbxCf.FId_EpmCaSAdapCaSI1_CA DINH_SbxCf.FId_EpmCaSDiag_CA DINH_SbxCf.FId_EpmCaSOfsDiagCaSI1_CA DINH_SbxCf.FId_EpmCaSOfsErrCaSI1_CA
      DINH_SbxCf.FId_EpmCaSSegCor_CA DINH_SbxCf.FId_EpmCrSDiag_CA DINH_SbxCf.FId_EpmCrSDiagVeh_CA DINH_SbxCf.FId_EpmOpMode_InjLock_CA DINH_SbxCf.FId_FBC_CA DINH_SbxCf.FId_FMALamO2Valid_CA
      DINH_SbxCf.FId_FMASwtOff1_CA DINH_SbxCf.FId_FMASwtOff3_CA DINH_SbxCf.FId_FlSysDens_CA DINH_SbxCf.FId_FlSysTnkLoEEP_CA DINH_SbxCf.FId_FlSysTnkLoInfo_CA DINH_SbxCf.FId_FuelTCTS_CA
      DINH_SbxCf.FId_FuelTFlSys_CA DINH_SbxCf.FId_FuelTFrzVal_CA DINH_SbxCf.FId_FuelTFrzValB1_CA DINH_SbxCf.FId_FuelTReplVal_CA DINH_SbxCf.FId_GlwCtl1_CA DINH_SbxCf.FId_GlwCtl2_CA
      DINH_SbxCf.FId_GlwCtl3_CA DINH_SbxCf.FId_GlwPlgCod_CA DINH_SbxCf.FId_GlwPlgGCUTDia_CA DINH_SbxCf.FId_IVActrTempRplVal_CA DINH_SbxCf.FId_IVAdjNVCEna_CA DINH_SbxCf.FId_IVDiaCylOKTst_CA
      DINH_SbxCf.FId_IVDiaTst_CA DINH_SbxCf.FId_IVPSplyDCDCOff_CA DINH_SbxCf.FId_IVPlausComprTst_CA DINH_SbxCf.FId_IVPlausRunUpTst_CA DINH_SbxCf.FId_InhibitNever_CA DINH_SbxCf.FId_InjUnStrtPlsBlk_CA
      DINH_SbxCf.FId_InjVlvBnk0ShutOff_CA DINH_SbxCf.FId_InjVlvCyl0ShutOff_CA DINH_SbxCf.FId_InjVlvCyl1ShutOff_CA DINH_SbxCf.FId_InjVlvCyl2ShutOff_CA DINH_SbxCf.FId_InjVlvCyl3ShutOff_CA DINH_SbxCf.FId_InjVlvCyl4ShutOff_CA
      DINH_SbxCf.FId_InjVlvCyl5ShutOff_CA DINH_SbxCf.FId_InjVlvPrep_CA DINH_SbxCf.FId_InjVlvPresMin_CA DINH_SbxCf.FId_InjVlvPresMinRun_CA DINH_SbxCf.FId_InjVlvPresMinStrt_CA DINH_SbxCf.FId_LSUAdap0_CA
      DINH_SbxCf.FId_LSUClbSched_CA DINH_SbxCf.FId_LSUCmpChk0_CA DINH_SbxCf.FId_LSUCtl0_CA DINH_SbxCf.FId_LSUDewRls0_CA DINH_SbxCf.FId_LSUDynChk0_CA DINH_SbxCf.FId_LSUHtCoup0_CA
      DINH_SbxCf.FId_LSUHtrPS0_CA DINH_SbxCf.FId_LSUIPOpnLdTst0_CA DINH_SbxCf.FId_LSUIsolChk0_CA DINH_SbxCf.FId_LSULoBatt0_CA DINH_SbxCf.FId_LSUMon0_CA DINH_SbxCf.FId_LSUO20_CA
      DINH_SbxCf.FId_LSUO2Clb0_CA DINH_SbxCf.FId_LSUO2SRC0_CA DINH_SbxCf.FId_LSUPlausChk0_CA DINH_SbxCf.FId_LSUPresComp0_CA DINH_SbxCf.FId_LSUPresCompAdap0_CA DINH_SbxCf.FId_LSURi0_CA
      DINH_SbxCf.FId_LSURiClb0_CA DINH_SbxCf.FId_LSUShCir0_CA DINH_SbxCf.FId_LSUUNVGOpnLdTst0_CA DINH_SbxCf.FId_LSUlsu0_CA DINH_SbxCf.FId_MeUnActrTst_CA DINH_SbxCf.FId_MeUnFrzI_CA
      DINH_SbxCf.FId_MeUnRot_CA DINH_SbxCf.FId_MeUnSetPTst_CA DINH_SbxCf.FId_PCVActrTst_CA DINH_SbxCf.FId_PCVFrzI_CA DINH_SbxCf.FId_PCVNoStrt_CA DINH_SbxCf.FId_PCVPwrStgTst_CA
      DINH_SbxCf.FId_PCVSetPTst_CA DINH_SbxCf.FId_QWCCTSDef_CA DINH_SbxCf.FId_QWCFTSDef_CA DINH_SbxCf.FId_QWCOff_CA DINH_SbxCf.FId_RailCPCtlMeUnMode_CA DINH_SbxCf.FId_RailCPCtlPCVMode_CA
      DINH_SbxCf.FId_RailCtlMode_CA DINH_SbxCf.FId_RailHpTst_CA DINH_SbxCf.FId_RailMeUn0Blk_CA DINH_SbxCf.FId_RailMeUn0Rls_CA DINH_SbxCf.FId_RailMeUn1Blk_CA DINH_SbxCf.FId_RailMeUn1Rls_CA
      DINH_SbxCf.FId_RailMeUn22Rls_CA DINH_SbxCf.FId_RailMeUn2Blk_CA DINH_SbxCf.FId_RailMeUn2Rls_CA DINH_SbxCf.FId_RailMeUn3Blk_CA DINH_SbxCf.FId_RailMeUn3Rls_CA DINH_SbxCf.FId_RailMeUn4Blk_CA
      DINH_SbxCf.FId_RailMeUn4Rls_CA DINH_SbxCf.FId_RailMeUnClsdShutOff_CA DINH_SbxCf.FId_RailMeUnCtlMode_CA DINH_SbxCf.FId_RailMeUnCtlUpLim_CA DINH_SbxCf.FId_RailPCV0Blk_CA DINH_SbxCf.FId_RailPCV0Rls_CA
      DINH_SbxCf.FId_RailPCV1Blk_CA DINH_SbxCf.FId_RailPCV1Rls_CA DINH_SbxCf.FId_RailPCV2Blk_CA DINH_SbxCf.FId_RailPCV2Rls_CA DINH_SbxCf.FId_RailPCV3Blk_CA DINH_SbxCf.FId_RailPCV3Rls_CA
      DINH_SbxCf.FId_RailPCV4Blk_CA DINH_SbxCf.FId_RailPCV4Rls_CA DINH_SbxCf.FId_RailPCVCtlMode_CA DINH_SbxCf.FId_RailPCVCtlUpLim_CA DINH_SbxCf.FId_RailPSS_CA DINH_SbxCf.FId_RailPSubsVal_CA
      DINH_SbxCf.FId_RailSetPointLim_CA DINH_SbxCf.FId_RailSetPointRed_CA DINH_SbxCf.FId_RailSetPointTst_CA DINH_SbxCf.FId_RailTnkLo_CA DINH_SbxCf.FId_SSTEGRClrDs_CA DINH_SbxCf.FId_TAA_CA
      DINH_SbxCf.FId_TEGRClrDsFrzVal_CA DINH_SbxCf.FId_TEGRClrDsRplVal_CA DINH_SbxCf.FId_ThrVlvOpnLd_CA DINH_SbxCf.FId_TrbChPmp_CA DINH_SbxCf.FId_ZFCClbActv_CA DINH_SbxCf.FId_ZFCCldCmbCham_CA
      DINH_SbxCf.FId_ZFCPCLClbActv_CA DINH_SbxCf.FId_stAVSCoESLSU_CA
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      DINH_stClctFId_mp
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Dio
    ""

    /begin DEF_CHARACTERISTIC
      Dio_idxAirCCmprOD_C Dio_idxAirCCmprRedTrqOD_C Dio_idxBrkMnID_C Dio_idxCATTS1PullOD_C Dio_idxClthID_C Dio_idxEGRVlvODDir_C
      Dio_idxEGRVlvODDis_C Dio_idxPFTS1PullOD_C Dio_idxTEGRPullOD_C Dio_idxThrVlvODDir_C Dio_idxThrVlvODDis_C Dio_swtPortP1P5OUTInv_C
      Dio_swtPortP1P6OUTInv_C Dio_swtPortP4P1OUTInv_C Dio_swtPortP4P2OUTInv_C Dio_swtPortP5P5INInv_C
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    Distab
    ""


/end FUNCTION

/begin FUNCTION

    Dma
    ""


/end FUNCTION

/begin FUNCTION

    Dme
    ""

    /begin DEF_CHARACTERISTIC
      Dme_stOverlayMethodOnly_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Dme_ctDataSetVariant Dme_numBytesAvailable Dme_numBytesAvailableOvl
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DSCHED
    ""

    /begin DEF_CHARACTERISTIC
      DSCHED_valOfsPrioOpMode_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st PthSet_stOvrRunCoord
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DSCHED_Auto
    ""

    /begin DEF_CHARACTERISTIC
      DSCHED_AsgnCheck.FId_InhibitAlways_C DSCHED_AsgnCheck.FId_CoordALS_C DSCHED_AsgnCheck.FId_CoordFBC_C DSCHED_AsgnCheck.FId_CoordTAA_C DSCHED_AsgnCheck.FId_CoordZFC_C DSCHED_AsgnCheck.FId_IVPlausRunUpTstActv_C
      DSCHED_AsgnCheck.FId_RailHpTstActv_C DSCHED_BsPrio.FId_InhibitAlways_C DSCHED_BsPrio.FId_CoordALS_C DSCHED_BsPrio.FId_CoordFBC_C DSCHED_BsPrio.FId_CoordTAA_C DSCHED_BsPrio.FId_CoordZFC_C
      DSCHED_BsPrio.FId_IVPlausRunUpTstActv_C DSCHED_BsPrio.FId_RailHpTstActv_C DSCHED_Excl.FId_InhibitAlways_CA DSCHED_Excl.FId_CoordALS_CA DSCHED_Excl.FId_CoordFBC_CA DSCHED_Excl.FId_CoordTAA_CA
      DSCHED_Excl.FId_CoordZFC_CA DSCHED_Excl.FId_IVPlausRunUpTstActv_CA DSCHED_Excl.FId_RailHpTstActv_CA DSCHED_FacPhys.FId_InhibitAlways_C DSCHED_FacPhys.FId_CoordALS_C DSCHED_FacPhys.FId_CoordFBC_C
      DSCHED_FacPhys.FId_CoordTAA_C DSCHED_FacPhys.FId_CoordZFC_C DSCHED_FacPhys.FId_IVPlausRunUpTstActv_C DSCHED_FacPhys.FId_RailHpTstActv_C DSCHED_JmpActvPrio.FId_InhibitAlways_C DSCHED_JmpActvPrio.FId_CoordALS_C
      DSCHED_JmpActvPrio.FId_CoordFBC_C DSCHED_JmpActvPrio.FId_CoordTAA_C DSCHED_JmpActvPrio.FId_CoordZFC_C DSCHED_JmpActvPrio.FId_IVPlausRunUpTstActv_C DSCHED_JmpActvPrio.FId_RailHpTstActv_C DSCHED_RmpIniPrio.FId_InhibitAlways_C
      DSCHED_RmpIniPrio.FId_CoordALS_C DSCHED_RmpIniPrio.FId_CoordFBC_C DSCHED_RmpIniPrio.FId_CoordTAA_C DSCHED_RmpIniPrio.FId_CoordZFC_C DSCHED_RmpIniPrio.FId_IVPlausRunUpTstActv_C DSCHED_RmpIniPrio.FId_RailHpTstActv_C
      DSCHED_RmpSlpActv.FId_InhibitAlways_C DSCHED_RmpSlpActv.FId_CoordALS_C DSCHED_RmpSlpActv.FId_CoordFBC_C DSCHED_RmpSlpActv.FId_CoordTAA_C DSCHED_RmpSlpActv.FId_CoordZFC_C DSCHED_RmpSlpActv.FId_IVPlausRunUpTstActv_C
      DSCHED_RmpSlpActv.FId_RailHpTstActv_C DSCHED_RmpSlpPas.FId_InhibitAlways_C DSCHED_RmpSlpPas.FId_CoordALS_C DSCHED_RmpSlpPas.FId_CoordFBC_C DSCHED_RmpSlpPas.FId_CoordTAA_C DSCHED_RmpSlpPas.FId_CoordZFC_C
      DSCHED_RmpSlpPas.FId_IVPlausRunUpTstActv_C DSCHED_RmpSlpPas.FId_RailHpTstActv_C DSCHED_RmpUpLim.FId_InhibitAlways_C DSCHED_RmpUpLim.FId_CoordALS_C DSCHED_RmpUpLim.FId_CoordFBC_C DSCHED_RmpUpLim.FId_CoordTAA_C
      DSCHED_RmpUpLim.FId_CoordZFC_C DSCHED_RmpUpLim.FId_IVPlausRunUpTstActv_C DSCHED_RmpUpLim.FId_RailHpTstActv_C DSCHED_xSleepFId_CA
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      DSCHED_DynPrio.FId_Unused DSCHED_DynPrio.FId_InhibitAlways DSCHED_DynPrio.FId_CoordALS DSCHED_DynPrio.FId_CoordFBC DSCHED_DynPrio.FId_CoordTAA DSCHED_DynPrio.FId_CoordZFC
      DSCHED_DynPrio.FId_IVPlausRunUpTstActv DSCHED_DynPrio.FId_RailHpTstActv DSCHED_PhysPrio.FId_Unused DSCHED_PhysPrio.FId_InhibitAlways DSCHED_PhysPrio.FId_CoordALS DSCHED_PhysPrio.FId_CoordFBC
      DSCHED_PhysPrio.FId_CoordTAA DSCHED_PhysPrio.FId_CoordZFC DSCHED_PhysPrio.FId_IVPlausRunUpTstActv DSCHED_PhysPrio.FId_RailHpTstActv DSCHED_RmpPrio.FId_Unused DSCHED_RmpPrio.FId_InhibitAlways
      DSCHED_RmpPrio.FId_CoordALS DSCHED_RmpPrio.FId_CoordFBC DSCHED_RmpPrio.FId_CoordTAA DSCHED_RmpPrio.FId_CoordZFC DSCHED_RmpPrio.FId_IVPlausRunUpTstActv DSCHED_RmpPrio.FId_RailHpTstActv
      DSCHED_St.FId_Unused DSCHED_St.FId_InhibitAlways DSCHED_St.FId_CoordALS DSCHED_St.FId_CoordFBC DSCHED_St.FId_CoordTAA DSCHED_St.FId_CoordZFC
      DSCHED_St.FId_IVPlausRunUpTstActv DSCHED_St.FId_RailHpTstActv DSCHED_WhyExcl.FId_Unused DSCHED_WhyExcl.FId_InhibitAlways DSCHED_WhyExcl.FId_CoordALS DSCHED_WhyExcl.FId_CoordFBC
      DSCHED_WhyExcl.FId_CoordTAA DSCHED_WhyExcl.FId_CoordZFC DSCHED_WhyExcl.FId_IVPlausRunUpTstActv DSCHED_WhyExcl.FId_RailHpTstActv
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    DSM
    ""

    /begin DEF_CHARACTERISTIC
      DSMRdy_xPId1_C DSM_numDFCSet_C DSM_numFIdSet_C DSM_stDebDFCSet_C DSM_stDebDfltSet_C DSM_stDFCSet_C
      DSM_stFIdSet_C DSM_swtCallBkFnInitEna_C DSM_tmrDFCSet_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      DFC_stRawDef DFES_stErrLamp DSMRdy_xPId1
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      DSCHED
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    DuartAppl_Std
    ""


/end FUNCTION

/begin FUNCTION

    Duart_Std
    ""


/end FUNCTION

/begin FUNCTION

    dummy_stub
    ""

    /begin DEF_CHARACTERISTIC
      EngDa_tiEngOffInit_C ImmCtl_stEnaEmul_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Vbx_prg_appl_key_stt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ImmCtl_Noise ImmCtl_stEmul
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ECBVlv_DD
    ""

    /begin DEF_CHARACTERISTIC
      ECBVlv_Pwm.tiPer_C ECBVlv_Pwm.stLvl_C ECBVlv_Pwm.rMaxDty_C ECBVlv_Pwm.rPerUn_C ECBVlv_Pwm.tiPh_C ECBVlv_PwmOut.rMin_C
      ECBVlv_PwmOut.rMax_C ECBVlv_PwmOut.tiBtwTstSCB_C ECBVlv_PwmOut.tiBtwTstOT_C ECBVlv_PwmOut.numTstMax_C ECBVlv_PwmOut.swtBattCor_C ECBVlv_PwmOut.swtPsInv_C
      ECBVlv_rCnv_CUR ECBVlv_rPsDisbl_C ECBVlv_stPsDiaDisbl_C ECBVlv_stPsDisbl_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_facCor DevLib_stPwrStgEnaCond
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ECBVlv_r ECBVlv_rPs
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Eec
    ""


/end FUNCTION

/begin FUNCTION

    Eee
    ""

    /begin SUB_FUNCTION
      Eeebd Eeepdd
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    Eeebd
    ""

    /begin OUT_MEASUREMENT
      Eeebd_numSectChg Eeebd_stEee
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Eeepdd
    ""


/end FUNCTION

/begin FUNCTION

    Eep
    ""

    /begin SUB_FUNCTION
      Eee EepHal Ees
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    EepHal
    ""

    /begin DEF_CHARACTERISTIC
      EEPRdErr_Datalost_CW EEPRdErr_Redundant_CW Eep_EnFirstInit_CW Eep_EnvRamClr_CW
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Eep_EnvRamHist Eep_EnvRamInvld Eep_numBlkCtr Eep_numEnvRamLength Eep_stBlk Eep_stBlockFail
      Eep_stMain Eep_stPostDrv Eep_xIniTimeus
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Ees
    ""

    /begin SUB_FUNCTION
      Eesbd Eespdd
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    Eesbd
    ""


/end FUNCTION

/begin FUNCTION

    Eespdd
    ""


/end FUNCTION

/begin FUNCTION

    EGRVlv_DD
    ""

    /begin DEF_CHARACTERISTIC
      EGRVlv_facCorStrt_C EGRVlv_HBrgPar.rTstDtyCyc_C EGRVlv_HBrgPar.tiDisblDiaTmpDef_C EGRVlv_HBrgPar.tiDisblDiaPermDef_C EGRVlv_HBrgPar.tiOpnLdDiaEna_C EGRVlv_HBrgPar.tiMaxOpnLdDiaEna_C
      EGRVlv_HBrgPar.rDtyCycPlausShCirGnd_C EGRVlv_HBrgPar.rDtyCycPlausShCirBatt_C EGRVlv_Pwm.tiPer_C EGRVlv_Pwm.stLvl_C EGRVlv_Pwm.rMaxDty_C EGRVlv_Pwm.rPerUn_C
      EGRVlv_Pwm.tiPh_C EGRVlv_PwmOut.rMin_C EGRVlv_PwmOut.rMax_C EGRVlv_PwmOut.tiBtwTstSCB_C EGRVlv_PwmOut.tiBtwTstOT_C EGRVlv_PwmOut.numTstMax_C
      EGRVlv_PwmOut.swtBattCor_C EGRVlv_PwmOut.swtPsInv_C EGRVlv_rCnv_MAP EGRVlv_rOutDfl_C EGRVlv_stPwrStgDiaDis_C EGRVlv_stPwrStgDis_C
      EGRVlv_swtChpSel_C EGRVlv_swtHwSel_C EGRVlv_swtLMSPwrStgOn_C EGRVlv_swtOpnLdDiaStrt_C EGRVlv_swtSelOvrCurrErr_C EGRVlv_tiBattCorFacFlt_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      HESrv_swtScndFlwActv_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_facCor CoEng_st DevLib_stPwrStgEnaCond EGRVlv_rEGR EGRVlv_stAdap EGRVlv_stMon
      Epm_nEng
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EGRVlv_r EGRVlv_rPs EGRVlv_stOpnLdDia
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EGRVlv_facCorFlt_mp EGRVlv_rCnv_mp EGRVlv_stOLXPostDrv_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EGSys_Axispoints
    ""


/end FUNCTION

/begin FUNCTION

    EGSys_GlbDef
    ""


/end FUNCTION

/begin FUNCTION

    ems2010_eep
    ""

    /begin IN_MEASUREMENT
      SyC_stPostDrv SyC_stSub
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ems2010_scheduling
    ""

    /begin IN_MEASUREMENT
      CoEng_st Epm_numVariant SyC_stSub T15_st
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      cnt_event_crk_off cnt_event_crk_on cnt_event_eng_stal cnt_event_in_cam cnt_event_ltoo cnt_event_ltoo1
      cnt_event_tolo
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmBCa_TstInj
    ""

    /begin DEF_CHARACTERISTIC
      EpmBCa_facSegTimeAcc_CUR EpmBCa_facSegTimeConstHigh_C EpmBCa_facSegTimeConstLow_C EpmBCa_nTstInjMax_C EpmBCa_numInjSer_C EpmBCa_numTstInjMax_C
      EpmBCa_phiSegEndOld_C EpmBCa_phiSegLen_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmSeq_numInt EpmSyn_phiInt Epm_ctCyl Epm_nEng Epm_numCyl Epm_phiDiffTDC
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmBCa_ctInjSer EpmBCa_ctTstInj EpmBCa_ctWaitTDC EpmBCa_CurrCyl EpmBCa_facTimes_mp EpmBCa_numCylInj
      EpmBCa_numWaitTDC EpmBCa_stTstInj EpmBCa_stTstInjRslt_mp EpmBCa_tiSegOld_mp EpmBCa_tiSeg_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmBCr_IntrCo
    ""

    /begin DEF_CHARACTERISTIC
      EpmBCr_phiTimeoutInt_C EpmBCr_swtEnable_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCaS_nEng EpmCrS_stDiagErrSig EpmCrS_stDiagNoSig EpmSeq_phiNxtInt EpmSyn_phiInt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmBCr_stIntrCo EpmBCr_stTmrModeStarted
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmBCr_Plaus
    ""

    /begin DEF_CHARACTERISTIC
      EpmBCr_nEng_DST EpmBCr_numSegTeeth_C EpmBCr_phiSync2Seg_C EpmBCr_rSeg2SegMax_GCUR EpmBCr_rSeg2SegMin_GCUR EpmBCr_rSeg2SyncMax_GCUR
      EpmBCr_rSeg2SyncMin_GCUR EpmBCr_stActEdge_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmBCr_phiSeg2Seg EpmBCr_tiSeg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmBCr_rSeg2SegMax_mp EpmBCr_rSeg2SegMin_mp EpmBCr_rSeg2Seg_mp EpmBCr_rSeg2SyncMax_mp EpmBCr_rSeg2SyncMin_mp EpmBCr_rSeg2Sync_mp
      EpmBCr_stPlaus_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmBCr_Pos
    ""

    /begin DEF_CHARACTERISTIC
      EpmBCr_phiZero2Sync_CA
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmBCr_phiSeg2Seg EpmBCr_tiSeg
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmBCr_nEng EpmBCr_phiPos EpmBCr_stPos
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmBCr_phiCurrCaSEdge EpmBCr_phiNxtCaSEdge EpmBCr_tiIncPer
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmCaS_Adap
    ""

    /begin DEF_CHARACTERISTIC
      EpmCaS_facAdapFil_C EpmCaS_phiDiffAdapMax_C EpmCaS_phiDiffLim_C EpmCaS_phiMntMax_C EpmCaS_swtForceRefAdap_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng Epm_stOpMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmCaS_stAdap Epm_numVariant
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmCaS_phiAdapRefPosI1_mp EpmCaS_phiDiffLimFil_mp EpmCaS_phiDiff_mp EpmCaS_stAdapErr
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmCaS_Diag
    ""

    /begin DEF_CHARACTERISTIC
      EpmCaS_numEdgeTol_C EpmCaS_numErrSigDef_C EpmCaS_numErrSigOk_C EpmCaS_numNoSigDef_C EpmCaS_stDiagMode_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmSeq_numInt Epm_ctCyl Epm_stOpMode T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmCaS_stErrSig EpmCaS_stNoSig
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmCaS_ctErrSigDef EpmCaS_ctErrSigOk EpmCaS_ctNoSig EpmCaS_numCurrEdge EpmCaS_stDiag
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmCaS_Meas
    ""

    /begin DEF_CHARACTERISTIC
      EpmCaS_swtMeasCaS_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCrS_stSigMode Epm_stOpMode
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmCaS_numRawValue_mp EpmCaS_phiRawValue_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmCaS_OfsDiag
    ""

    /begin DEF_CHARACTERISTIC
      EpmCaS_numOfsErr_C EpmCaS_phiOfsMax_C EpmCaS_phiOfsMin_C EpmCaS_phiOfsTolc_C EpmCaS_stOfsDiagMode_C EpmCaS_tiOfsPT1_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCaS_phiCor EpmSyn_stRR Epm_stOpMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmCaS_phiCaSOfsAvg EpmCaS_phiOfsCorr EpmCaS_stOfs EpmCaS_stOfsErr
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmCaS_ctOfsErr_mp EpmCaS_numBufEntry_mp EpmCaS_numSegTeeth_mp EpmCaS_numValidTeeth_mp EpmCaS_phiMissedSeg_mp EpmCaS_phiSegLenTolc_mp
      EpmCaS_phiSpeedSegLen_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmCaS_Seg
    ""

    /begin DEF_CHARACTERISTIC
      EpmCaS_dSegSeries_CA EpmCaS_facPlausHigh_GCUR EpmCaS_facPlausLow_GCUR EpmCaS_facPlaus_DST EpmCaS_numSegSerLst_C EpmCaS_phiNCor_CUR
      EpmCaS_phiSegLenTol_CA EpmCaS_phiSegLen_CA EpmCaS_phiSegOfs_CA EpmCaS_phiTempCor05_DST EpmCaS_phiTempCorI1_GCUR EpmCaS_stActEdge_C
      EpmCaS_tiGlitchFilter_C EpmCaS_tiTimeout_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EngDa_tEng EpmCaS_stAdap Epm_nEng
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmCaS_ctEdgeEquid EpmCaS_nEng EpmCaS_phiCor EpmCaS_phiDiff EpmCaS_phiEdge EpmCaS_phiTempCor
      EpmCaS_stNEng EpmCaS_tiEdge
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmCaS_nCaS_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmCaS_SegCor
    ""


/end FUNCTION

/begin FUNCTION

    EpmCrS_Diag
    ""

    /begin DEF_CHARACTERISTIC
      EpmCrS_dnEngMax_C EpmCrS_nDiagOff_C EpmCrS_nDiagOn_C EpmCrS_numErrSigGlitMax_C EpmCrS_numErrSigIncDef_C EpmCrS_numErrSigMaxDef_C
      EpmCrS_numErrSigMinOK_C EpmCrS_numNoSigDef_C EpmCrS_stDiagT50Reset_C EpmCrS_swtEnableDiag_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st EpmCaS_stNEng Epm_dnEngFlt Epm_nEng Epm_stOpMode Strt_stPs
      T15_st VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmCrS_stDiag EpmCrS_stDiagErrSig EpmCrS_stDiagNoSig
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmCrS_ctCaSRev_mp EpmCrS_ctErrSig EpmCrS_ctGlitch EpmCrS_ctGlitchRev_mp EpmCrS_ctRev100msLim_mp EpmCrS_ctRevWaitDiag
      EpmCrS_stDiagFFReset_mp EpmCrS_stDiagReset_mp EpmCrS_stDiagVehSpdReset_mp EpmCrS_stSigDiagSrc
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmCrS_Plaus
    ""

    /begin DEF_CHARACTERISTIC
      EpmCrS_facGapCrit1_C EpmCrS_facGapCrit2_C EpmCrS_facGapPlausHigh_CA EpmCrS_facIncPlausHigh_CA EpmCrS_facIncPlausLow_CA EpmCrS_nMaxInc_C
      EpmCrS_nMinInc_C EpmCrS_nThreshRange_CA EpmCrS_nTiIncPerAvrg_CA EpmCrS_numIgnInc_C EpmCrS_numTiIncPerAvrg_CA EpmCrS_tiGlitchFilter_CA
      EpmCrS_tiIgnSig_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCrS_stSigMode Epm_nEng
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmCrS_ctRange_mp EpmCrS_numTiIncPerAvrg_mp EpmCrS_tiIncPer_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmCrS_RevCnt
    ""

    /begin IN_MEASUREMENT
      CoEng_st EpmCrS_numSeg EpmHCrS_stSigMode Epm_nEng Epm_stSync
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmCrS_ctRevIni EpmCrS_ctRevStrt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmCrS_ctRevCnt
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmCrS_Seg
    ""

    /begin DEF_CHARACTERISTIC
      EpmCrS_facScale_C EpmCrS_nFacScale_C EpmCrS_stTTMeasureOn_C EpmCrS_swtIncSrc_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      EpmSeq_phiInt_CA EpmSeq_swtInt_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmSeq_numInt EpmSyn_phiInt Epm_ctCyl Epm_nEng Epm_numCyl Epm_stOpMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmCrS_ctInc EpmCrS_numSeg EpmCrS_phiIntSeg EpmCrS_stSigMode EpmCrS_tiSeg EpmCrS_tiSegCurr
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmCrS_facScale_mp EpmCrS_numNewInc_mp EpmCrS_tiInc_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmHCaS_SigBuf
    ""


/end FUNCTION

/begin FUNCTION

    EpmHCaS_SigEval
    ""


/end FUNCTION

/begin FUNCTION

    Epmhcrs_Bkupcrs
    ""

    /begin DEF_CHARACTERISTIC
      EpmHCrS_cylfrstGap_C EpmHCrS_cylscndGap_C EpmHCrS_numIntfrstGap_C EpmHCrS_numIntscndGap_C EpmHCrS_phiGap_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmSeq_numInt Epm_ctCyl
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmHCrS_FindGap_mp EpmHCrS_stTimer EpmHCrS_TimerVal_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmHCrS_SigBuf
    ""

    /begin IN_MEASUREMENT
      EpmSyn_phiInt Epm_phiDiffTDC
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmHCrS_SigEval
    ""

    /begin DEF_CHARACTERISTIC
      EpmHCrS_swtIAPDvtCorEna_C EpmHCrS_swtIAPEna_C EpmHCrS_swtIASEna_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCrS_stSigMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmHCrS_stSigErr EpmHCrS_stSigMode
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmHInt_IntGen
    ""

    /begin LOC_MEASUREMENT
      EpmHInt_tiInt4Del_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmHwe_Ini
    ""


/end FUNCTION

/begin FUNCTION

    EpmHwe_Srv
    ""


/end FUNCTION

/begin FUNCTION

    EpmRRS_AgDetect
    ""

    /begin OUT_MEASUREMENT
      EpmRRS_bEngSwOff
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmSeq_StateMn
    ""

    /begin DEF_CHARACTERISTIC
      EpmSeq_nMaxStrtInt_C EpmSeq_phiDelayMax_C EpmSeq_phiIntBCr_CA EpmSeq_phiInt_CA EpmSeq_phiStrtInt_CA EpmSeq_phiSyncInt_C
      EpmSeq_swtInt_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmBCr_stTmrModeStarted EpmCrS_stSigMode Epm_nEng Epm_numCyl Epm_stOpMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmSeq_numIncDiffInt EpmSeq_numInt EpmSeq_phiNxtInt EpmSeq_stInt
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmSrv_Lib
    ""

    /begin DEF_CHARACTERISTIC
      EpmSrv_numTDCMIAPStrt_C EpmSrv_numTDCMIAP_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmSrv_stCnvAgT2Ag_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmSyn_CaSPos
    ""

    /begin DEF_CHARACTERISTIC
      EpmSyn_dCaSSegMsk_C EpmSyn_dTrigMsk_C EpmSyn_dTrigRslt_C EpmSyn_phiTrig_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_stOpMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmSyn_stRR
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmSyn_CaSData EpmSyn_ctEdgeEarly EpmSyn_ctEdgeLate EpmSyn_ctLstEdge_mp EpmSyn_ctSigTabLstEntr_mp EpmSyn_EdgeFailType
      EpmSyn_numCaSSync EpmSyn_numMatches_mp EpmSyn_numMatchPos EpmSyn_numMatchPos_mp EpmSyn_numNewEdges_mp EpmSyn_numSegInSigTab_mp
      EpmSyn_phiCaSPos EpmSyn_phiSegLenUncorr EpmSyn_stCasEval EpmSyn_stCaSPos EpmSyn_stGapPos EpmSyn_stPreSeg_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EpmSyn_CrSPos
    ""

    /begin DEF_CHARACTERISTIC
      EpmSyn_phiIncCor_CUR EpmSyn_phiRRMax_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCrS_stSigMode EpmSyn_stRR Epm_nEng Epm_stOpMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      EpmSyn_numIntTyp EpmSyn_phiInt EpmSyn_stCrSPos EpmSyn_stCrSPosErr
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmSyn_phiDiff_mp EpmSyn_phiIncCor_mp EpmSyn_phiOffs
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Epm_Auto
    ""

    /begin DEF_CHARACTERISTIC
      Epm_numConf_CA
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      Epm_numVersion
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Epm_Axispoints
    ""


/end FUNCTION

/begin FUNCTION

    Epm_HE
    ""

    /begin OUT_MEASUREMENT
      Epm_ctCylPerECU Epm_stRmtInjVlv
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Epm_Ini
    ""

    /begin DEF_CHARACTERISTIC
      Epm_numCyl_C Epm_numFireSeg_C Epm_phiGap2Zero_C Epm_phiTdc1_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Epm_numCyl Epm_phiDiffTDC
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Epm_OpMode
    ""

    /begin DEF_CHARACTERISTIC
      Epm_nNoSyncVerify_C Epm_numReSync_C Epm_swtBlkInjCaSSync_C Epm_swtOpModeStgy_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      EpmCaS_stActEdge_C EpmCaS_tiGlitchFilter_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmBCr_phiPos EpmBCr_stTmrModeStarted EpmCaS_nEng EpmCaS_stOfsErr EpmCrS_stSigMode EpmSeq_numInt
      EpmSeq_phiNxtInt EpmSyn_numIntTyp EpmSyn_phiInt EpmSyn_stCrSPos EpmSyn_stCrSPosErr EpmSyn_stRR
      Epm_ctCylPerECU Epm_nEng Epm_numCyl
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Epm_ctCyl Epm_stCmbTestReq Epm_stOpMode Epm_stSync
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Epm_ctReSync_mp Epm_ctTDCPhys_mp Epm_phiIntDelay_mp Epm_stReSyncReason_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Epm_Spd
    ""

    /begin DEF_CHARACTERISTIC
      Epm_tiSpd2Zero_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmBCr_nEng EpmBCr_stPos EpmCaS_nEng EpmCaS_stErrSig EpmCaS_stNoSig EpmCrS_stDiag
      EpmCrS_stDiagErrSig EpmCrS_stDiagNoSig EpmCrS_stSigMode EpmCrS_tiSeg EpmCrS_tiSegCurr EpmSyn_phiInt
      Epm_stOpMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Epm_nEng Epm_nEng10ms Epm_nEngCurr Epm_nEngLRes Epm_nEngRaw Epm_stSpd
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Epm_nEngTooth10ms_mp Epm_stSporadicAgTrg_mp Epm_tiSegRaw_mp Epm_tiSpd2Zero_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Epm_SpdGrd
    ""

    /begin DEF_CHARACTERISTIC
      Epm_tiSpdGrdFlt_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCrS_tiSeg EpmSeq_numInt Epm_nEng Epm_stSync
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Epm_dnEng Epm_dnEngFlt Epm_nEngDiff
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Epm_nEngOldS0_mp Epm_nEngOldS1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ESC_SeqSched
    ""

    /begin DEF_CHARACTERISTIC
      ESC_dLimCond_ASD_CA ESC_dLimCond_Common_CA ESC_dLimCond_CPP_CA ESC_dLimCond_FBC_CA ESC_dLimCond_Joint_CA ESC_dLimCond_LiGov_CA
      ESC_dLimCond_Post_CA ESC_dLimCond_Pre_CA ESC_dLimCond_PSC_CA ESC_dLimCond_S0_A_CA ESC_dLimCond_S0_B_CA ESC_dLimCond_S0_Rmt_CA
      ESC_dLimCond_S1_A_CA ESC_dLimCond_S1_B_CA ESC_dLimCond_S1_Rmt_CA ESC_dLimCond_UnitInjector_CA ESC_dLimCond_Update_CA ESC_nLimInj_C
      ESC_nLimThreshHyst_CA ESC_nLimThresh_CA ESC_numLimInj_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCrS_tiSeg EpmCrS_tiSegCurr EpmSeq_numInt Epm_ctCyl Epm_nEng Epm_numCyl
      Epm_stRmtInjVlv ESC_tiSampling
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      ESC_stSchdFlag_mp ESC_stSchdLevel_mp ESC_stSchdS0_mp ESC_stSchdS1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ESC_Stack
    ""

    /begin IN_MEASUREMENT
      EpmCrS_tiSeg EpmCrS_tiSegCurr
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ESC_stErr ESC_tiSampling
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ESC_TaskLink
    ""

    /begin DEF_CHARACTERISTIC
      ESC_stS1FrstSched_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmSeq_numInt SyC_stSub SyC_tiDrv
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Etc
    ""

    /begin DEF_CHARACTERISTIC
      Etc_MaxReqTO_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Etc_ctCurRunTst
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ETClb_AVS
    ""

    /begin REF_CHARACTERISTIC
      ETClb_tiETOfsMax_CA ETClb_tiETOfsMin_CA ETClb_tiET_MAX_CA ETClb_tiET_MIN_CA
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ETClb_Calibration
    ""

    /begin DEF_CHARACTERISTIC
      ETClb_ctLrnThresQck_C ETClb_ctLrnThresQIS_C ETClb_ctLrnThresRC_C ETClb_ctLrnThres_C ETClb_dpRailLim_CA ETClb_facFltQck_C
      ETClb_facFltRC_C ETClb_facFlt_C ETClb_numCyclMeas_C ETClb_numCyclNoDyn_C ETClb_numCyclStartEnergize_C ETClb_pRailSet_CA
      ETClb_qThresPCL_CA ETClb_SigThres_CA ETClb_swtQckClbActv_C ETClb_swtWrDflVal_C ETClb_tiBstPresCorr0_CUR ETClb_tiBstPresCorr1_CUR
      ETClb_tiBstPresCorr2_CUR ETClb_volEffectiveMin_CA ETClb_vStartClb_CA ETClb_vStopClb_CA
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      ETClb_tiET_MAX_CA ETClb_tiET_MIN_CA InjVlv_stZFCETCorActv_C InjVlv_swtZFCCorOvrRunOn_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Air_pCACDs ETClb_stLimClbFrq MoFOvR_stActvMsg PthSet_stOvrRunCoord VehV_v ZFC_swtPCLActv
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ETClb_stCor ETClb_swtCorActv
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ETClb_ctInjCycl_mp ETClb_ctLrn_mp ETClb_dtiETFlt0_mp ETClb_dtiETFlt1_mp ETClb_dtiETFlt2_mp ETClb_numCylCur_mp
      ETClb_numPres_mp ETClb_numRailPresClbPnt_mp ETClb_pRailSet ETClb_stDemCor_mp ETClb_stOld_mp ETClb_stQISActv
      ETClb_stRlsCylCor_mp ETClb_st_mp ETClb_swtQckClb_mp ETClb_tiETAvrg ETClb_tiETCor0_mp ETClb_tiETCor1_mp
      ETClb_tiETCor2_mp ETClb_tiETCur_mp ETClb_tiETMinEff_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ETClb_Eval
    ""

    /begin DEF_CHARACTERISTIC
      ETClb_tiETStepQIS_CA ETClb_tiETStep_CA ETClb_tiET_MAX_CA ETClb_tiET_MIN_CA
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      ZFC_swtPCLActv
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      ETClb_stEvalResult_mp ETClb_stEval_mp ETClb_tiETMax ETClb_tiETMin
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ETClb_Lib
    ""

    /begin DEF_CHARACTERISTIC
      ETClb_ctDflLrnAllw_CA ETClb_ctDflLrn_CA ETClb_ctLrnPerDelta_C ETClb_dtiDflETFlt0_CA ETClb_dtiDflETFlt1_CA ETClb_dtiDflETFlt2_CA
      ETClb_lDelta_C ETClb_lLrnDelta_C ETClb_numDflCylCur_CA ETClb_stRlsCylCorDfl_C ETClb_swtDflLimClbFrq_C ETClb_swtDflQckClb_C
      ETClb_swtLimClbFrqOff_C ETClb_tiDflETCur_CA ETClb_tiETOfsMax_CA ETClb_tiETOfsMin_CA
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      ETClb_ctLrnThres_C ETClb_pRailSet_CA ETClb_swtWrDflVal_C ETClb_tiET_MAX_CA ETClb_tiET_MIN_CA ETClb_volEffectiveMin_CA
      InjVlv_stZFCETCorActv_C InjVlv_swtZFCCorOvrRunOn_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl ETClb_stCor ETClb_swtCorActv GlbDa_lTotDst MoFOvR_stActvMsg
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ETClb_stLimClbFrq
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ETClb_ctDelta_mp ETClb_ctLrnCyclAllw_mp ETClb_swtRCClb_mp ETClb_tiETChkCor0_mp ETClb_tiETChkCor1_mp ETClb_tiETChkCor2_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    EtkS
    ""


/end FUNCTION

/begin FUNCTION

    ExeCon
    ""


/end FUNCTION

/begin FUNCTION

    FBC_Axispoints
    ""


/end FUNCTION

/begin FUNCTION

    FBC_Equal
    ""

    /begin DEF_CHARACTERISTIC
      FBC_BPFac.NumLo_CA FBC_BPFac.NumHi_CA FBC_BPFac.Den1_CA FBC_BPFac.Den2_CA FBC_BPFac1NumG_CUR FBC_ctPhComp_C
      FBC_ctSegOffset_C FBC_ctTDCOfs_C FBC_dqThresSurge_C FBC_dSegNhiCaS_CA FBC_dSegNloCaS_CA FBC_dSyn_C
      FBC_facBPRedNum_C FBC_fSurge_CUR FBC_GvrnI.Ki_C FBC_GvrnI.KiPos_C FBC_GvrnI.KiNeg_C FBC_GvrnI.WinPos_C
      FBC_GvrnI.WinNeg_C FBC_GvrnP.Kp_C FBC_nCtlOfsMin_C FBC_nCtlThresMax_C FBC_nGvrnOfsMin_C FBC_nGvrnThresMax_C
      FBC_nHyst_C FBC_nSurgeOffset_C FBC_qCtlOfsMax_C FBC_qCtlThresMin_C FBC_qGvrnThresMax_CUR FBC_qGvrnThresMin_C
      FBC_qLimDia_C FBC_qLim_CUR FBC_qRCLim_C FBC_qRC_CA FBC_rGripThres_C FBC_stOpModeFrz_C
      FBC_stOpModeInhib_C FBC_swtInitI_C FBC_swtRC_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      FBC_ActESpP_C FBC_nThresFbc_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Clth_st CoEng_st CoEOM_stOpModeAct EpmCrS_numSeg EpmCrS_tiSeg Epm_nEng
      Epm_numCyl FBC_WheelLrnOut InjCtl_qSetUnBal PthSet_stOvrRunCoord PT_rGrip PT_rTrq
      SpdGov_nSetPLo
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FBC_ctSegInt FBC_dBPSum FBC_qArr FBC_qDvtCyl FBC_qDvtCylPhys FBC_qIntegrator
      FBC_qLimAct FBC_qLimIncr FBC_stActive FBC_stEqualInit FBC_stRegionSRCtl
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      FBC_dBPCaS FBC_dBPCaSOld_mp FBC_facBPNum_mp FBC_facSegVal_mp FBC_nMaxOvrRun_mp FBC_q
      FBC_qSet FBC_qSetOld_mp FBC_stBPRedNum_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FBC_WheelLrn
    ""

    /begin DEF_CHARACTERISTIC
      FBC_ActESpP_C FBC_DSMUrgencyOffset_C FBC_DXAdapLo_C FBC_DXAdapUp_C FBC_DXalf0_C FBC_EnblCpy_C
      FBC_EnblIpo_C FBC_nBrIpoRng_CA FBC_nLrnThres_CA FBC_nThresFbc_C FBC_PrtnRmp_C FBC_TFConst_C
      FBC_TFLrnConst_C FBC_ThresDyn_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      FBC_nCtlThresMax_C FBC_nGvrnOfsMin_C FBC_nHyst_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st EpmCrS_numSeg EpmSyn_phiInt Epm_nEng Epm_numCyl FBC_stEqualInit
      PthSet_stOvrRunCoord SpdGov_nSetPLo
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FBC_Badpt FBC_RegionChng FBC_stLearn FBC_swtESpPEEPIni FBC_WheelLrnOut
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      FBC_AACoef_mp FBC_AAInSum_mp FBC_AAIn_mp FBC_AAOrd_mp FBC_AAOut_mp FBC_AAPhiAbs_mp
      FBC_AAPhiLen_mp FBC_DXAdap_mp FBC_DXSfn_mp FBC_DXSfp_mp FBC_DXSf_mp FBC_DXSl_mp
      FBC_DXS_mp FBC_dynSpd_mp FBC_numAASeg_mp FBC_stBufSeg_mp FBC_stBufSubSeg_mp FBC_stRegionESpP_mp
      FBC_stStateESpP_mp FBC_TSmCoef_mp FBC_WheelLrnOutOld_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FlashHndl
    ""


/end FUNCTION

/begin FUNCTION

    FlSys_CalcCnvFac
    ""

    /begin DEF_CHARACTERISTIC
      FlSys_facStoich_C FlSys_rhoFlCnvFac_C FlSys_swtRhoFlCnv_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      FlSys_facStoich FlSys_rhoFlCnvFac FlSys_swtRhoFlCnv
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FlSys_Deflate
    ""

    /begin DEF_CHARACTERISTIC
      FlSys_nDeflateMax_C FlSys_nDeflateMin_C FlSys_pDeflate_C FlSys_tiDeflateDel_C FlSys_tiDeflate_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      Rail_stCtlLoopSel_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st Epm_nEng FlSys_stDeflateOffDeflateTst FlSys_stTnk FlSys_swtSrcPSDeflateTst FlSys_tiDeflateDeflateTst
      PSP_st RailP_pFlt SyC_stMn SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FlSys_stDeflate FlSys_tiDeflate
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      FlSys_stDeflateActv_mp FlSys_stDeflateXPostDrv_mp FlSys_tiDeflateMax_mp FlSys_tiDeflateRdEEP_mp FlSys_tiDeflateStp_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FlSys_DeflateTst
    ""

    /begin DEF_CHARACTERISTIC
      FlSys_tiMaxDeflateTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng FlSys_stDeflateFin
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FlSys_stDeflateOffDeflateTst FlSys_swtSrcPSDeflateTst FlSys_tiDeflateDeflateTst
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      FlSys_stRefDeflateTst FlSys_stStMDeflateTst FlSys_tiEvalDeflateTst_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FlSys_DetFlTnk
    ""

    /begin DEF_CHARACTERISTIC
      FlSys_bFlTnkDes_C FlSys_dvolFlConsTnkLoMax_C FlSys_dvolFlConsTnkLoMin_C FlSys_swtBFlTnkDes_C FlSys_swtTnkInfo_C FlSys_swtVolFlTnkQntDes_C
      FlSys_volFlConsTnkHi_C FlSys_volFlTnkQntDes_C FlSys_volTnkDelta_C FlSys_volTnkLo_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st Dspl_bFlTnk Dspl_volFlTnkQnt FlSys_dvolFlCons SyC_stMn SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FlSys_stTnk
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      FlSys_volFlConsAct_mp FlSys_volFlConsRdEEP_mp FlSys_volFlConsWrEEP_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FlSys_FlCons
    ""

    /begin IN_MEASUREMENT
      Epm_nEng Epm_numCyl FlSys_rhoFl FlSys_rhoFlCnvFac FlSys_swtRhoFlCnv InjSys_qTot
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FlSys_dvolFlCons
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      FlSys_dvolPerStroke_mp FlSys_rhoFlSel_mp FlSys_volFlCons
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FlSys_FlPres
    ""

    /begin DEF_CHARACTERISTIC
      FlSys_pLos_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EnvP_p
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FlSys_p
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FMA_Adapt
    ""

    /begin DEF_CHARACTERISTIC
      FMA_facDensCor_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AFS_mAirPerCyl Epm_ctCyl Epm_nEng FMA_stSwtOff InjCtl_qSetUnBal InjSys_qInrCmb
      TrbnDsRLam_rLamRec
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      FMA_qAct_mp FMA_qDev_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FMA_CtlCalc
    ""

    /begin DEF_CHARACTERISTIC
      FMA_swtCorOff_C FMA_swtIC_C FMA_trqLimMax_C FMA_trqLimMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CnvSet_etaCurr Epm_ctCyl Epm_nEng FMA_facSwtOff InjCtl_qCurr InjSys_qInrCmb
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FMA_qAirCtlCor FMA_qCor FMA_qDC FMA_trqAirCtlCor
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      FMA_qCtl_mp FMA_q_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FMA_ErrMod
    ""

    /begin DEF_CHARACTERISTIC
      FMA_facNQSwtOff_MAP FMA_IFst.Ki_C FMA_IFst.KiPos_C FMA_IFst.KiNeg_C FMA_IFst.WinPos_C FMA_IFst.WinNeg_C
      FMA_ISlw.Ki_C FMA_ISlw.KiPos_C FMA_ISlw.KiNeg_C FMA_ISlw.WinPos_C FMA_ISlw.WinNeg_C FMA_numLimMax_C
      FMA_numLimMin_C FMA_numNGrid_C FMA_numQGrid_C FMA_qAdapIni_GMAP FMA_qAdapIni_X_AXIS FMA_qAdapIni_Y_AXIS
      FMA_qIntMax_C FMA_qIntMin_C FMA_qLimMax_C FMA_qLimMin_C FMA_qMapMax_C FMA_qMapMin_C
      FMA_qMax_C FMA_qMin_C FMA_swtChngValErrMod_C FMA_swtRst_C FMA_tiPT1Fst_C FMA_tiPT1Slw_C
      FMA_tiSwtPar_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng FMA_qCtl_mp InjCtl_qSetUnBal
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FMA_tiFuncOp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      FMA_facNQSwtOff_mp FMA_facSwtOffTot_mp FMA_numLimMax_mp FMA_numLimMin_mp FMA_qDiff_mp FMA_qErrMod_mp
      FMA_qMapRow0_mp FMA_qMapRow1_mp FMA_qMapRow2_mp FMA_qMapRow3_mp FMA_qMapRow4_mp FMA_qMapRow5_mp
      FMA_qMapRow6_mp FMA_qMapRow7_mp FMA_qReg_mp FMA_qSetFil_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FMA_Monitor
    ""

    /begin DEF_CHARACTERISTIC
      FMA_dfacSwtOffMax_C FMA_dqThres_C FMA_drLamThres_C FMA_facAirSwtOff_CUR FMA_facAPSwtOff_CUR FMA_facEngSwtOff_CUR
      FMA_facFlSwtOff_CUR FMA_nThres_C FMA_qThres_C FMA_rLamThresMax_C FMA_rLamThresMin_C FMA_stRgnMsk_C
      FMA_swtOnFMA_C FMA_tiDLamThres_C FMA_tiDynThres_C FMA_tiFaultRmp_C FMA_tiLamDT1_C FMA_tiLamThres_C
      FMA_tiOvrRun_C FMA_tiQDT1_C FMA_tiQLam_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AirCtl_stMon Air_tCACDs CoEOM_stOpModeAct CoES_stAVSCoLSU EngDa_tEng EnvP_p
      Epm_ctCyl Epm_nEng FuelT_t InjSys_qInrCmb InjSys_stCtlQnt TrbnDsRLam_rLam
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FMA_facSwtOff FMA_stSwtOff
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      FMA_dqAbs_mp FMA_drLamAbs_mp FMA_facAirSwtOff_mp FMA_facAPSwtOff_mp FMA_facEngSwtOff_mp FMA_facFaultSwtOff_mp
      FMA_facFlSwtOff_mp FMA_facRgnSwtOff_mp FMA_facSlpSwtOff2Var_mp FMA_facSlpSwtOff_mp FMA_stDynDlyd_mp FMA_stDynLam_mp
      FMA_stNoAdapt_mp FMA_stOvrRunDlyd_mp FMA_stReset_mp FMA_stRngLam_mp FMA_stSwtOff3Var_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FMO_CorValCalc
    ""

    /begin OUT_MEASUREMENT
      FMO_facAirMsCor FMO_qASMod FMO_qCor FMO_qEmiCtlCor FMO_qFullLdCor FMO_trqEmiCtlCor
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FrmInf_1000ms
    ""


/end FUNCTION

/begin FUNCTION

    FrmInf_100ms
    ""


/end FUNCTION

/begin FUNCTION

    FrmInf_10ms
    ""


/end FUNCTION

/begin FUNCTION

    FrmInf_20ms
    ""


/end FUNCTION

/begin FUNCTION

    FrmInf_4ms
    ""


/end FUNCTION

/begin FUNCTION

    FrmInf_50ms
    ""


/end FUNCTION

/begin FUNCTION

    FrmInf_KeyFrmTxCallback
    ""


/end FUNCTION

/begin FUNCTION

    FrmInf_NodeStatusInd
    ""


/end FUNCTION

/begin FUNCTION

    FrmInf_ReceiveMessage
    ""

    /begin DEF_CHARACTERISTIC
      ACC_CANHS_R_01_CA AIRBAGCrash_CA BCM_CANHS_RNr_01_CA BCM_CANHS_RNr_02_CA BCM_VERLOG_CA BRAKE_CANHS_RNr_01_CA
      BRAKE_CANHS_RNr_02_CA BRAKE_CANHS_RNr_03_CA BRAKE_CANHS_RNr_04_CA BRAKE_CANHS_R_01_CA CLIM_CANHS_R_01_CA CLUSTER_CANHS_RNr_01_CA
      CLUSTER_CANHS_R_01_CA DDCM_CANLSFT_R_01_CA FrmInf_swtDfltCal_C SWA_CANHS_RNr_01_CA TORQUE_AT_CANHS_RNr_01_CA TORQUE_AT_CANHS_RNr_02_CA
      USM_CANHS_RNr_01_CA
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    FrmInf_SendMessage
    ""


/end FUNCTION

/begin FUNCTION

    FuelT_DD
    ""

    /begin DEF_CHARACTERISTIC
      FuelT_SRC.uMin_C FuelT_SRC.uMax_C FuelT_tTransf_CUR
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      FuelT_tSens FuelT_uRaw
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    FuelT_VD
    ""

    /begin DEF_CHARACTERISTIC
      FuelT_RmpSlp.Pos_C FuelT_RmpSlp.Neg_C FuelT_swtSensPrs_C FuelT_swtTempSel_C FuelT_tDflFlSys_C FuelT_tiLPFiltPT1_C
      FuelT_TransStg.Dfl_C FuelT_TransStg.stSensId_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CEngDsT_t
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      FuelT_t FuelT_tFlSys
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    GlwCtl_ActrCtl
    ""

    /begin DEF_CHARACTERISTIC
      GlwCtl_tiPreGlwPsh_CUR GlwCtl_tiPreGlw_CUR GlwCtl_uThresHiOvrVltg_C GlwCtl_uThresHiUndrVltg_C GlwCtl_uThresLoOvrVltg_C GlwCtl_uThresLoUndrVltg_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_uSens Epm_nEng GlwCtl_stGlw GlwCtl_stPshRd GlwCtl_tEng GlwCtl_uGlwPlgRaw
      GlwPlg_u
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      GlwCtl_swtPreGlw GlwLmp_st
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      GlwCtl_stActrOut_mp GlwCtl_stGlwPlgActr_mp GlwCtl_stShOff_mp GlwCtl_tiLmp_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    GlwCtl_AxisPoints
    ""


/end FUNCTION

/begin FUNCTION

    GlwCtl_PwrCtl
    ""

    /begin DEF_CHARACTERISTIC
      GlwCtl_dwEnrgSlp_CUR GlwCtl_numAirTempPwrCtl_C GlwCtl_swtClgMode_C GlwCtl_swtEnrgPreEnaVal_C GlwCtl_swtEnrgPstEna_C GlwCtl_swtRlsPshDisbl_C
      GlwCtl_swtSelUOut_C GlwCtl_swtStrt_C GlwCtl_tiClgHi_C GlwCtl_tiClgLo_C GlwCtl_tiHiPreGlwPrectl_CUR GlwCtl_tiRdy1_C
      GlwCtl_tThresSwtTClg_C GlwCtl_uGlwPlgHiPreGlwPrectl_CUR GlwCtl_uGlwPlgHiPreGlw_CUR GlwCtl_uHiPreGlwOfs_C GlwCtl_uNomGlwPlg_C GlwCtl_uOutItm_MAP
      GlwCtl_uOut_CUR GlwCtl_uOut_MAP GlwCtl_uPresPstCor_MAP GlwCtl_uPstCor_MAP GlwCtl_uStrt_C GlwCtl_uTIndPstCor_MAP
      GlwCtl_wEnrgPre_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AirSys_tFld BattU_uSens EnvP_p EpmCrS_ctRevStrt Epm_nEng GlwCtl_qInjQnt
      GlwCtl_stGlw GlwCtl_tEng
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      GlwCtl_stAftRunDelDem GlwCtl_stPshRd GlwCtl_stPshWr GlwCtl_swtGlwPlgMode GlwCtl_uGlwPlgRaw
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      GlwCtl_stAftDemClgTmr_mp GlwCtl_stAftEnrgInteg_mp GlwCtl_stAftRunXPostDrv_mp GlwCtl_stHiPreGlwActv_mp GlwCtl_stHiPreGlwEnbl_mp GlwCtl_stPshDisbl_mp
      GlwCtl_stPshRdStrt_mp GlwCtl_stPshWrInteg_mp GlwCtl_stPshWrTmr_mp GlwCtl_stTmr_mp GlwCtl_tAirPwrCtl_mp GlwCtl_tiHiPreGlwPrectl_mp
      GlwCtl_uGlwPlgHiPreGlwRaw_mp GlwCtl_uGlwPlgHiPreGlw_mp GlwCtl_uOutGlw_mp GlwCtl_uOutItm_mp GlwCtl_uOutPst_mp GlwCtl_uOutRdyPre_mp
      GlwCtl_uOutRdy_mp GlwCtl_uOut_mp GlwCtl_uPresPstCor_mp GlwCtl_uPstCor_mp GlwCtl_uTIndPstCor_mp GlwCtl_wEnrgPre_mp
      GlwCtl_wIntegEnrg_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    GlwCtl_StM
    ""

    /begin DEF_CHARACTERISTIC
      GlwCtl_nPre_C GlwCtl_nPst_C GlwCtl_nRdy_C GlwCtl_nThresPre_C GlwCtl_numAirTempStM_C GlwCtl_numEngTempStM_C
      GlwCtl_numInjQnt_C GlwCtl_qPstAdj_C GlwCtl_qPst_CUR GlwCtl_qThresFlQnt_C GlwCtl_qThresFl_C GlwCtl_swtWakeUpPrs_C
      GlwCtl_tAdjMax_C GlwCtl_tAdjMin_C GlwCtl_tDflEng_C GlwCtl_tiChk_C GlwCtl_tiDebPre_C GlwCtl_tiDebT50_C
      GlwCtl_tiGlwMax_C GlwCtl_tiPre1_MAP GlwCtl_tiPre2_MAP GlwCtl_tiPst_MAP GlwCtl_tiRdy_CUR GlwCtl_tiStrt_C
      GlwCtl_tiThresFl1_CUR GlwCtl_tiThresFl2_C GlwCtl_tiThresFlNoPst_C GlwCtl_tStrt_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AirSys_tFld Air_tAFS CEngDsT_t CoEng_st EngDa_tFld EnvP_p
      Epm_nEng InjCtl_qCurr InjCtl_qRaw InjCtl_qSetUnBal T50_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      GlwCtl_qInjQnt GlwCtl_stGlw GlwCtl_tEng GlwCtl_tEngAdj GlwCtl_tiPreGlwRmn
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      GlwCtl_qNoPst_mp GlwCtl_qPst_mp GlwCtl_stAllw_mp GlwCtl_tAirStM_mp GlwCtl_tiPre_mp GlwCtl_tiPst_mp
      GlwCtl_tiRdy_mp GlwCtl_tiThresFl1_mp GlwCtl_tTempVal_mp GlwCtl_tValEEP_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    GlwPlg_DD
    ""

    /begin DEF_CHARACTERISTIC
      GlwPlg_DigOut.tiBtwTstSCB_C GlwPlg_DigOut.tiBtwTstOT_C GlwPlg_DigOut.numTstMax_C GlwPlg_numTstMax_C GlwPlg_Pwm.tiPer_C GlwPlg_Pwm.stLvl_C
      GlwPlg_Pwm.rMaxDty_C GlwPlg_Pwm.rPerUn_C GlwPlg_Pwm.tiPh_C GlwPlg_rLVSCod_C GlwPlg_rLVSMax_C GlwPlg_rLVSMin_C
      GlwPlg_stPsDiaDisbl_C GlwPlg_stPsDisbl_C GlwPlg_swtBattCorEna_C GlwPlg_swtCodRdy_C GlwPlg_tiBtwTstOT_C GlwPlg_tiBtwTstSCB_C
      GlwPlg_uBattLim_C GlwPlg_uHysLsp_C GlwPlg_uHysRsp_C GlwPlg_uRef_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_uSens DevLib_stPwrStgEnaCond GlwCtl_swtGlwPlgMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      GlwPlg_rLVS GlwPlg_rLVSPs GlwPlg_stPs GlwPlg_u
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    GlwPlg_DD_PWMIn
    ""

    /begin DEF_CHARACTERISTIC
      GlwPlg_dcycPwmInMax_C GlwPlg_dcycPwmInMin_C GlwPlg_rThresDiaHi_C GlwPlg_rThresDiaLo_C GlwPlg_rThresDiaSumHi_C GlwPlg_rThresDiaSumLo_C
      GlwPlg_tiDelRLVSPs_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      GlwCtl_swtGlwPlgMode GlwPlg_rLVSPs
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      GlwPlg_rGCUFdbk
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      GlwPlg_stPwmInErr_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Gpta
    ""


/end FUNCTION

/begin FUNCTION

    HCUn_DD
    ""

    /begin DEF_CHARACTERISTIC
      HCVlv_DigOut.tiBtwTstSCB_C HCVlv_DigOut.tiBtwTstOT_C HCVlv_DigOut.numTstMax_C HCVlv_stPsDiaDisbl_C HCVlv_stPsDisbl_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      DevLib_stPwrStgEnaCond HCVlv_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      HCVlv_stPs
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    HESrv_Lib
    ""

    /begin DEF_CHARACTERISTIC
      HESrv_swtPOpVis_C HESrv_swtScndFlwActv_C
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    HESrv_MacroDef
    ""


/end FUNCTION

/begin FUNCTION

    HESrv_MSid
    ""

    /begin OUT_MEASUREMENT
      HESrv_stMSid
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    I14230_Reset
    ""


/end FUNCTION

/begin FUNCTION

    I14230_Tpr
    ""


/end FUNCTION

/begin FUNCTION

    IfxFlash
    ""


/end FUNCTION

/begin FUNCTION

    InCbiFui_Dataxxx
    ""

    /begin IN_MEASUREMENT
      FuelT_tFlSys
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vxx_fuel_temp Vxx_pump_tql
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InCbiFui_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_dies_wat_det Vbx_min_fuel Vsx_min_fuel_vld Vsx_sens_fuel_temp_vld Vxx_fuel_temp Vxx_pump_tql
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InCbiFui_Minfuxx
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_min_fuel_dly Cxx_no_min_fuel_dly
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_min_fuel Vbx_mux_min_fuel_raw_prev Vsx_min_fuel_vld Vxx_min_fuel_dly Vxx_min_fuel_dly_prev vxx_time_counter
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      InCbiFui_Minfuxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    InCbiFui_Schedul
    ""

    /begin SUB_FUNCTION
      InCbiFui_Dataxxx InCbiFui_Minfuxx InCbiFui_Tfuxxsr InCbiFui_Wflxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    InCbiFui_Tfuxxsr
    ""

    /begin OUT_MEASUREMENT
      Vsx_sens_fuel_temp_vld
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InCbiFui_Wflxxsr
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_dfdec_sens_wfl_oc Cxx_dfinc_sens_wfl_oc Cxx_n_min_wfl_diag Cxx_vb_wfl_max Cxx_vb_wfl_min Cxx_vs_min_wfl_diag
      Cxx_wait_wfl_authorize_conf Cxx_wait_wfl_auto_conf
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_df_sens_wfl_oc Vbx_dies_wat_det Vbx_sens_wfl_cfm
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_diag_ena_sens_wfl_oc Vbx_wfl_authorize_conf
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      InCbiFui_Wflxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    InCbiRpi_Dataxxx
    ""

    /begin IN_MEASUREMENT
      RailP_pFlt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_rail_prs Vxx_rps_rail_prs_dif
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      InCbiRpi_Dataxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    InCbiRpi_Ex
    ""

    /begin IN_MEASUREMENT
      Vsx_sens_rail_prs_vld Vxx_rail_prs Vxx_rps_rail_prs_dif
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InCbiRpi_Fupxxsr
    ""

    /begin DEF_CHARACTERISTIC
      Cbx_prs_actr_pres_cfm
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vsx_sens_rail_prs_vld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_rail_prs_h_lvl
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InCbiRpi_Schedul
    ""

    /begin SUB_FUNCTION
      InCbiRpi_Dataxxx InCbiRpi_Fupxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    INF_DINH
    ""


/end FUNCTION

/begin FUNCTION

    InjDev_Axispoints
    ""


/end FUNCTION

/begin FUNCTION

    InjDev_GlbDef
    ""


/end FUNCTION

/begin FUNCTION

    InjSys_Axispoints
    ""


/end FUNCTION

/begin FUNCTION

    InjSys_Co
    ""

    /begin DEF_CHARACTERISTIC
      InjSys_ctAirTempRailRgnSel_C InjSys_ctAirTempRailSel_C InjSys_ctAirTempRgnSel_C InjSys_ctAirTempSel_C InjSys_ctEngTempRgnSel_C InjSys_ctEngTempSel_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AirSys_tFld EngDa_tFld
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjSys_stLeadPar InjSys_tAir InjSys_tAirRail InjSys_tAirRailRgn InjSys_tAirRgn InjSys_tEng
      InjSys_tEngRgn
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjSys_CorLib
    ""

    /begin IN_MEASUREMENT
      Epm_nEng InjCtl_qSetUnBal
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjSys_GlbDef
    ""


/end FUNCTION

/begin FUNCTION

    InjSys_ImpInfLib
    ""


/end FUNCTION

/begin FUNCTION

    InjSys_Lib
    ""

    /begin IN_MEASUREMENT
      InjCrv_qPiI1Des InjCrv_qPiI2Des InjCrv_qPiI3Des InjCrv_qPoI1Des InjCrv_qPoI2Des InjCrv_qPoI2Eff
      InjCrv_stInjCharActVal InjSys_qInrCmb InjSys_qOutrCmb
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjUn_MassCnv
    ""

    /begin IN_MEASUREMENT
      FlSys_rhoFlCnvFac FlSys_swtRhoFlCnv
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjUn_StrtTst
    ""

    /begin DEF_CHARACTERISTIC
      InjUn_ctSyncStrtPls_C InjUn_nStrtLim_C InjUn_stShOffStrt_C InjUn_swtStrtPls_C InjUn_tiRailStrtPls_C InjUn_tiShOffStrtPls_C
      InjUn_tiSpdStrtPls_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st CoEng_stShutOffPath Epm_nEng Epm_stOpMode InjUn_stSta T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjUn_stStrt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjUn_stStrtCsBlk_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_AddBal
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_facAddBalRls_MAP
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_ctCyl InjCtl_qSetUnBal RailP_pFlt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjVlv_facAddBalRls
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_AddBalLib
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_facBalMax_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      InjVlv_qMI1Bal_mp InjVlv_qPiI1Bal_mp InjVlv_qPiI2Bal_mp InjVlv_qPiI3Bal_mp InjVlv_qPoI1Bal_mp InjVlv_qPoI2BalEff_mp
      InjVlv_qPoI2Bal_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_AddBalZFC
    ""

    /begin REF_CHARACTERISTIC
      InjVlv_stZFCETCorActv_C InjVlv_swtZFCCorOvrRunOn_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoFOvR_stActvMsg
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_AddBalZFCDpd
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_AddVolCor
    ""


/end FUNCTION

/begin FUNCTION

    injvlv_auto
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_Axispoints
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_CalcMI1ET
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_nETMaxLim_C InjVlv_swtTiMI1ET_C InjVlv_tiETMax_C InjVlv_tiMI1ET_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_tiETMinLow_C
    /end REF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      InjVlv_tiMI1ETUnLim
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_tiMI1ET_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_CalcPiI1ET
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_swtTiPiI1ET_C InjVlv_tiPiI1ET_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_tiETMinLow_C
    /end REF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      InjVlv_tiZFCPiI1ETCor
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_tiPiI1ET_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_CalcPiI2ET
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_swtTiPiI2ET_C InjVlv_tiPiI2ET_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_tiETMinLow_C
    /end REF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      InjVlv_tiZFCPiI2ETCor
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_tiPiI2ET_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_CalcPiI3ET
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_swtTiPiI3ET_C InjVlv_tiPiI3ET_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_tiETMinLow_C
    /end REF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      InjVlv_tiZFCPiI3ETCor
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_tiPiI3ET_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_CalcPoI1ET
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_swtTiPoI1ET_C InjVlv_tiPoI1ET_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_tiETMinLow_C
    /end REF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      InjVlv_tiPoI1ET_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_CalcPoI2ET
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_swtTiPoI2ET_C InjVlv_tiPoI2ET_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_tiETMinLow_C
    /end REF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      InjVlv_tiPoI2ET_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ChrgBalInjLim
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_numInjChrgBalRC_C InjVlv_numInjChrgBal_CUR InjVlv_numInjDesRC_C InjVlv_pwrDCDCMax_CUR InjVlv_pwrDCDCOvrLdMax_CUR InjVlv_rChrgBalInjHys_C
      InjVlv_rOvrLdRlx_C InjVlv_swtNumInjRC_C InjVlv_tiOvrLdMax_C InjVlv_tiWaitActv_C InjVlv_wInj_CUR InjVlv_xOvrLdRlxThresh_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_u Epm_nEng IVActr_facWActrDvtAvrg IVCtl_uUp
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjVlv_numInjChrgBal InjVlv_xIntegOvrLd
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_frqTDC_mp InjVlv_numCylECU_mp InjVlv_numInjChrgBalLim_mp InjVlv_numInjChrgBalRaw_mp InjVlv_numInjDes_mp InjVlv_numInjOvrLdRaw_mp
      InjVlv_numInjOvrLd_mp InjVlv_pwrDCDCMax_mp InjVlv_pwrDCDCOvrLdMax_mp InjVlv_pwrInjAvrg_mp InjVlv_stOvrLdRls_mp InjVlv_tiWaitAct_mp
      InjVlv_uSetUpAvrg_mp InjVlv_wInjCorr_mp InjVlv_wInjNom_mp InjVlv_xIntegOvrLdOff_mp InjVlv_xIntegOvrLdOn_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_EstET
    ""

    /begin REF_CHARACTERISTIC
      InjVlv_tiETMinLow_C
    /end REF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    InjVlv_GetBgn
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_GetET
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_swtInputETMAP_C InjVlv_tiETPoI2_MAP InjVlv_tiET_MAP
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      InjVlv_pInET_mp InjVlv_volInET_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_GetInfo
    ""

    /begin IN_MEASUREMENT
      Epm_numCyl
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_GetInjInfo
    ""

    /begin IN_MEASUREMENT
      Epm_numCyl
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_GlbDef
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_HDIni
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_tiWup2On_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_tiETMinLow_C
    /end REF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    InjVlv_HDLib
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_numBnkTDC_CA InjVlv_numECUTDC_CA InjVlv_numPsTDC_CA
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    InjVlv_InjCo
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_stInjCoRC_C InjVlv_swtInjCoRC_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      InjVlv_stPrep IVDia_stTst IVDia_stTstActv IVPSIC_stIntegAdjStM IVPSply_stDCDCCo MoCSOP_stRdyMsg
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjVlv_stInjCo
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_stInjCoRun_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_InjRls
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_stInjCharComp_C InjVlv_stInjRls_CA
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_ctCyl InjCrv_stInjCharComp InjCrv_stInjCharShOffTst InjCrv_stStMShOffTst MoCSOP_stRdyMsg
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjVlv_stInjCharComp InjVlv_stInjRls
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_MI1CSCETCor
    ""

    /begin REF_CHARACTERISTIC
      InjVlv_tiETMax_C InjVlv_tiETMinLow_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_stShutOffPath Epm_ctCyl Epm_nEng InjCtl_qSetUnBal InjVlv_tiMI1ETUnLim TrqInrCtl_r
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_MI1DynQntCor
    ""

    /begin LOC_MEASUREMENT
      InjVlv_ctCylMI1_mp InjVlv_qMI1Cor_mp InjVlv_volMI1Cor_mp InjVlv_volMI1QntAdj_mp InjVlv_volMI1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_MI1ZFCCor
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_MI2DynQntCor
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_PiI1DynQntCor
    ""

    /begin LOC_MEASUREMENT
      InjVlv_ctCylPiI1_mp InjVlv_qPiI1Cor_mp InjVlv_volPiI1Cor_mp InjVlv_volPiI1QntAdj_mp InjVlv_volPiI1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_PiI2DynQntCor
    ""

    /begin LOC_MEASUREMENT
      InjVlv_ctCylPiI2_mp InjVlv_qPiI2Cor_mp InjVlv_volPiI2Cor_mp InjVlv_volPiI2QntAdj_mp InjVlv_volPiI2_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_PiI3DynQntCor
    ""

    /begin LOC_MEASUREMENT
      InjVlv_ctCylPiI3_mp InjVlv_qPiI3Cor_mp InjVlv_volPiI3Cor_mp InjVlv_volPiI3QntAdj_mp InjVlv_volPiI3_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_PoI1DynQntCor
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_qPoI1Min_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      InjVlv_ctCylPoI1_mp InjVlv_qPoI1Cor_mp InjVlv_volPoI1Cor_mp InjVlv_volPoI1QntAdj_mp InjVlv_volPoI1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_PoI1ZFCCor
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_PoI2DynQntCor
    ""

    /begin LOC_MEASUREMENT
      InjVlv_ctCylPoI2_mp InjVlv_qPoI2Cor_mp InjVlv_volPoI2Cor_mp InjVlv_volPoI2QntAdj_mp InjVlv_volPoI2_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_PoI2ZFCCor
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_Prep
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_numPrep_C InjVlv_pPrepMax_C InjVlv_stPrepRC_C InjVlv_swtPrepRC_C InjVlv_tiChrgPrep_CUR InjVlv_tiDisChPrep_CUR
      InjVlv_tiETPrep_CUR InjVlv_tPrepMax_C InjVlv_uUpPrep_CUR
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_numBnkTDC_CA
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      InjVlv_stInjCo IVActr_tActr IVPSply_stBufErr RailP_pFlt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjVlv_stPrep InjVlv_tiChrgPrep InjVlv_tiDisChPrep InjVlv_uUpPrep
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_numPrepLeft_mp InjVlv_stPrepInjErr_mp InjVlv_stPrepInjOK_mp InjVlv_stPrepPreCond_mp InjVlv_tiETPrep_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_PresMin
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_pMin_C InjVlv_pMin_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st EngDa_tEng RailP_pFlt Rail_stCtlLoop
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ProgETLib
    ""

    /begin LOC_MEASUREMENT
      InjVlv_stInjMI1_mp InjVlv_stInjMI2_mp InjVlv_stInjPiI1_mp InjVlv_stInjPiI2_mp InjVlv_stInjPiI3_mp InjVlv_stInjPoI1_mp
      InjVlv_stInjPoI2_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ProgETZFC
    ""

    /begin LOC_MEASUREMENT
      InjVlv_stInjZFC_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ProgMI
    ""

    /begin LOC_MEASUREMENT
      InjVlv_ctMI1AgDiff_mp InjVlv_phiMI1Diff_mp InjVlv_stInjCharPrg_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ProgPiI
    ""

    /begin REF_CHARACTERISTIC
      InjVlv_swtEnaAgDiff_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_stShutOffPath Epm_ctCyl Epm_nEng Epm_numCyl FBC_q FlSys_rhoFl
      InjCrv_phiPiI1Des InjCrv_phiPiI2Des InjCrv_phiPiI3Des InjCrv_qPiI1Des InjCrv_qPiI2Des InjCrv_qPiI3Des
      InjCrv_stInjCharActVal InjCrv_tiPiI1Des InjCrv_tiPiI2Des InjCtl_qSetUnBal InjVlv_facAddBalRls InjVlv_tiOfsSOEHyd
      InjVlv_volPiI1CorCyc InjVlv_volPiI2CorCyc QWC_facFTS QWC_st RailP_pFlt
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_ctPiI1AgDiff_mp InjVlv_phiPiI1Diff_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ProgPiI2
    ""

    /begin REF_CHARACTERISTIC
      InjVlv_swtEnaAgDiff_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_ctCyl Epm_nEng
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_ctPiI2AgDiff_mp InjVlv_phiPiI2Diff_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ProgPiI3
    ""

    /begin REF_CHARACTERISTIC
      InjVlv_swtEnaAgDiff_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_ctCyl Epm_nEng
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_ctPiI3AgDiff_mp InjVlv_phiPiI3Diff_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ProgPoI1
    ""

    /begin IN_MEASUREMENT
      InjVlv_tiOfsSOEHyd
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ProgPoI2
    ""

    /begin IN_MEASUREMENT
      InjVlv_tiOfsSOEHyd
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_ProgZFC
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_PsICLib
    ""

    /begin IN_MEASUREMENT
      Epm_numCyl
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_Sched
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_PZOSW_C InjVlv_swtAgTi2AgMode_C InjVlv_swtEnaAgDiff_C InjVlv_tiETMinLow_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      IVDia_tiETTst_C IVH_iChrgSOPT_C IVH_iDisChSOPT_C IVH_tiChrgSOPT_C IVH_tiETSOPT_C IVH_tiPseChrgSOPT_C
      IVH_tiPseDisChSOPT_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_stShutOffPath Epm_nEng Epm_numCyl FBC_qArr FlSys_rhoFl InjCrv_qMI1Des
      InjCrv_qPiI1Des InjCrv_qPiI2Des InjCrv_qPiI3Des InjCrv_qPoI1Splt InjCrv_qPoI2Des InjCrv_qPoI2Eff
      InjCrv_stInjCharActVal InjCtl_qSetUnBal InjVlv_facAddBalRls InjVlv_stInjCo IVCtl_tiChrg IVCtl_tiPseChrg
      IVCtl_tiPseDisCh IVDia_stTst QWC_facFTS QWC_qNorm QWC_st RailP_pFlt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjVlv_tiMIIntr InjVlv_volMI1CorCyc InjVlv_volPiI1CorCyc InjVlv_volPiI2CorCyc InjVlv_volPoI1CorCyc InjVlv_volPoI2CorCyc
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_stInjClsnPerm_mp InjVlv_stInjClsn_mp InjVlv_stTCtlInj_mp InjVlv_volPoI2NoCorCyc_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_SetBgn
    ""

    /begin IN_MEASUREMENT
      Epm_numCyl Epm_stOpMode
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_SetDur
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_SetImmdInj
    ""

    /begin REF_CHARACTERISTIC
      InjVlv_numBnkTDC_CA InjVlv_numPsTDC_CA
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_SetTiPse
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_tiPause_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      InjVlv_tiPse
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_SetupInjProc
    ""

    /begin IN_MEASUREMENT
      Epm_numCyl
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_SOEHydCor
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_tiOfsSOEHyd_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      RailP_pFlt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjVlv_tiOfsSOEHyd
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_SOELib
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_swtSOERngChk_C InjVlv_tiSOERngThresMax_C InjVlv_tiSOERngThresMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_tiSOERngCor_mp InjVlv_tiSOERngDiff_mp InjVlv_tiSOERngDst_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_SPIIni
    ""

    /begin REF_CHARACTERISTIC
      InjVlv_numBnkTDC_CA
    /end REF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      InjVlv_stPsIcErrCom InjVlv_stPsIcErrIlse InjVlv_stPsIcIniDiag InjVlv_stPsIcIniTrans
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_stPsIcChipVer_mp InjVlv_stPsIcIni_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_SPIInjDia
    ""

    /begin LOC_MEASUREMENT
      InjVlv_stPsIcDiaBnk1_mp InjVlv_stPsIcDiaBnk2_mp InjVlv_stPsIcNumBnkPcP_mp InjVlv_stPsIcNumBnk_mp InjVlv_stPsIcNumChipPcP_mp InjVlv_stPsIcNumChip_mp
      InjVlv_stPsIcStBufDatEx_mp InjVlv_stPsIcStBufTraInj_mp InjVlv_stPsIcTraEvSyn_mp InjVlv_stPsIcTra_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    InjVlv_SPILib
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_SPIMemChk
    ""


/end FUNCTION

/begin FUNCTION

    InjVlv_ZFCETCor
    ""

    /begin DEF_CHARACTERISTIC
      InjVlv_pRailZFCETCor_AXIS InjVlv_qZFCETCor_AXIS InjVlv_rZFCETDif0_GMAP InjVlv_rZFCETDif1_GMAP InjVlv_rZFCETDif2_GMAP InjVlv_rZFCETMsk_GMAP
      InjVlv_stInputZFCETGMap_C InjVlv_stZFCETCorActv_C InjVlv_swtZFCCorOvrRunOn_C InjVlv_tiZFCETCorMax_C InjVlv_tiZFCETCorMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoFOvR_stActvMsg RailP_pCurr_mp
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjVlv_qInZFCETGMap_mp InjVlv_rZFCETCoeffDif_mp InjVlv_rZFCETCoeffMsk_mp InjVlv_tiPiI1ZFCETCor_mp InjVlv_tiPiI2ZFCETCor_mp InjVlv_tiPiI3ZFCETCor_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IsoTpAppl_Std
    ""


/end FUNCTION

/begin FUNCTION

    IsoTp_Std
    ""


/end FUNCTION

/begin FUNCTION

    IVActr_Enrg
    ""

    /begin DEF_CHARACTERISTIC
      IVActr_facWActrChCor_C IVActr_facWActrCor_C IVActr_facWActrDisChCor_C IVActr_facWActrDvtAvrgRC_C IVActr_facWActrDvtMax_C IVActr_facWActrDvtMin_C
      IVActr_facWActrMax_C IVActr_facWActrMin_C IVActr_facWActrTemp_CUR IVActr_numFacWVldMin_C IVActr_stActrEnrgRC_C IVActr_swtActrEnrgEnaRC_C
      IVActr_swtActrEnrgRC_C IVActr_swtEnaWActrCor_C IVActr_swtFacWActrDvtAvrgRC_C IVActr_swtNewMeasRC_C IVActr_tiEnrgIntegAdjMax_C IVActr_uBotDfl_C
      IVActr_wActrChDfl_C IVActr_wActrDisChDfl_C IVActr_wActrNom_CUR IVActr_wActrPlausMax_C IVActr_wActrPlausMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl IVActr_ch IVActr_stCh IVActr_stUChrgUp IVActr_stUUp IVActr_tActr
      IVActr_tiActrMeasCurr IVActr_uChrgUp IVActr_uUp IVDia_stUPlausCyl IVPSIC_tiIntegAdj
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVActr_facWActrDvtAvrg IVActr_stActrEnrg IVActr_tiEnrgCalc
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVActr_facWActrDvtUnCor_mp IVActr_facWActrDvt_mp IVActr_facWActrTemp_mp IVActr_numFacWVld_mp IVActr_tiDiffActrInteg_mp IVActr_uChUpInCur_mp
      IVActr_wActrDiff_mp IVActr_wActrNomCor_mp IVActr_wActrNom_mp IVActr_wChActrRaw_mp IVActr_wDisChActrRaw_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVActr_GetMeas
    ""

    /begin DEF_CHARACTERISTIC
      IVActr_chRC_C IVActr_pRailLnkRC_C IVActr_resCalcChShunt_C IVActr_stChRC_C IVActr_stTiDisChRC_C IVActr_stTiETMeasRC_C
      IVActr_stUChrgUpRC_C IVActr_stUDisChStopRC_C IVActr_stUUpRC_C IVActr_swtChRC_C IVActr_swtGetMeasRC_C IVActr_swtPRailLnkRC_C
      IVActr_swtTiChrgLnkRC_C IVActr_swtTiDisChLnkRC_C IVActr_swtTiDisChRC_C IVActr_swtTiETMeasRC_C IVActr_swtUChrgUpRC_C IVActr_swtUDisChStopRC_C
      IVActr_swtUUpLnkRC_C IVActr_swtUUpRC_C IVActr_tiActrMeasTOut_C IVActr_tiChrgLnkRC_C IVActr_tiDisChLnkRC_C IVActr_tiDisChRC_C
      IVActr_tiETMeasRC_C IVActr_tiMax_C IVActr_tiMin_C IVActr_uActrLin_CUR IVActr_uChrgUpRC_C IVActr_UCh_SRC.uMin_C
      IVActr_UCh_SRC.uMax_C IVActr_uDisChStopRC_C IVActr_uUpLnkRC_CA IVActr_uUpRC_C IVActr_Vltg_SRC.uMin_C IVActr_Vltg_SRC.uMax_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      InjVlv_stInjCo InjVlv_tiMIIntr IVCtl_p IVCtl_tiChrg IVCtl_tiDisCh IVCtl_uUp
      IVPSIC_stIntegAdjVld IVPSIC_tiIntegRC IVPSIC_uIntegOfs IVPSIC_uIntegWrkPnt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVActr_ch IVActr_chnImmdMeas IVActr_numCylMeasNxt IVActr_pRailLnk IVActr_stCh IVActr_stGetImmdMeas
      IVActr_stGetMeas IVActr_stMeasDisbl IVActr_stMeasTyp IVActr_stTiDisCh IVActr_stTiETMeas IVActr_stUChrgUp
      IVActr_stUDisChStop IVActr_stUUp IVActr_tiActrMeasCurr IVActr_tiChrgLnk IVActr_tiDisCh IVActr_tiDisChLnk
      IVActr_tiETMeas IVActr_uChrgUp IVActr_uDisChStop IVActr_uUp IVActr_uUpLnk
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVActr_stMeasEna_mp IVActr_tiActrMeasTmr_mp IVActr_uActrRaw_mp IVActr_uCh_mp IVActr_uImmdMeasRaw_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVActr_Temp
    ""

    /begin DEF_CHARACTERISTIC
      IVActr_tActrDfl_C IVActr_tActr_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CEngDsT_t
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVActr_tActr
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVAdj_Co
    ""

    /begin DEF_CHARACTERISTIC
      IVAdj_stQntAdj_MAP IVAdj_stRawValRepl_C IVAdj_swtDiaIVAdj_C IVAdj_swtRawValRepl_C IVAdj_volQntAdjLim_C IVAdj_volQntAdjMax0_C
      IVAdj_volQntAdjMax1_C IVAdj_volQntAdjMax2_C IVAdj_volQntAdjMax3_C IVAdj_volQntAdjMin0_C IVAdj_volQntAdjMin1_C IVAdj_volQntAdjMin2_C
      IVAdj_volQntAdjMin3_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl InjVlv_volMI1Cor_mp RailP_pFlt
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVAdj_stChkSumErrAdj_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVAdj_CoLib
    ""

    /begin DEF_CHARACTERISTIC
      IVAdj_numClsIVAMax_C IVAdj_numClsIVAMin_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      IVAdj_clsIVA IVAdj_stIVAErr
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVAdj_stChkErr_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVAdj_NVC
    ""

    /begin DEF_CHARACTERISTIC
      IVAdj_facCtNVCEna_C IVAdj_facNVCDflI_C IVAdj_facNVCInPI_C IVAdj_facNVCMax_C IVAdj_facNVCMin_C IVAdj_facNVCRC_CA
      IVAdj_INVC_CSTR.Ki_C IVAdj_INVC_CSTR.KiPos_C IVAdj_INVC_CSTR.KiNeg_C IVAdj_INVC_CSTR.WinPos_C IVAdj_INVC_CSTR.WinNeg_C IVAdj_mskInjCharNVC_C
      IVAdj_mskStUChrgUpNVC_C IVAdj_mskStUUpNVC_C IVAdj_numCylRC_C IVAdj_pMaxNVC_C IVAdj_pMinNVC_C IVAdj_PNVC_CSTR.Kp_C
      IVAdj_PNVC_CSTR.KpPos_C IVAdj_PNVC_CSTR.KpNeg_C IVAdj_PNVC_CSTR.WinPos_C IVAdj_PNVC_CSTR.WinNeg_C IVAdj_stGovInitRC_C IVAdj_swtFacNVCRC_C
      IVAdj_swtNVCGovInitRC_C IVAdj_tActrMaxNVC_C IVAdj_tActrMinNVC_C IVAdj_tiMeasUUpThresNVC_C IVAdj_tiPIDisChThresNVC_C IVAdj_uDiffNVCSet_CUR
      IVAdj_uPIVltgThresNVC_C IVAdj_valSrcPtrRC_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl InjCrv_stInjCharActVal IVActr_pRailLnk IVActr_stUChrgUp IVActr_stUUp IVActr_tActr
      IVActr_tiActrMeasCurr IVActr_tiETMeas IVActr_uChrgUp IVActr_uUp IVCtl_tiChrg IVCtl_tiDiff
      IVCtl_uDiffUp
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVAdj_facNVC
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVAdj_ctNVCEna_mp IVAdj_facNVCEepWrI_mp IVAdj_facNVCInitI_mp IVAdj_pDiffNVCSetCURIn_mp IVAdj_stNVCCond_mp IVAdj_stNVCEna_mp
      IVAdj_stNVCGovInit_mp IVAdj_stNVCRls IVAdj_tiNVCGovCalc IVAdj_uDiffNVCInPI_mp IVAdj_uDiffNVCSet_mp IVAdj_uDiffNVC_mp
      IVAdj_valDestPtr_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVCtl_TGov
    ""

    /begin DEF_CHARACTERISTIC
      IVCtl_iPIMax_C IVCtl_iPIMin_C IVCtl_ITGov_CSTR.Ki_C IVCtl_ITGov_CSTR.KiPos_C IVCtl_ITGov_CSTR.KiNeg_C IVCtl_ITGov_CSTR.WinPos_C
      IVCtl_ITGov_CSTR.WinNeg_C IVCtl_mskTGov_C IVCtl_PTGov_CSTR.Kp_C IVCtl_PTGov_CSTR.KpPos_C IVCtl_PTGov_CSTR.KpNeg_C IVCtl_PTGov_CSTR.WinPos_C
      IVCtl_PTGov_CSTR.WinNeg_C IVCtl_tiDiffOBDDvt_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl IVActr_stTiDisCh IVActr_tiActrMeasCurr IVActr_tiDisCh IVActr_tiDisChLnk IVCtl_tiChrg
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVCtl_iCorPI IVCtl_tiDiff
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVCtl_iCorPIUnLim_mp IVCtl_stTGovPIHi_mp IVCtl_stTGovPILo_mp IVCtl_tiTGovCalc
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVCtl_TSetP
    ""

    /begin DEF_CHARACTERISTIC
      IVCtl_iDisCh_MAP IVCtl_tiChrg_CUR IVCtl_tiDisCh_CUR IVCtl_tiPseChrg_CUR IVCtl_tiPseDisCh_CUR
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      IVDia_tiChrgTst_C IVDia_tiDisChTst_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      InjVlv_stInjCo InjVlv_tiChrgPrep InjVlv_tiDisChPrep IVCtl_iCorPI IVCtl_p IVCtl_uUp
      RailP_pFlt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVCtl_tiChrg IVCtl_tiDisCh IVCtl_tiPseChrg IVCtl_tiPseDisCh
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVCtl_iDisChUnCor_mp IVCtl_iDisCh_mp IVCtl_uUpMapIn_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVCtl_VltgCo
    ""

    /begin DEF_CHARACTERISTIC
      IVCtl_facVltgTempCor_CUR IVCtl_iChrgRC_CA IVCtl_iChrg_MAP IVCtl_pRC_CA IVCtl_swtIChrgRC_C IVCtl_swtPRC_C
      IVCtl_uCorPreCtl_CUR IVCtl_uUpOBDMax_CUR IVCtl_uUpOBDMin_CUR
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      IVDia_uUpTst_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl InjVlv_stInjCo InjVlv_uUpPrep IVActr_tActr IVAdj_clsIVA IVAdj_facNVC
      IVCtl_stStrt IVCtl_tiChrg IVCtl_uCorPI IVCtl_uUpStrt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVCtl_p IVCtl_stOBDErr IVCtl_uUp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVCtl_facVltgTempCor IVCtl_iChrg_mp IVCtl_uChrgMapIn_mp IVCtl_uChrgUp_mp IVCtl_uCorPreCtl_mp IVCtl_uUpOBDMax_mp
      IVCtl_uUpOBDMin_mp IVCtl_uUpUnCor_mp IVCtl_uUpUnLim_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVCtl_VltgGov
    ""

    /begin DEF_CHARACTERISTIC
      IVCtl_facUDiffUpPlausMax_C IVCtl_IVltgGov_CSTR.Ki_C IVCtl_IVltgGov_CSTR.KiPos_C IVCtl_IVltgGov_CSTR.KiNeg_C IVCtl_IVltgGov_CSTR.WinPos_C IVCtl_IVltgGov_CSTR.WinNeg_C
      IVCtl_mskVltgGov_C IVCtl_PVltgGov_CSTR.Kp_C IVCtl_PVltgGov_CSTR.KpPos_C IVCtl_PVltgGov_CSTR.KpNeg_C IVCtl_PVltgGov_CSTR.WinPos_C IVCtl_PVltgGov_CSTR.WinNeg_C
      IVCtl_uDiffUpOBDDvt_C IVCtl_uPIMax_C IVCtl_uPIMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl IVActr_stUUp IVActr_tiActrMeasCurr IVActr_uUp IVActr_uUpLnk IVCtl_p
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVCtl_uCorPI IVCtl_uDiffUp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVCtl_stUDiffUpImPlaus_mp IVCtl_stVltgGovPIHi_mp IVCtl_stVltgGovPILo_mp IVCtl_tiVltgGovCalc IVCtl_uCorPIUnLim_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVCtl_VltgSetP
    ""

    /begin DEF_CHARACTERISTIC
      IVCtl_uSetPress0_CUR IVCtl_uSetPress10_CUR IVCtl_uSetPress11_CUR IVCtl_uSetPress12_CUR IVCtl_uSetPress13_CUR IVCtl_uSetPress14_CUR
      IVCtl_uSetPress15_CUR IVCtl_uSetPress1_CUR IVCtl_uSetPress2_CUR IVCtl_uSetPress3_CUR IVCtl_uSetPress4_CUR IVCtl_uSetPress5_CUR
      IVCtl_uSetPress6_CUR IVCtl_uSetPress7_CUR IVCtl_uSetPress8_CUR IVCtl_uSetPress9_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      IVAdj_clsIVA IVCtl_p
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVCtl_VltgStrt
    ""

    /begin DEF_CHARACTERISTIC
      IVCtl_tiStrtMax_C IVCtl_uUpStrt_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVCtl_stStrt IVCtl_uUpStrt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVCtl_tiStrt_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVDia_Co
    ""

    /begin DEF_CHARACTERISTIC
      IVDia_numMinCylOk_C IVDia_stDFCChp_C IVDia_stDFCCylNoCls_C IVDia_stErrDFC_CA IVDia_stErrMskPattern_CA IVDia_stErrMskSelect_CA
      IVDia_uShCirChSwtThres_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_numBnkTDC_CA
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl InjVlv_stInjCo InjVlv_stPsIcErrCom InjVlv_stPsIcErrIlse InjVlv_tiMIIntr IVActr_tiActrMeasCurr
      IVDia_stUPlausBnk IVDia_stUPlausCyl IVPSply_stBufErr
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVDia_st IVDia_stChkShCirChSwt IVDia_stPsIcChp IVDia_stPsIcCyl IVDia_stPsIcMICyl IVDia_stShCirChSwt
      IVDia_tiMIPsIc
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVDia_ctDebShCirChSwt IVDia_stClctComplInvldCyl_mp IVDia_stCylSync_mp IVDia_stDFCPtt_mp IVDia_stErrClctChp_mp IVDia_stErrClctComplCyl_mp
      IVDia_stErrClctPsIcCyl_mp IVDia_stErrCyl_mp IVDia_stOnlyNeedPsIc_mp IVDia_stRlsDFCRecgCompl_mp IVDia_stRlsDFCRecgPsIc_mp IVDia_stRlsErrRecgCompl_mp
      IVDia_stRlsErrRecgPsIc_mp IVDia_tiEval_mp IVDia_uMonShCirChSwt_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVDia_Plaus
    ""

    /begin DEF_CHARACTERISTIC
      IVDia_facUPlaus_CA IVDia_uUpHi1Thres_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_numBnkTDC_CA
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      IVActr_tiActrMeasCurr
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVDia_stUPlausBnk IVDia_stUPlausCyl
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVDia_uThres_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVDia_Tst
    ""

    /begin DEF_CHARACTERISTIC
      IVDia_numTst_C IVDia_pTstMax_C IVDia_stTstActvRC_C IVDia_stTstRC_C IVDia_swtStTstActvRC_C IVDia_swtStTstRC_C
      IVDia_tiChrgTst_C IVDia_tiDisChTst_C IVDia_tiETTst_C IVDia_uUpTst_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_numBnkTDC_CA
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st Epm_numCyl InjVlv_stInjCo IVPSply_stBufErr RailP_pFlt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVDia_stTst IVDia_stTstActv IVDia_stTstBnkShCir IVDia_stTstBnkShCirChSwt IVDia_stTstChp IVDia_stTstCylNoCls
      IVDia_stTstCylNoLd IVDia_stTstCylShCir IVDia_stTstCylShCirHSLS IVDia_stTstCylShCirMeas
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVDia_numTstLeft_mp IVDia_stTstPreCond_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVH_ADCInt
    ""

    /begin IN_MEASUREMENT
      IVActr_chnImmdMeas
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVH_BusyInt
    ""

    /begin IN_MEASUREMENT
      IVActr_numCylMeasNxt
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVH_Ini
    ""

    /begin IN_MEASUREMENT
      IVActr_numCylMeasNxt
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVH_ProgSOIInt
    ""

    /begin IN_MEASUREMENT
      Epm_stOpMode
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVH_SetupInjInt
    ""


/end FUNCTION

/begin FUNCTION

    IVH_SOPTst
    ""

    /begin DEF_CHARACTERISTIC
      IVH_iChrgSOPT_C IVH_iDisChSOPT_C IVH_tiChrgSOPT_C IVH_tiETSOPT_C IVH_tiPseChrgSOPT_C IVH_tiPseDisChSOPT_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      InjVlv_numBnkTDC_CA
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_numCyl InjVlv_stInjCo
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVH_SPIInt
    ""

    /begin DEF_CHARACTERISTIC
      IVH_tiBusyMax_C
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    IVH_WupInt
    ""


/end FUNCTION

/begin FUNCTION

    IVPlaus_ComprTst
    ""

    /begin DEF_CHARACTERISTIC
      IVPlaus_nEngDiffComprTst_C IVPlaus_nMinComprTst_C IVPlaus_phiPreTDCComprTst1_C IVPlaus_phiPreTDCComprTst2_C IVPlaus_phiPstTDCComprTst3_C IVPlaus_phiPstTDCComprTst4_C
      IVPlaus_tiMaxComprTst_C IVPlaus_uMinBattComprTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_u EpmSeq_numInt EpmSyn_phiInt Epm_ctCyl Epm_nEng Epm_numCyl
      VehV_v
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVPlaus_cntNSyncS0_mp IVPlaus_cntNSyncS1_mp IVPlaus_nEngDiffComprTst IVPlaus_nEngDiffComprTst_mp IVPlaus_nMinComprTst IVPlaus_numMn2PrevTDCComprTst_mp
      IVPlaus_numPi2PrevTDCComprTst_mp IVPlaus_phiMn2PrevTDCComprTst_mp IVPlaus_phiPi2PrevTDCComprTst_mp IVPlaus_phiPreTDCComprTst1 IVPlaus_phiPreTDCComprTst2 IVPlaus_phiPstTDCComprTst3
      IVPlaus_phiPstTDCComprTst4 IVPlaus_stEffectComprTst IVPlaus_stRefComprTst IVPlaus_stStMNSyncComprTst IVPlaus_stStMTSyncComprTst IVPlaus_swtSrcPSComprTst_mp
      IVPlaus_tiEvalComprTst_mp IVPlaus_tiPreTDCComprTst IVPlaus_tiPstTDCComprTst
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVPlaus_CylChk
    ""

    /begin DEF_CHARACTERISTIC
      IVPlaus_numSegOfs2_C IVPlaus_stCylChk_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCrS_numSeg Epm_nEng Epm_nEngCurr Epm_numCyl FBC_qDvtCyl
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVPlaus_nCyl IVPlaus_qFBCCyl
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVPlaus_MonRunUpTst
    ""

    /begin IN_MEASUREMENT
      IVPlaus_stEffectRunUpTst
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVPlaus_RunUpTst
    ""

    /begin DEF_CHARACTERISTIC
      IVPlaus_cntSegDwnRunUpTst_C IVPlaus_cntSegUpRunUpTst_C IVPlaus_cntSegWaitRunUpTst_C IVPlaus_nMaxRunUpTst_C IVPlaus_nMinRunUpTst_C IVPlaus_nStrtRunUpTst_C
      IVPlaus_phiMI1DesRunUpTst_C IVPlaus_phiPiI1DesRunUpTst_C IVPlaus_phiPiI2DesRunUpTst_C IVPlaus_pSetPntRunUpTst_C IVPlaus_qPiI1DesRunUpTst_C IVPlaus_qPiI2DesRunUpTst_C
      IVPlaus_qSetUnBalRunUpTst_C IVPlaus_rEGRVlvRunUpTst_C IVPlaus_rThrVlvRunUpTst_C IVPlaus_rTrbChRunUpTst_C IVPlaus_stInjCharRunUpTst_C IVPlaus_stMskCoEOMOpModeRunUpTst_C
      IVPlaus_swtNoChkRefRunUpTst_C IVPlaus_swtTrqLimRunUpTst_C IVPlaus_tClntMinRunUpTst_C IVPlaus_tiMaxRunUpTst_C IVPlaus_tiPiI1DesRunUpTst_C IVPlaus_tiPiI2DesRunUpTst_C
      IVPlaus_tiWaitRunUpTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Brk_st CEngDsT_t Clth_st CnvSet_etaCurr CoEOM_stOpModeAct CoETS_trqInrCurrLim
      EpmSeq_numInt Epm_ctCyl Epm_nEng Epm_numCyl Epm_stSync PT_stTraType
      VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVPlaus_cntSegDwnRunUpTst IVPlaus_cntSegUpRunUpTst IVPlaus_nHiDwnRunUpTst IVPlaus_nHiUpRunUpTst IVPlaus_nLoDwnRunUpTst IVPlaus_nLoUpRunUpTst
      IVPlaus_nMinRunUpTst IVPlaus_nStrtRunUpTst IVPlaus_numShOffCyl IVPlaus_phiMI1DesRunUpTst IVPlaus_phiPiI1DesRunUpTst IVPlaus_phiPiI2DesRunUpTst
      IVPlaus_pSetPntRunUpTst IVPlaus_qPiI1DesRunUpTst IVPlaus_qPiI2DesRunUpTst IVPlaus_qSetUnBalRunUpTst IVPlaus_stEffectRunUpTst IVPlaus_stInjCharRunUpTst
      IVPlaus_stRefRunUpTst IVPlaus_stStMRunUpTst IVPlaus_tiDwnRunUpTst IVPlaus_tiPiI1DesRunUpTst IVPlaus_tiPiI2DesRunUpTst IVPlaus_tiUpRunUpTst
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVPlaus_cntSeg_mp IVPlaus_qSetUnBalLimRunUpTst_mp IVPlaus_rEGRVlvRunUpTst_mp IVPlaus_rThrVlvRunUpTst_mp IVPlaus_rTrbChRunUpTst_mp IVPlaus_stModeRunUpTst_mp
      IVPlaus_swtSrcPSRunUpTst_mp IVPlaus_tiEvalRunUpTst_mp IVPlaus_tiWaitRunUpTst_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVPSIC_IntegAdj
    ""

    /begin DEF_CHARACTERISTIC
      IVPSIC_ctIntegAdjMax_C IVPSIC_uIntegLin_CUR IVPSIC_Vltg_SRC.uMin_C IVPSIC_Vltg_SRC.uMax_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      IVPSIC_stIntegAdjRet IVPSIC_stIntegAdjStM IVPSIC_stIntegAdjVld IVPSIC_tiIntegAdj IVPSIC_tiIntegRC IVPSIC_uIntegOfs
      IVPSIC_uIntegWrkPnt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVPSIC_uRawIntegClb_mp IVPSIC_uRawIntegLin_mp IVPSIC_uRawIntegWrkPnt_mp IVPSIC_uRawIntegZr_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVPSply_BufVltg
    ""

    /begin DEF_CHARACTERISTIC
      IVPSply_uBufLin_CUR
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      IVPSply_uBufRaw_mp IVPSply_uBuf_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    IVPSply_DCDC
    ""

    /begin DEF_CHARACTERISTIC
      IVPSply_stBufErrRC_C IVPSply_stDCDCCoRC_C IVPSply_swtDCDCErrRC_C IVPSply_swtEnaDfcChSwt_C IVPSply_swtStBufErrRC_C IVPSply_swtStDCDCCoRC_C
      IVPSply_tiDCDCWait_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      InjVlv_stInjCo InjVlv_stPsIcErrCom InjVlv_stPsIcErrIlse InjVlv_stPsIcIniTrans IVDia_stShCirChSwt SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      IVPSply_stBufErr IVPSply_stDCDCCo
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      IVPSply_stDCDCStop IVPSply_stDCDCStrtLckd IVPSply_tiDCDCChrg_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LsmHal
    ""


/end FUNCTION

/begin FUNCTION

    LSU_DDElecDia
    ""

    /begin DEF_CHARACTERISTIC
      LSU_BattHiDeb.tiHiLo_C LSU_BattHiDeb.tiLoHi_C LSU_OvrRunDeb.tiHiLo_C LSU_OvrRunDeb.tiLoHi_C LSU_RiDeb.tiHiLo_C LSU_RiDeb.tiLoHi_C
      LSU_rO2Lmbd1Thres_C LSU_rO2Min_C LSU_stOpMLmbd1EnaMsk_C LSU_swtCldSensDia_C LSU_tiCldTstActv_C LSU_tiDvtFlt_C
      LSU_tiLmbd1RgnDly_C LSU_tiLmbd1RichMDly_C LSU_tiMaxDebVirtNernst_C LSU_tiOpnLdTstActv_C LSU_tiRiMeasDisa_C LSU_uBattMin_C
      LSU_uO2OpnLdNernstMax_C LSU_uO2OpnLdNernstMin_C LSU_uO2OpnLdVirtGndMax_C LSU_uO2OpnLdVirtGndMin_C LSU_uRiOpnLdTstMax_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      LSU_tHtCtlEna_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_u CoEng_st CoEOM_stOpModeAct HESrv_stMSid LSU_rO2RawTempComp LSU_rO2Stat
      LSU_stDPFThmRgn LSU_stErr LSU_stHtCtl LSU_stO2IntValid LSU_stSCUNEna LSU_swtEna
      LSU_tRi LSU_uO2Raw LSU_uRiFlt PthSet_stOvrRunCoord
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_stCldSensDiaActv LSU_stDiaIAEna LSU_stOpnLdTstActv LSU_stRefPmpDis
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_rO2RawFlt_mp LSU_stDebBattHi_mp LSU_stDebOvrRun_mp LSU_stDiaReg_mp LSU_stOpnErrIP
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_DDHtr
    ""

    /begin DEF_CHARACTERISTIC
      LSU_dcycMaxErr_C LSU_dcycMax_C LSU_dcycTstImp_C LSU_Pwm.tiPer_C LSU_Pwm.stLvl_C LSU_Pwm.rMaxDty_C
      LSU_Pwm.rPerUn_C LSU_Pwm.tiPh_C LSU_PwmOut.rMin_C LSU_PwmOut.rMax_C LSU_PwmOut.tiBtwTstSCB_C LSU_PwmOut.tiBtwTstOT_C
      LSU_PwmOut.numTstMax_C LSU_PwmOut.swtBattCor_C LSU_PwmOut.swtPsInv_C LSU_stHtDis_C LSU_stHtrPwrStgSel_C LSU_stPortSel_CA
      LSU_stPsDiaDisbl_C LSU_uBattMaxHigh_C LSU_uBattMaxLow_C LSU_uBattNominal_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      LSU_dcycHtMin_C LSU_uBattMin_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_u DevLib_stPwrStgEnaCond HESrv_stMSid LSU_dcycHt LSU_stErr LSU_stHtCtl
      LSU_stRmp LSU_swtEna
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_dcycHtCor LSU_dcycLimActHt LSU_stHtDis
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_facUCor_mp LSU_rOutHWE_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_DDO2Raw
    ""

    /begin DEF_CHARACTERISTIC
      LSU_ctSclFacO2Clb_C LSU_pExhO2MaxDiaDis_C LSU_rO2Transf_CUR LSU_stOpMO2SRCMinEnaMsk_C LSU_swtO2Flt_C LSU_swtSensPrs_C
      LSU_tiDelO2Clb_C LSU_tiDelO2Val_C LSU_tiExhPresFlt_C LSU_tiO2ClbPT1_C LSU_tiO2Clb_C LSU_tiO2PT1_C
      LSU_tiO2SRCMinDly_C LSU_tRiSigQlHiLim_C LSU_tRiSigQlLoLim_C LSU_uO2ClbDvtMax_C LSU_uO2ClbDvtMin_C LSU_uO2ClbMax_C
      LSU_uO2ClbMin_C LSU_uO2Max_C LSU_uO2Min_C LSU_uO2Ref_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      LSU_numEGFld_CA LSU_uBattMin_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      ASMod_pEGFld BattU_u CoEOM_stOpModeAct HESrv_stMSid LSU_stAdap LSU_stDPFThmRgn
      LSU_stErr LSU_stHtCtl LSU_stO2ClbEna LSU_stPmpCtl LSU_stRefPmp LSU_stRegrPresCompAdap
      LSU_stRiClb LSU_stSrvTstDem LSU_tRi PthSet_stOvrRunCoord
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_rO2Act LSU_rO2Raw LSU_stO2IntValid LSU_stO2SPICalDem LSU_swtEna LSU_uO2FltOfsCor
      LSU_uO2Raw LSU_uO2RawOfsCor
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_stO2Act_mp LSU_stO2Clb_mp LSU_uO2Clb LSU_uO2Dvt LSU_uO2RawOfsCorLast_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_DDO2RawFlt
    ""

    /begin IN_MEASUREMENT
      EpmCrS_numSeg HESrv_stMSid
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_uO2Flt LSU_uO2RawAdcDirect
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_uO2FltSegOld_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_DDPT1FltConstCalc
    ""

    /begin DEF_CHARACTERISTIC
      LSU_tiPT1FltO2Raw_C LSU_tiPT1FltRiRaw_C
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    LSU_DDRiRaw
    ""

    /begin DEF_CHARACTERISTIC
      LSU_ctSclFacRiClb_C LSU_facUToRi_C LSU_resRiClbDvtMax_C LSU_resRiClbDvtMin_C LSU_resRiClbMax_C LSU_resRiClbMin_C
      LSU_resRiClbRef_C LSU_tiDelRiClb_C LSU_tiDelRiVal_C LSU_tiRiClbPT1_C LSU_tiRiClb_C LSU_tiRiPT1_C
      LSU_tRi_CUR LSU_uRiOfs_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      HESrv_stMSid LSU_stErr LSU_stOpnLdTstActv LSU_stRiClbEna LSU_stSrvTstDem LSU_swtEna
      LSU_uRiFlt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_resRi LSU_stRiClb LSU_stRiSPICalDem LSU_stRiValid LSU_tRi
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_resRiClb LSU_resRiClbRaw_mp LSU_resRiDvt LSU_resRiRaw LSU_resRi_mp LSU_uRiRawOfsCor
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_DDRiRawFlt
    ""

    /begin IN_MEASUREMENT
      HESrv_stMSid
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_uRiFlt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_uRiRaw_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_DDSPI
    ""

    /begin DEF_CHARACTERISTIC
      LSU_stRefCurrHi_C LSU_stRefCurrNrm_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      HESrv_stMSid LSU_stDiaIAEna LSU_stErr LSU_stIpHiCurrEna LSU_stIpNrmCurrEna LSU_stO2SPICalDem
      LSU_stOpnLdTstActv LSU_stPmpCtl LSU_stRiSPICalDem LSU_stSCUNEna LSU_swtEna
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_stCirModeNew
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_stSPIIniVal_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_DDWireDia
    ""

    /begin DEF_CHARACTERISTIC
      LSU_ctSclFacHtCoup_C LSU_ctSclFacWireIP_C LSU_dcycMinGrad_C LSU_dmEGHtCoupActv_C LSU_dNumHtCoup_C LSU_numEGSel_CA
      LSU_resRiMaxGrad_C LSU_rO2IsolChkMax_C LSU_rO2IsolChkMin_C LSU_stWireDiaActv_C LSU_tiClgLstRun_C LSU_tiHtCoupChk_C
      LSU_tiHtCoupFltTst_C LSU_tiHtCoupFlt_C LSU_tiHtCoupPerTst_C LSU_tiHtCoupPer_C LSU_tiIsolChkErr_C LSU_tiIsolChkPer_C
      LSU_tiIsolChkPmp_C LSU_uO2MaxGrad_C LSU_uO2MaxRippel_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      ASMod_dmEGFld ASMod_tiClg CoEng_st HESrv_stMSid LSU_dcycHtCor LSU_resRi
      LSU_rO2Act LSU_stDPFThmRgn LSU_stErr LSU_stHtCtl LSU_stIniClb LSU_stO2ClbEna
      LSU_stO2IntValid LSU_stSrvTstDem LSU_swtEna LSU_uO2Raw
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_stHtDisbl LSU_stIsolChkActv LSU_stPmpEna
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_ctHtCoup LSU_dcycHtCoupStp1 LSU_dcycHtCoupStp2 LSU_dcycRippel_mp LSU_dHtCoupStepLast LSU_dHtCoupStp
      LSU_resRiHtCoupStp1 LSU_resRiHtCoupStp2 LSU_resRiRippel_mp LSU_stHtCoupActv LSU_stIsolChkO2Last LSU_stRecValEval_mp
      LSU_stTstTrigger_mp LSU_stWireDiaChk_mp LSU_stWireDiaErr_mp LSU_uO2FltRippel_mp LSU_uO2Grad_mp LSU_uO2HtCoupStp1
      LSU_uO2HtCoupStp2 LSU_uO2HtCoupStp3 LSU_uO2Rippel_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_DiaOvrvw
    ""


/end FUNCTION

/begin FUNCTION

    LSU_IntfcDia
    ""

    /begin DEF_CHARACTERISTIC
      LSU_stSrvTstEna_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      LSU_stSrvTstDem
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_VDAdap
    ""

    /begin DEF_CHARACTERISTIC
      LSU_AirPerTimeI.Ki_C LSU_AirPerTimeI.KiPos_C LSU_AirPerTimeI.KiNeg_C LSU_AirPerTimeI.WinPos_C LSU_AirPerTimeI.WinNeg_C LSU_d2rIni_C
      LSU_EvalMaxVal_C LSU_EvalMinVal_C LSU_facO2TempCorIni_C LSU_facO2TempCorMaxDvt_C LSU_facTempDepNom_C LSU_mAirAdapActv_C
      LSU_numStdTempAdap_C LSU_rLamRec_CUR LSU_swtAdap_C LSU_swtTempCompEna_C LSU_swtTempCompNomEna_C LSU_tAirAdapActv_C
      LSU_tiAdapFltIni_C LSU_tiAdapFlt_C LSU_tiEvalFltIni_C LSU_tiEvalFlt_C LSU_tiStbTemp_C LSU_tRiSetPLo_C
      LSU_tRiSetPMaxDvt_C LSU_tRiSetPStd_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      LSU_tRiMaxTempComp_C LSU_tRiMinTempComp_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AFS_dm ASMod_pEGFld ASMod_rLamRecExhMnfDs CoEng_st EnvT_t HESrv_stMSid
      LSU_rO2PresComp LSU_rO2Raw LSU_stDPFThmRgn LSU_stEGRActvOvrn LSU_stErr LSU_stO2IntValid
      LSU_swtEna LSU_tDvt LSU_tRi PthSet_stOvrRunCoord
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_rLam LSU_rLamRec LSU_rO2Adap LSU_rO2PresTempComp LSU_rO2RawTempComp LSU_stAdap
      LSU_stAdapActv LSU_stChng LSU_tRiCurrSetP NSCDsRLam_rLam NSCDsRLam_rLamRec TrbnDsRLam_rLam
      TrbnDsRLam_rLamRec TrbnDsRLam_rO2PresComp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_ctStdTempAdap LSU_d2rO2Eval_mp LSU_d2rO2_mp LSU_drO2Adap LSU_drO2AdapLoTemp LSU_drO2Flt_mp
      LSU_facO2CorLoTemp_mp LSU_facO2CorStdTemp_mp LSU_facO2Cor_mp LSU_facO2TempCor_mp LSU_facTempCompNom_mp LSU_facTempComp_mp
      LSU_mAirAftOvrRun LSU_rO2AdptLastLSU_mp LSU_stActv_mp LSU_stHold_mp LSU_swtAdap
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_VDClbSched
    ""

    /begin DEF_CHARACTERISTIC
      LSU_nMaxClb1_C LSU_nMaxClb2_C LSU_nMinClb1_C LSU_nMinClb2_C LSU_qMaxClb1_C LSU_qMaxClb2_C
      LSU_qMinClb1_C LSU_qMinClb2_C LSU_stChpClbActv_C LSU_stOpMClbEnaMsk_C LSU_ti1stClb_C LSU_tiClbEnaDly_C
      LSU_tiPerClb_C LSU_uMinClb_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st CoEOM_stOpModeAct Epm_ctCyl Epm_nEng InjSys_qInrCmb LSU_stIsolChkActv
      LSU_stSrvTstDem LSU_swtEna
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_stErr LSU_stIniClb LSU_stO2ClbEna LSU_stRiClbEna
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_stClbTrg_mp LSU_stNotOpPoint1_mp LSU_stNotOpPoint2_mp LSU_stTmrClbPerRun
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_VDHtrCtl
    ""

    /begin DEF_CHARACTERISTIC
      LSU_dcycHtMin_C LSU_DcycRmp.Pos_C LSU_DcycRmp.Neg_C LSU_dcycStrt_CUR LSU_facSclFacTExcMax_C LSU_facSclFacTExcMin_C
      LSU_nHtCtlEna_C LSU_numAirTempSel_C LSU_Sens1DT1.T1_C LSU_Sens1DT1.Kd_C LSU_Sens1I.Ki_C LSU_Sens1I.KiPos_C
      LSU_Sens1I.KiNeg_C LSU_Sens1I.WinPos_C LSU_Sens1I.WinNeg_C LSU_Sens1P.Kp_C LSU_Sens1P.KpPos_C LSU_Sens1P.KpNeg_C
      LSU_Sens1P.WinPos_C LSU_Sens1P.WinNeg_C LSU_Sens2DT1.T1_C LSU_Sens2DT1.Kd_C LSU_Sens2I.Ki_C LSU_Sens2I.KiPos_C
      LSU_Sens2I.KiNeg_C LSU_Sens2I.WinPos_C LSU_Sens2I.WinNeg_C LSU_Sens2P.Kp_C LSU_Sens2P.KpPos_C LSU_Sens2P.KpNeg_C
      LSU_Sens2P.WinPos_C LSU_Sens2P.WinNeg_C LSU_tExcMax_C LSU_tExcMin_C LSU_tHtCtlEna_C LSU_tiDelHtrTst_C
      LSU_tiDelIniVal_C LSU_tiUBattPT1_C LSU_tRiMaxTempComp_C LSU_tRiMinTempComp_C LSU_uHtPerfBattMin_MAP
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      LSU_dcycMax_C LSU_uBattMin_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AirSys_tFld ASMod_dmEGFld ASMod_tEGFld BattU_u Epm_nEng HESrv_stMSid
      LSU_dcycLimActHt LSU_stErr LSU_stHtDis LSU_stHtDisbl LSU_stRiValid LSU_stSrvTstDem
      LSU_swtEna LSU_tRi LSU_tRiCurrSetP PthSet_stOvrRunCoord
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_dcycHt LSU_stHtCtl LSU_stRmp LSU_stSCUNEna LSU_tDvt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_dcycDT1_mp LSU_dcycHtIniRmp LSU_dcycHtStrt LSU_dcycI_mp LSU_dcycP_mp LSU_dmEGFldHtCtl_mp
      LSU_tAirStrt_mp LSU_tEGFldHtCtl_mp LSU_uHtBattPT1Flt_mp LSU_uHtPerfBattMin_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_VDMon
    ""

    /begin DEF_CHARACTERISTIC
      LSU_ctSclFacDynChk_C LSU_ctSclFacO2Plaus_C LSU_mAirMaxTst_C LSU_mAirMax_C LSU_mAirMinTst_C LSU_mAirMin_C
      LSU_mAirPlausEnaTst_CA LSU_mAirPlausEna_CA LSU_nMaxTst_C LSU_nMax_C LSU_nMinChkDyn_C LSU_nMinTst_C
      LSU_nMin_C LSU_qDiffMax_C LSU_qMaxTst_C LSU_qMax_C LSU_qMinTst_C LSU_qMin_C
      LSU_qThresChkDyn_C LSU_qThresOvrRun_C LSU_rO2MaxVar_C LSU_rO2NegDvtTst_C LSU_rO2NegDvt_C LSU_rO2PosDvtTst_C
      LSU_rO2PosDvt_C LSU_stMonActv_C LSU_stMskEGROvrn_C LSU_stO2Calc_C LSU_stOpMMonEnaMsk_C LSU_stSelDynChkSig_C
      LSU_stSelOpPntOvrn_C LSU_stSelPlausChkSig_C LSU_swtChkDPFThmRgn_CA LSU_tiDPFThmRgnDly_C LSU_tiO2CalcFltTst_C LSU_tiO2CalcFlt_C
      LSU_tiO2EvalTst_C LSU_tiO2Eval_C LSU_tiSwt_CA LSU_tiWait1_CA LSU_tiWait2_CA LSU_tiWait3_CA
      LSU_tiWait4_CA LSU_volMinFl_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      LSU_uBattMin_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AFS_mAirPerCyl AirCtl_stAirCtlBits BattU_u CoEOM_stOpModeAct EGRVlv_r Epm_ctCyl
      Epm_nEng FlSys_facStoich FlSys_rhoFl Fl_volTnkQnt HESrv_stMSid InjSys_qInrCmb
      InjSys_stCtlQnt LSU_rO2Adap LSU_rO2PresComp LSU_rO2PresTempComp LSU_rO2Raw LSU_rO2RawTempComp
      LSU_stAdap LSU_stErr LSU_stO2IntValid LSU_stSrvTstDem LSU_swtEna PFltLd_stRgnThrActv
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_rO2Stat LSU_stDPFThmRgn LSU_stEGRActvOvrn
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_bpPlausSetPoint_mp LSU_mAirPlausChk LSU_numMaxCmpChk_mp LSU_qStrt_mp LSU_rO2Calc_mp LSU_rO2DiffCmpChk_mp
      LSU_rO2DvtNeg_mp LSU_rO2DvtPos_mp LSU_rO2FrstValCmpChk_mp LSU_rO2SecValCmpChk_mp LSU_rO2SignDyn_mp LSU_rO2Thres1_mp
      LSU_rO2Thres2_mp LSU_stChkDyn_mp LSU_stCmpChkCon_mp LSU_stCmpChk_mp LSU_stCmpErr_mp LSU_stDynState
      LSU_stEGRActvPlausChk_mp LSU_stO2Chk LSU_stO2Err LSU_stPlausChk LSU_stPlausChkCon LSU_stPOpCmpChk_mp
      LSU_tiState1_mp LSU_tiState2_mp LSU_tiState3_mp LSU_tiState4_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_VDPmpCtl
    ""

    /begin DEF_CHARACTERISTIC
      LSU_stPmpCtlDisbl_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      DevLib_stPwrStgEnaCond HESrv_stMSid LSU_stCldSensDiaActv LSU_stErr LSU_stHtCtl LSU_stOpnLdTstActv
      LSU_stPmpEna LSU_stRiClb LSU_swtEna
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_stPmpCtl
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_VDPresComp
    ""

    /begin DEF_CHARACTERISTIC
      LSU_ctMeasPresCompMax_C LSU_ctWaitPresCompMax_C LSU_dnEngSpdThresHi_C LSU_dpExhGsRefAvrgThres_C LSU_dpExhGsThresHi_C LSU_facPresCompLean_CUR
      LSU_facPresCompRich_CUR LSU_numCalcRegrThres_C LSU_numCoefRegrThres_C LSU_numEGFld_CA LSU_numPresVltgMax_C LSU_numRegrDfl_CA
      LSU_numRegrThres_C LSU_numSqrtRegr_CUR LSU_numSumPresDfl_CA LSU_numSumPresSqDfl_CA LSU_numSumPresVltgDfl_CA LSU_numSumVltgDfl_CA
      LSU_numSumVltgSqDfl_CA LSU_pExhGsSqMax_C LSU_pExhPresOfs_C LSU_pKPresCompMax_C LSU_pKPresCompMin_C LSU_rO2SwtPresComp_C
      LSU_swtExhPresSel_C LSU_swtPresCompAdapOn_C LSU_swtWrPresCompAdapDfl_C LSU_tiEngSpdDT1_C LSU_tiPExhGsDT1_C LSU_uO2OfsCorSqMax_C
      LSU_uO2OfsCor_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      LSU_rO2Transf_CUR
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      ASMod_pEGFld Epm_nEng Exh_pPFltDiff HESrv_stMSid LSU_rO2Raw LSU_stAdapActv
      LSU_swtEna LSU_uO2FltOfsCor LSU_uO2RawOfsCor
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_rO2PresComp LSU_stRegrPresCompAdap
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_ctMeasPresComp_mp LSU_ctRegrPresVltg_mp LSU_ctWaitPresComp_mp LSU_dnEngSpdAbsFlt_mp LSU_dpExhGsAbsFlt_mp LSU_facPresCompAdap
      LSU_facPresCompAdapMul_mp LSU_facPresComp_mp LSU_numArgSqrt_mp LSU_numBefSqrPresComp_mp LSU_numCoefRegr_mp LSU_numDenomRegrPres_mp
      LSU_numDenomRegrVltg_mp LSU_numGradPresCompAdap_mp LSU_numGradRegr_mp LSU_numOfsRegr_mp LSU_numRegr_mp LSU_numSqrPresComp_mp
      LSU_numSumCntPresSq_mp LSU_numSumCntPresVltg_mp LSU_numSumCntVltgSq_mp LSU_numSumRegrPresSq_mp LSU_numSumRegrPresVltg_mp LSU_numSumRegrPres_mp
      LSU_numSumRegrVltgSq_mp LSU_numSumRegrVltg_mp LSU_pExhGasLstVal_mp LSU_pExhGsAvrg_mp LSU_pExhGs_mp LSU_pKPresCompAdap
      LSU_pKRegrAdapUnLim_mp LSU_pPresCompAdapMul_mp LSU_pRegrPresAvrg_mp LSU_pSumExhGsMeas_mp LSU_rNrmPresAvrg_mp LSU_rPresAvrg_mp
      LSU_stCalcSqr_mp LSU_stDynPresCompAdap_mp LSU_stPresCompAdap LSU_stRdcRegrPresVltg_mp LSU_stRdcRegrPres_mp LSU_stRdcRegrVltg_mp
      LSU_stRegrPresComp_mp LSU_stRegr_mp LSU_uO2OfsCorAvrg_mp LSU_uO2PresComp_mp LSU_uSumO2OfsCorMeas_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    LSU_VDRefPmp
    ""

    /begin DEF_CHARACTERISTIC
      LSU_stRefPmpDisbl_C LSU_tiRefPmpHi_C LSU_tiRefTransLo_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      DevLib_stPwrStgEnaCond HESrv_stMSid LSU_stHtCtl LSU_stOpnLdTstActv LSU_stRefPmpDis LSU_stRiClb
      LSU_swtEna
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      LSU_stIpHiCurrEna LSU_stIpNrmCurrEna LSU_stRefPmp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_stRefCurrTrans_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    medcadapt
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Axispoints_Core
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Axispoints_Custom
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Axispoints_DS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Axispoints_DS_GS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Axispoints_Prj
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Compu_Core
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Compu_Custom
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Compu_DS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Compu_DS_GS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Compu_Prj
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_DatasetExt
    ""

    /begin DEF_CHARACTERISTIC
      medc_datasetid
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    MEDC_FixConst_Core
    ""


/end FUNCTION

/begin FUNCTION

    medc_fixconst_custom
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_FixConst_DS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_FixConst_DS_GS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_FixConst_Prj
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Models_Core
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Models_Custom
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Models_DS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Models_DS_GS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Models_Prj
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Switches_Core
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Switches_Custom
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Switches_DS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Switches_DS_GS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_Switches_Prj
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_VarConst_Core
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_VarConst_Custom
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_VarConst_DS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_VarConst_DS_GS
    ""


/end FUNCTION

/begin FUNCTION

    MEDC_VarConst_Prj
    ""


/end FUNCTION

/begin FUNCTION

    MemLay
    ""


/end FUNCTION

/begin FUNCTION

    MeUn_ActrTst
    ""

    /begin DEF_CHARACTERISTIC
      MeUn_facRefActrTst_C MeUn_iMaxActrTst_CA MeUn_iMinActrTst_CA MeUn_iSetMaxActrTst_C MeUn_iSetMinActrTst_C MeUn_iWinActrTst_C
      MeUn_nDiffMaxActrTst_C MeUn_nSetActrTst_CA MeUn_pMinMeUn_C MeUn_pSetActrTst_CA MeUn_qDiffMaxActrTst_C MeUn_rAccPedActrTst_C
      MeUn_swtNoChkRefActrTst_C MeUn_swtZeroVolActrTst_C MeUn_tClntMinActrTst_C MeUn_tiActrTstMax_C MeUn_tiDetActrTst_C MeUn_tiRmpDurActrTst_C
      MeUn_tiWaitActrTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      APP_rUnFlt Brk_st CEngDsT_t Epm_nEng HLSDem_nSetPLo InjCtl_qSetUnBal
      MeUn_iSet MeUn_iSetFlt PCV_iSetFlt PT_stTraType RailP_pFlt Rail_pSetPoint
      Rail_stCtlLoop VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MeUn_nSubsActrTst
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MeUn_cntRepActrTst_mp MeUn_cntSpdActrTst_mp MeUn_facRefActrTst MeUn_iPCVAvrgLoActrTst_mp MeUn_iRefActrTst_mp MeUn_iResActrTst_mp
      MeUn_iSetActrTst MeUn_iSetMaxActrTst MeUn_iSetMinActrTst MeUn_nActrTst MeUn_pActrTst MeUn_pSetPntActrTst
      MeUn_qAvrgActrTst_mp MeUn_stActrTst MeUn_stEffectActrTst MeUn_stRefActrTst MeUn_stResActrTst_mp MeUn_stStMActrTst
      MeUn_stZeroVolTst MeUn_swtTstParActrTst MeUn_tiEvalActrTst_mp MeUn_tiRmpDurActrTst MeUn_tiWait_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MeUn_DDCo
    ""

    /begin DEF_CHARACTERISTIC
      MeUn_CrntCtlDT1.T1_C MeUn_CrntCtlDT1.Kd_C MeUn_iLin_CUR MeUn_nDiffMax_C MeUn_PwmOut.rMin_C MeUn_PwmOut.rMax_C
      MeUn_PwmOut.tiBtwTstSCB_C MeUn_PwmOut.tiBtwTstOT_C MeUn_PwmOut.numTstMax_C MeUn_PwmOut.swtBattCor_C MeUn_PwmOut.swtPsInv_C MeUn_resCoil_C
      MeUn_rMaxDty_C MeUn_rPerUn_C MeUn_rPs_C MeUn_rSetLin_CUR MeUn_SRC.uMin_C MeUn_SRC.uMax_C
      MeUn_stLvl_C MeUn_stPwrStgActv_C MeUn_stPwrStgDia_C MeUn_swtRPs_C MeUn_tiPerUBattHi_C MeUn_tiPer_CUR
      MeUn_tiPh_C MeUn_uBattHi_C MeUn_uBattLo_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_facCor BattU_u BattU_uRated DevLib_stPwrStgEnaCond Epm_nEng MeUn_stRot
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      MeUn_iActVal MeUn_nDiffRef_mp MeUn_rPsPreRot_mp MeUn_rPs_mp MeUn_rSetDT1_mp MeUn_rSetLin_mp
      MeUn_rSet_mp MeUn_tiPer_mp MeUn_uRaw_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MeUn_Rot
    ""

    /begin DEF_CHARACTERISTIC
      MeUn_ctRot_C MeUn_rLim_CUR MeUn_rRotEnd_C MeUn_rRotStrt_C MeUn_stRotActv_C MeUn_tiRotDel_C
      MeUn_tiRotExt_C MeUn_tiRotWait_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st FuelT_tFlSys SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MeUn_stRot
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MeUn_ctRot_mp MeUn_stRotXPostDrv_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MeUn_SetPTst
    ""

    /begin DEF_CHARACTERISTIC
      MeUn_iSetMax_C MeUn_swtActvSetPTst_C MeUn_tiMaxSetPTst_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      MeUn_iSetMin_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Brk_st Clth_st Epm_nEng MeUn_iSet PT_stTraType VehV_v
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      MeUn_cntTrgOffSetPTst_mp MeUn_iEndLimSetPTst_mp MeUn_iEndSetPTst MeUn_iOfsSetPTst MeUn_iOldSetPTst_mp MeUn_iStrtLimSetPTst_mp
      MeUn_iStrtSetPTst MeUn_iSubstSetPTst MeUn_stEffectSetPTst MeUn_stParSetPTst MeUn_stRefSetPTst MeUn_stStMSetPTst
      MeUn_tiDlySetPTst MeUn_tiStpMeasSetPTst_mp MeUn_tiStpSetPTst MeUn_tiTotSetPTst_mp MeUn_trgSigSetPTst_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MeUn_VDCo
    ""

    /begin DEF_CHARACTERISTIC
      MeUn_CrntCtlI.Ki_C MeUn_CrntCtlI.KiPos_C MeUn_CrntCtlI.KiNeg_C MeUn_CrntCtlI.WinPos_C MeUn_CrntCtlI.WinNeg_C MeUn_facCrntCtlInit_CUR
      MeUn_facCrntCtlMax_C MeUn_facCrntCtlMin_C MeUn_iCnvFlowRate_CUR MeUn_iSetMin_C MeUn_iSet_C MeUn_pActrPrt_C
      MeUn_pFlowOfFl_C MeUn_swtISet_C MeUn_tiCrntCtlInit_C MeUn_tiFlt1PT1_C MeUn_tiFlt2PT1_C MeUn_tiFltPT1Init_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      DevLib_stMonActrPrt FuelT_tFlSys MeUn_stRot RailP_pFlt Rail_stCtlLoop
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MeUn_dvolSet MeUn_iSet MeUn_iSetFlt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MeUn_facCrntCtlLim_mp MeUn_iActFlt_mp MeUn_iDvt_mp MeUn_stActrCtl_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Mli
    ""


/end FUNCTION

/begin FUNCTION

    Mm
    ""


/end FUNCTION

/begin FUNCTION

    MoCADC_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoCADC_ctDebNTP_C MoCADC_ctDebTst_C MoCADC_ctDebVltgRatio_C MoCADC_ctDiagNTP_C MoCADC_ctRst_C MoCADC_facVltgRatioMax_C
      MoCADC_facVltgRatioMin_C MoCADC_uNTPMax_C MoCADC_uTstMax_C MoCADC_uTstMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Mo_stCplChk Mo_stICODiagMsg Mo_stICOMsg Mo_stMoC Mo_stMoF
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCADC_facVltgRatio MoCADC_st MoCADC_stIrvErrNTP MoCADC_stIrvErrTst MoCADC_stIrvErrVltgRatio MoCADC_stMsg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCADC_ctDebNTP MoCADC_ctDebTst MoCADC_ctDebVltgRatio MoCADC_ctDiagNTP MoCADC_ctDiagTst MoCADC_ctDiagVltgRatio
      MoCADC_uNTP MoCADC_uTst
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoCCom_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoCCom_ctDebErrCnt_C MoCCom_ctDebErrSPI_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      MoCSOP_ctDebSOPTst_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCCPU_PartResp MoCMem_st MoCPFC_PartResp MoCSOP_stAct MoCSOP_stActMsg MoCSOP_stErr
      MoCSOP_stRdy Mo_stCplChk SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCCom_ctErrFC MoCCom_ctErrMMMsg MoCCom_ctSOPTstActv MoCCom_Query MoCCom_st MoCCom_stQueryNew
      MoCCom_stWDAActvMsg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCCom_bCPUNew MoCCom_bErrCntErr MoCCom_bErrCntNPl MoCCom_bPCPNew MoCCom_bPFCNew MoCCom_bSpiErr
      MoCCom_bSpiNPl MoCCom_ctCorRespCnt MoCCom_ctDiagErrCnt MoCCom_ctDiagErrSPI MoCCom_ctErrMM MoCCom_ctErrMMOld
      MoCCom_ctErrSPI MoCCom_Response MoCCom_stMmRespCnt
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoCCPU_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoCCPU_IpoTst_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCCom_Query MoCCom_stQueryNew
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCCPU_PartResp MoCCPU_Query
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCCPU_ctSeq MoCCPU_IpoIn MoCCPU_TempRes
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoCGPTA_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoCGPTA_numErr_C MoCGPTA_tiDvtMax_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Mo_stCplChk
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoCMem_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoCMem_ctDebErrChkRAM_C MoCMem_ctDebErrChkROM_C MoCMem_ctDebHealChkRAMCpl_C MoCMem_ctDebHealChkRAM_C MoCMem_ctDebHealChkROMCpl_C MoCMem_ctDebHealChkROM_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Mo_stCplChk Mo_stMoC
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCMem_st
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCMem_adCurrent MoCMem_adRamOffset MoCMem_ctDebErrChkRAM MoCMem_ctDebErrChkROM MoCMem_ctDebHealChkRAM MoCMem_ctDebHealChkROM
      MoCMem_numCurrent MoCMem_stFunctionSwitch
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoCPCP_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoCPCP_numErr_C MoCPCP_stEnaMFTst_CW MoCPCP_tiHeal_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCCom_stQueryNew MoCMem_st Mo_stCplChk Mo_stMoC
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCPCP_adCurrent MoCPCP_ctErr MoCPCP_ctHeal MoCPCP_numCurrentCSum
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoCPFC_Co
    ""

    /begin IN_MEASUREMENT
      MoCCom_Query
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCPFC_PartResp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCPFC_Checksum MoCPFC_Checkword MoCPFC_Counter
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoCRAM_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoCRam_ChkRAMIFA9SyncTst_CW MoCRam_ChkRAMIFA9Tst_CW MoCRam_noRAMChkSD_CW
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCMem_st MoCRom_numRomPageErr MoCRom_ptrTabIndexAct
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCRam_stProtRAMCleared
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCRam_ctMain1RamChk MoCRam_ctMain2RamChk MoCRam_ctMainProtRam MoCRam_ctRepEx MoCRam_numAreasChecked MoCRam_numReset
      MoCRam_stEEPInit MoCRam_stRepExRam
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoCROM_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoCRom_BgSwOffTst_CW MoCRom_noROMChkIni_CW MoCRom_noROMCodeChkRst_CW MoCRom_noROMDataChkRst_CW MoCRom_RepExTst_CW
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCMem_st SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCRom_numRomPageErr MoCRom_ptrTabIndexAct
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCRom_ctRepEx_mp MoCRom_KeyCode MoCRom_KeyData MoCRom_stXPostDrv_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoCSOP_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoCSOP_ctDebHwNoRdy_C MoCSOP_ctDebPSDia_C MoCSOP_ctDebPSIni_C MoCSOP_ctDebSOPTst_C MoCSOP_ctWaitInjTstRdy_C MoCSOP_nMinOVLth_C
      MoCSOP_stCANErrReac_CW MoCSOP_stICOMsgReport_C MoCSOP_stMMErrReac_CW MoCSOP_stSOPTstActv_CW MoCSOP_stSWResetDem_CW MoCSOP_swtPsvTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCCom_ctErrFC MoCCom_st MoCMem_st MoFESpd_nEng Mo_stCplChk Mo_stICODiagMsg
      Mo_stICOMsg Mo_stMoF SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCSOP_ctErrMM MoCSOP_stAct MoCSOP_stActMsg MoCSOP_stActvMsg MoCSOP_stErr MoCSOP_stOvl
      MoCSOP_stRdy MoCSOP_stRdyMsg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCSOP_ctABEFrz MoCSOP_ctABEFrzCpl MoCSOP_ctDebHwNoRdy MoCSOP_ctDebPSDia MoCSOP_ctDebPSIni MoCSOP_ctDebSOPTst
      MoCSOP_ctDebSOPTstCpl MoCSOP_ctDebWait4ABE MoCSOP_ctDebWait4ABECpl MoCSOP_ctErrMMRespByte MoCSOP_ctErrMM_mp MoCSOP_ctErrOSTimeout
      MoCSOP_ctErrRespTime MoCSOP_ctErrSPI MoCSOP_ctErrSPI_mp MoCSOP_ctIdx_mp MoCSOP_ctWaitInjTstRdy MoCSOP_st
      MoCSOP_stABE_mp MoCSOP_stExtSM_mp MoCSOP_stInnerSM_mp MoCSOP_stIVHSOPTst_mp MoCSOP_stLdRespTab MoCSOP_stMm
      MoCSOP_stMmRespCnt MoCSOP_stMm_mp MoCSOP_stReqErrReac MoCSOP_stReqErrReacCpl MoCSOP_stWDA_mp MoCSOP_tiResp
      MoCSOP_tiRespMM_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoExe_Co
    ""

    /begin IN_MEASUREMENT
      SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoExe_ctCyc
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFAPP_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoFAPP_uFL_C MoFAPP_uLoLim_C MoFAPP_uMaxDiffFL_C MoFAPP_uMaxDiffPL_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCADC_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoFAPP_stETC MoFAPP_uRaw1 MoFAPP_uRawETC
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoFAPP_stAPP_mp MoFAPP_uAPP1RawOld MoFAPP_uAPP2RawOld MoFAPP_uRaw1_mp MoFAPP_uRaw2_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFBrk_Co
    ""

    /begin OUT_MEASUREMENT
      MoFBrk_st
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFESpd_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoFESpd_ctDeb_C MoFESpd_ctRst_C MoFESpd_nDiffMax_C MoFESpd_nMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoFETC_stTst Mo_ctRst Mo_stCplChk Mo_stICODiagMsg Mo_stICOMsg Mo_stMoC
      Mo_stMoF
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoFESpd_ctDeb MoFESpd_nEng MoFESpd_stSync
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoFESpd_ctDiag MoFESpd_nEngL2 MoFESpd_phiGT1Last MoFESpd_stIrvErr MoFESpd_stSync1 MoFESpd_stSync2
      MoFESpd_stTst MoFESpd_tiLast
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFETC_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoFETC_ctTst_C MoFETC_stBrkNotPressed_C MoFETC_stRSABrkNotPressed_C MoFETC_swtEnaRSAAPPCond_C MoFETC_swtEnaRSABrkCond_C MoFETC_swtEnaRSAVehSpdCond_C
      MoFETC_swtInactvDiagTO_C MoFETC_swtInactvTO_C MoFETC_uRawIdlAPP_C MoFETC_uRSARawIdlAPP_C MoFETC_vMax_C MoFETC_vRSAMax_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Etc_ctCurRunTst MoFAPP_stETC MoFAPP_uRawETC MoFBrk_st MoFETC_stAPPIdlPos MoFETC_stBrkNotPressed
      MoFETC_v RsaETC_stEngTstActv
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoFETC_stTst MoFETC_stTstMsg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoFETC_ctTst MoFETC_stAPPIdlPos_mp MoFETC_stBrkNotPressed_mp MoFETC_stCond_mp MoFETC_stRSAAPPIdlPos_mp MoFETC_stRSABrkNotPressed_mp
      MoFETC_stRSAETCond_mp MoFETC_stRSAVehSpdCond_mp MoFETC_stTO_mp MoFETC_stTstRSA_mp MoFETC_stTst_mp MoFETC_stuRawIdlAPP_mp
      MoFETC_stuRSARawIdlAPP_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFICO_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoFICO_swtTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCCom_ctErrMMMsg
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoFICO_stDisturb
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFInjDat_GetInj
    ""

    /begin DEF_CHARACTERISTIC
      MoFInjDat_facInjEff_MAP MoFInjDat_numCyl_C MoFInjDat_pLin_CUR MoFInjDat_uSRCMax_C MoFInjDat_uSRCMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_ctCyl Epm_nEng Mo_stCplChk Mo_stMoC
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoFInjDat_stChkSum MoFInjDat_stPressSRC MoFInjDat_tiTDCAvrg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoFInjDat_numCylActr_mp MoFInjDat_numInjType_mp MoFInjDat_phiInjAct_mp MoFInjDat_phiInjBegActr_mp MoFInjDat_pLinCurr_mp MoFInjDat_stMemChk
      MoFInjDat_tiInjAct_mp MoFInjDat_tiInjDurActr_mp MoFInjDat_tiTDCSumET_mp MoFInjDat_uRaw_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFOvR_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoFOvR_swtTst_C MoFOvR_tiLimET_MAP
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoFESpd_nEng MoFInjDat_tiTDCAvrg MoFOvR_stRls Mo_stCplChk Mo_stMoC
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoFOvR_stActvMsg MoFOvR_stPlausInj
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoFOvR_tiLimET_mp MoFOvR_tiOvRMonActive_mp tiOvRMonActive
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFRailP_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoFRailP_ctDebErr_C MoFRailP_ctDebGradMax_C MoFRailP_ctRst_C MoFRailP_pDefMax_C MoFRailP_pDefMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoFInjDat_stPressSRC Mo_stCplChk Mo_stICODiagMsg Mo_stICOMsg Mo_stMoC Mo_stMoF
      RailP_pFlt RailP_stGrad Rail_pSetPoint SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoFRailP_p MoFRailP_stGradErr
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoFRailP_ctDebErr MoFRailP_ctDebGradMax MoFRailP_ctDiag MoFRailP_stIrvErr
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFRST_Co
    ""

    /begin DEF_CHARACTERISTIC
      MoFRST_swtTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoFRST_stRstMsg
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MoFSrv_Lib
    ""


/end FUNCTION

/begin FUNCTION

    Mo_Axispoints
    ""


/end FUNCTION

/begin FUNCTION

    Mo_AxispointsCust
    ""


/end FUNCTION

/begin FUNCTION

    Mo_Glbl
    ""

    /begin DEF_CHARACTERISTIC
      Mo_swtClrEEPCtrs_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Reset_xId
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Mo_ctRst Mo_EnvCondMoCErrCol1 Mo_EnvCondMoCErrCol2 Mo_EnvCondMoFESpd Mo_EnvCondMoFRailP Mo_EnvCondPSShutOff
      Mo_EnvConds Mo_ErrCol1 Mo_ErrCol2 Mo_stCplChk Mo_stICODiagMsg Mo_stICOMsg
      Mo_stIrvErrReacMsg Mo_stMoC Mo_stMoF Mo_stRstDiagMsg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Mo_bCplChk Mo_bICOL1 Mo_bICOL2 Mo_bLimpHom Mo_bLowVltg Mo_bRamErr
      Mo_bRomErr Mo_ctDebMax_u16 Mo_ctDebMax_u8 Mo_stEEPRW
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    MRly_ShOff
    ""


/end FUNCTION

/begin FUNCTION

    MRly_VD
    ""

    /begin DEF_CHARACTERISTIC
      MRly_ctErlyOpng_C MRly_tiBattVltgFlt_C MRly_tiStkRlyDiaDel_C MRly_uStblThr_C MRly_uStkRlyBattThr_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      MRly_ctErlyOpng_mp MRly_st MRly_stAct
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MRly_stStkRlytst_mp MRly_stStkRly_mp MRly_uBattFlt_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Msc
    ""


/end FUNCTION

/begin FUNCTION

    nlinf_comreceive
    ""


/end FUNCTION

/begin FUNCTION

    nlinf_comsetsend
    ""


/end FUNCTION

/begin FUNCTION

    nlinf_comstart
    ""


/end FUNCTION

/begin FUNCTION

    nlinf_comstop
    ""


/end FUNCTION

/begin FUNCTION

    nlinf_conf
    ""


/end FUNCTION

/begin FUNCTION

    NLInf_RxCallback
    ""


/end FUNCTION

/begin FUNCTION

    NLInf_TxCallback
    ""


/end FUNCTION

/begin FUNCTION

    OS_Kernel
    ""

    /begin LOC_MEASUREMENT
      OS_cnt1000msTask OS_cnt100msTask OS_cnt10msTask OS_cnt1msTask OS_cnt2000msTask OS_cnt200msTask
      OS_cnt20msTask OS_cnt2msTask OS_cnt4000msTask OS_cnt400msTask OS_cnt40msTask OS_cnt4msTask
      OS_cnt50msTask OS_cnt5msTask OS_cnt60000msTask OS_cntBgTask OS_cntDsmClearTask OS_cntEngReStrtTask
      OS_cntEpmNoSyncTask OS_cntIniEndTask OS_cntIniTask OS_cntMoTask OS_cntSyncDummyTask OS_cntSyncFirstTask
      OS_cntSyncIni OS_cntSyncPostTask OS_cntSyncPreTask OS_cntSyncS0Task OS_cntSyncS1Task OS_cntSyncSchedTask
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OS_Shell
    ""

    /begin LOC_MEASUREMENT
      OS_ErrCtr_accessResource_u8 OS_ErrCtr_callevel_u8 OS_ErrCtr_deadline_u8 OS_ErrCtr_default_u8 OS_ErrCtr_generalError_u8 OS_ErrCtr_idValue_u8
      OS_ErrCtr_limit_u8 OS_ErrCtr_noFuncState_u8 OS_ErrCtr_stackcnt_u8 OS_ErrCtr_stackstat_u8 OS_ErrCtr_sum_u8 OS_ErrCtr_timetable_u8
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboHtg_Cbxxxou
    ""

    /begin DEF_CHARACTERISTIC
      GlwPlg_rLVSPsAct_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      GlwCtl_stAftRunDelDem GlwCtl_stGlw GlwLmp_st GlwPlg_rLVS GlwPlg_rLVSPs
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_htg_cmd Vbx_htg_pwl_on Vbx_wup_cmd Vbx_wup_req Vxx_htg_pwm_prct
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboHtg_Diagxxx
    ""

    /begin LOC_MEASUREMENT
      Vbx_df_glow_cmd_fail
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboHtg_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_htg_cmd Vbx_htg_pwl_on Vbx_wup_cmd Vbx_wup_req Vxx_htg_pwm_prct
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboHtg_Inasiia
    ""

    /begin OUT_MEASUREMENT
      Air_tAFS
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboHtg_Inclcoi
    ""

    /begin OUT_MEASUREMENT
      EngDa_tFld
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboHtg_Schedul
    ""

    /begin SUB_FUNCTION
      OuCboHtg_Cbxxxou OuCboHtg_Inasiia OuCboHtg_Inclcoi
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Asbsctl
    ""

    /begin OUT_MEASUREMENT
      ACCtl_stOut PCR_stMon
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Asbsctl
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Asmactl
    ""

    /begin OUT_MEASUREMENT
      AirCtl_stMon
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Asmactl
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Cbffwsc
    ""

    /begin DEF_CHARACTERISTIC
      Cbx_fms_dwk_cor_main_cfg Cxx_fms_nLpos
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_ctCyl InjCrv_qDiffCorAfter_mp InjCrv_qDiffCorPost_mp InjCrv_qDiffCorPreInj2_mp InjCrv_qMI1Min_mp InjCrv_qPiI1Min_mp
      InjCrv_qPoI2AfterMin_mp InjCrv_qPoI2PostMin_mp
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjCrv_numPoI1Splt InjCrv_qMI1Des InjCrv_qPiI1Des InjCrv_qPiI2Des InjCrv_qPoI1Des InjCrv_qPoI1Splt
      InjCrv_qPoI2Des InjCrv_stInjCharActVal
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjCrv_qPiI1Des_mp InjCrv_qPiI1PreInj1_mp InjCrv_qPiI1PreInj2_mp InjCrv_qPoI1Des_mp InjCrv_qPoI2Des_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Cbffwts
    ""

    /begin IN_MEASUREMENT
      Epm_ctCyl
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjCrv_qPoI2Eff
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Cbffwts
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Cbtimsc
    ""

    /begin DEF_CHARACTERISTIC
      InjCrv_tiPoI1SpltDiffMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      InjCrv_tiAfterET InjCrv_tiMI1ET InjCrv_tiPiI1ET InjCrv_tiPiI2ET InjCrv_tiPoI1ET InjVlv_tiPse
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjCrv_phiPiI1Des InjCrv_phiPiI2Des InjCrv_phiPoI1Des InjCrv_phiPoI2Des InjCrv_tiPiI1Des InjCrv_tiPiI2Des
      InjCrv_tiPoI1Splt InjCrv_tiPoI1SpltDiffMin InjCrv_tiPoI2Des
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjCrv_tiPiI1PreInj1_mp InjCrv_tiPiI1PreInj2_mp InjCrv_tiPoI1SpltDiff_mp InjCrv_tiPoI1SpltSet_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Cbtimts
    ""

    /begin OUT_MEASUREMENT
      InjCrv_phiMI1Des
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Cbtimts
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Dataxxx
    ""

    /begin OUT_MEASUREMENT
      Vbx_inj_cmd_max_nok
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Dginj1x
    ""

    /begin OUT_MEASUREMENT
      Vsx_inj1_vld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_inj1_chk_sum Vbx_df_inj1_crt_intv Vbx_df_inj1_shp Vbx_df_inj_cpt_blk
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Dginj2x
    ""

    /begin OUT_MEASUREMENT
      Vsx_inj2_vld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_inj2_chk_sum Vbx_df_inj2_crt_intv Vbx_df_inj2_shp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Dginj3x
    ""

    /begin OUT_MEASUREMENT
      Vsx_inj3_vld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_inj3_chk_sum Vbx_df_inj3_crt_intv Vbx_df_inj3_shp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Dginj4x
    ""

    /begin OUT_MEASUREMENT
      Vsx_inj4_vld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_inj4_chk_sum Vbx_df_inj4_crt_intv Vbx_df_inj4_shp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Dginjxx
    ""

    /begin IN_MEASUREMENT
      Vsx_inj1_vld Vsx_inj2_vld Vsx_inj3_vld Vsx_inj4_vld
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vsx_inj_vld
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_inj1_crt_intv Vbx_df_inj2_crt_intv Vbx_df_inj3_crt_intv Vbx_inj_cmd_max_nok Vsx_inj1_vld Vsx_inj2_vld
      Vsx_inj3_vld Vsx_inj4_vld Vsx_inj_sys_vld Vsx_inj_vld Vxx_inj_dist Vxx_inj_dist_ini
      Vxx_inj_dist_l_res
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Inasiaf
    ""

    /begin OUT_MEASUREMENT
      Air_tCACDs
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      AFS_mAirPerCyl
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Inasiaf
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Inasiap
    ""

    /begin OUT_MEASUREMENT
      Air_pCACDs EnvP_p
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Inasiap
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Inclcoi
    ""

    /begin OUT_MEASUREMENT
      EngDa_tEng
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Inclcoi
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Injdist
    ""

    /begin OUT_MEASUREMENT
      Vxx_inj_dist Vxx_inj_dist_ini Vxx_inj_dist_l_res
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Injdist
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Injsysx
    ""

    /begin IN_MEASUREMENT
      Vsx_ff_actr_vld Vsx_ff_fct_vld Vsx_fprs_actr_vld Vsx_fprs_fct_vld Vsx_inj_vld Vsx_sens_rail_prs_vld
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vsx_inj_sys_vld
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboInj_Inpcapi
    ""

    /begin OUT_MEASUREMENT
      APP_r
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Inpcapi
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Inpcbki
    ""

    /begin DEF_CHARACTERISTIC
      Brk_stDflVal_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Brk_st
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Inpcbki
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Inpcdl2
    ""

    /begin OUT_MEASUREMENT
      PT_rGrip PT_stGrip
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Inpcdl2
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Inpcdls
    ""

    /begin DEF_CHARACTERISTIC
      Clth_stDflVal_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Clth_st PT_stTraType Tra_numGearDes
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Inpcdls
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Invfaci
    ""

    /begin DEF_CHARACTERISTIC
      AirC_pDfl_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      AirC_pClnt
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Invfaci
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Invfcri
    ""

    /begin OUT_MEASUREMENT
      T15_st
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Invfcri
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Invfvs1
    ""

    /begin OUT_MEASUREMENT
      GlbDa_lTotDst
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Invfvs1
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Lblibcs
    ""

    /begin OUT_MEASUREMENT
      FlSys_rhoFl
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Lblibcs
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Pcpactl
    ""

    /begin DEF_CHARACTERISTIC
      PT_rTrqDfl_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      PT_rTrq
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Pcpactl
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Schedul
    ""

    /begin SUB_FUNCTION
      OuCboInj_Asbsctl OuCboInj_Asmactl OuCboInj_Cbffwsc OuCboInj_Cbffwts OuCboInj_Cbtimsc OuCboInj_Cbtimts
      OuCboInj_Dataxxx OuCboInj_Dginj1x OuCboInj_Dginj2x OuCboInj_Dginj3x OuCboInj_Dginj4x OuCboInj_Dginjxx
      OuCboInj_Inasiaf OuCboInj_Inasiap OuCboInj_Inclcoi OuCboInj_Injdist OuCboInj_Injsysx OuCboInj_Inpcapi
      OuCboInj_Inpcbki OuCboInj_Inpcdl2 OuCboInj_Inpcdls OuCboInj_Invfaci OuCboInj_Invfcri OuCboInj_Invfvs1
      OuCboInj_Lblibcs OuCboInj_Pcpactl OuCboInj_Tqlimmx OuCboInj_Tqmdfs2 OuCboInj_Tqmdfsp OuCboInj_Tqsatsm
      OuCboInj_Tqsetft OuCboInj_Vfacomn
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Tqlimmx
    ""

    /begin OUT_MEASUREMENT
      CoETS_trqInrCurrLim
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Tqlimmx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Tqmdfs2
    ""

    /begin OUT_MEASUREMENT
      InjCtl_qCurr
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Tqmdfs2
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Tqmdfsp
    ""

    /begin OUT_MEASUREMENT
      CnvSet_etaCurr
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Tqmdfsp
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Tqsatsm
    ""

    /begin OUT_MEASUREMENT
      InjSys_stCtlQnt
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Tqsatsm
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Tqsetft
    ""

    /begin DEF_CHARACTERISTIC
      PthSet_tiOvrRunCoordDebPos_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_ctCyl InjCrv_stInjCharActVal InjCtl_qSetUnBal
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      PthSet_stOvrRun PthSet_stOvrRunCoord
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Tqsetft
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboInj_Vfacomn
    ""

    /begin OUT_MEASUREMENT
      TS_stMnSwtAC
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboInj_Vfacomn
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Cbffwsc
    ""

    /begin REF_CHARACTERISTIC
      InjCrv_numInjMaxSys_C
    /end REF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      InjCrv_numInjMaxSys
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Cbffwsc
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Cbffwts
    ""

    /begin OUT_MEASUREMENT
      InjSys_qTot
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Cbffwts
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Cbrapsp
    ""

    /begin REF_CHARACTERISTIC
      Rail_pSetPointInit_C
    /end REF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Rail_pSetPointRSA
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Cbrapsp
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Cbspvcm
    ""

    /begin OUT_MEASUREMENT
      CoEOM_stOpModeAct
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Cbspvcm
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Ex
    ""

    /begin IN_MEASUREMENT
      Vsx_ff_actr_vld Vsx_fprs_actr_vld
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Factrxx
    ""

    /begin OUT_MEASUREMENT
      Vsx_ff_actr_vld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_ff_actr_blk_open
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Inclcoi
    ""

    /begin OUT_MEASUREMENT
      CEngDsT_t
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Inclcoi
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Inpcapi
    ""

    /begin OUT_MEASUREMENT
      APP_rUnFlt
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Inpcapi
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Inpcdls
    ""

    /begin OUT_MEASUREMENT
      Tra_numGear
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Invfemi
    ""

    /begin DEF_CHARACTERISTIC
      BattU_uNrm_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      BattU_facCor BattU_u
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Invfemi
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Invfvsi
    ""

    /begin OUT_MEASUREMENT
      VehV_v
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Invfvsi
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Pactrxx
    ""

    /begin OUT_MEASUREMENT
      Vsx_fprs_actr_vld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_fprs_actr_blk_clos
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Schedul
    ""

    /begin SUB_FUNCTION
      OuCboRpr_Cbffwsc OuCboRpr_Cbffwts OuCboRpr_Cbrapsp OuCboRpr_Cbspvcm OuCboRpr_Factrxx OuCboRpr_Inclcoi
      OuCboRpr_Inpcapi OuCboRpr_Inpcdls OuCboRpr_Invfemi OuCboRpr_Invfvsi OuCboRpr_Pactrxx OuCboRpr_Smisrsp
      OuCboRpr_Tqmdfsp
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Smisrsp
    ""

    /begin OUT_MEASUREMENT
      HLSDem_nSetPLo
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Smisrsp
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuCboRpr_Tqmdfsp
    ""

    /begin OUT_MEASUREMENT
      InjCtl_qSetUnBal
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuCboRpr_Tqmdfsp
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuVfoSup_Actuaxx
    ""

    /begin DEF_CHARACTERISTIC
      Cbx_l_pwl_conf Cxx_dfdec_actr_rly_oc Cxx_dfdec_actr_rly_scg Cxx_dfdec_actr_rly_scw Cxx_dfinc_actr_rly_oc Cxx_dfinc_actr_rly_scg
      Cxx_dfinc_actr_rly_scw Cxx_min_pwl_dly Cxx_pwl_dly Cxx_pwl_dly_pws_max Cxx_pwl_dly_secu
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_actr_rly_cmd Vbx_max_ecu_pws Vbx_min_ecu_pws Vbx_pwl_dly_pws Vbx_pwl_dly_secu Vbx_pwl_on
      Vbx_rly_cmd_req Vsx_actr_rly_vld Vxx_pwl_dly Vxx_pwl_dly_pws
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuVfoSup_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_actr_rly_cmd Vbx_pwl_dly_pws Vbx_rest_pwl_rtn Vsx_actr_rly_vld Vsx_pws_1_vld Vsx_pws_2_vld
      Vsx_pws_3_vld Vsx_pws_sens_acel_pdl_v1_vld Vsx_pws_sens_acel_pdl_v2_vld Vsx_pws_sens_ac_prs_vld Vsx_pws_sens_emtv_vld Vsx_pws_sens_ex_prs_vld
      Vsx_pws_sens_it_vld Vsx_pws_sens_map_vld Vsx_pws_sens_pftrelprs_vld Vsx_pws_sens_rail_prs_vld Vsx_pws_sens_ups_vld Vxx_pwl_dly
      Vxx_pwl_dly_pws Vxx_pws_1 Vxx_pws_2 Vxx_pws_3
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuVfoSup_Pwlrtnx
    ""

    /begin OUT_MEASUREMENT
      Vbx_rest_pwl_rtn
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      OuVfoSup_Pwlrtnx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    OuVfoSup_Pws3xxx
    ""

    /begin OUT_MEASUREMENT
      Vsx_pws_3_vld Vxx_pws_3
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      SSPMon_dfdec3_mp SSPMon_dfinc3_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuVfoSup_Pwsxvld
    ""

    /begin IN_MEASUREMENT
      Vsx_pws_1_vld Vsx_pws_2_vld Vsx_pws_3_vld
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vsx_pws_sens_acel_pdl_v1_vld Vsx_pws_sens_acel_pdl_v2_vld Vsx_pws_sens_ac_prs_vld Vsx_pws_sens_emtv_vld Vsx_pws_sens_ex_prs_vld Vsx_pws_sens_it_vld
      Vsx_pws_sens_map_vld Vsx_pws_sens_pftrelprs_vld Vsx_pws_sens_rail_prs_vld Vsx_pws_sens_ups_vld
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuVfoSup_Pwsxxxx
    ""

    /begin OUT_MEASUREMENT
      Vsx_pws_1_vld Vsx_pws_2_vld Vxx_pws_1 Vxx_pws_2
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      SSPMon_dfdec1_mp SSPMon_dfdec2_mp SSPMon_dfinc1_mp SSPMon_dfinc2_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    OuVfoSup_Schedul
    ""

    /begin SUB_FUNCTION
      OuVfoSup_Actuaxx OuVfoSup_Pwlrtnx OuVfoSup_Pws3xxx OuVfoSup_Pwsxvld OuVfoSup_Pwsxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    Pcp
    ""


/end FUNCTION

/begin FUNCTION

    PCV_ActrTst
    ""

    /begin DEF_CHARACTERISTIC
      PCV_facWinActrTst_CUR PCV_nDiffMaxActrTst_C PCV_nSetActrTst_C PCV_numCalcAvrgActrTst_C PCV_numCycOffActrTst_C PCV_numMaxErrActrTst_C
      PCV_numRepActrTst_C PCV_pMaxActrTst_C PCV_pMinActrTst_C PCV_pWinLoActrTst_C PCV_qDiffMaxActrTst_C PCV_rAccPedActrTst_C
      PCV_rDstHiActrTst_C PCV_rDstLoActrTst_C PCV_rMax_C PCV_rMin_C PCV_rStpActrTst_C PCV_stMskCoEOMOpModeActrTst_C
      PCV_swtNoChkRefActrTst_C PCV_tiDelMeasActrTst_C PCV_tiMaxActrTst_C PCV_tiWaitActrTst_C PCV_tMinActrTst_C PCV_uDiffMaxActrTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      APP_rUnFlt BattU_u Brk_st CEngDsT_t Clth_st CoEOM_stOpModeAct
      Epm_nEng InjCtl_qSetUnBal PCV_iActVal PCV_rPs PT_stTraType RailP_pFlt
      VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      PCV_cntErrActrTst PCV_nSetActrTst PCV_nSubsActrTst PCV_numCycOffActrTst PCV_numRepActrTst PCV_pWinActrTst
      PCV_pWinLoActrTst PCV_rDstHiActrTst PCV_rDstLoActrTst PCV_rOutActrTst PCV_rStpActrTst PCV_stDefActrTst
      PCV_stEffectActrTst PCV_stRefActrTst PCV_stRsltActrTst PCV_stStMActrTst PCV_tiDelMeasActrTst
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      PCV_cntRepActrTst_mp PCV_cntTrgOffActrTst_mp PCV_facWinActrTst_mp PCV_pAvrgActrTst_mp PCV_pStrtEvalActrTst_mp PCV_qAvrgActrTst_mp
      PCV_rStrtActrTst_mp PCV_swtSrcPSActrTst_mp PCV_tiCalcActrTst_mp PCV_tiDelActrTst_mp PCV_tiTotalActrTst_mp PCV_tiWaitActrTst_mp
      PCV_trgSigActrTst_mp PCV_uAvrgActrTst_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    PCV_Adapt
    ""

    /begin DEF_CHARACTERISTIC
      PCV_dvolPreCtlBasNom_MAP PCV_dvolUpLim_CUR PCV_facAdaptDiffI_C PCV_facAdaptDiff_C PCV_facAdaptFlowMin_C PCV_facAdaptFlow_MAP
      PCV_facAdaptMax_C PCV_facAdaptMin_C PCV_facAdaptWgh_C PCV_numAdaptMaxCycl_C PCV_numAdaptMin_C PCV_numAdaptSum_C
      PCV_numAdaptThres_C PCV_numAdapt_C PCV_pAdaptThresMax_C PCV_pAdaptThresMin_C PCV_pAdaptThres_C PCV_swtAdaptCPC_C
      PCV_swtAdaptFlow_C PCV_swtAdaptRst_C PCV_swtAdapt_C PCV_tFuelAdaptMax_C PCV_tFuelAdaptMin_C PCV_tiSwtMeUn_C
      PCV_tSwtMeUn_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st Epm_nEng FuelT_t FuelT_tFlSys InjCtl_qSetUnBal MeUn_dvolSet
      PCV_iDvt PCV_iSet PCV_pSet RailP_pFlt Rail_dvolPreCtlAdaptPCV Rail_pDvt
      Rail_pSetPoint Rail_stCtlLoop SyC_stMn SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      PCV_facAdapt PCV_facAdaptFlow PCV_stAdaptMeUn
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      PCV_ctAdaptCalc_mp PCV_ctAdaptCycl_mp PCV_ctAdaptStbl_mp PCV_ctAdaptSum_mp PCV_dvolFlow_mp PCV_dvolMeUnFlow_mp
      PCV_dvolPreCtlNom_mp PCV_numAdaptThres_mp PCV_pAdaptThres_mp PCV_pFltSum_mp PCV_pSetSum_mp PCV_stAdapt
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    PCV_DDCo
    ""

    /begin DEF_CHARACTERISTIC
      PCV_CrntCtlDT1.T1_C PCV_CrntCtlDT1.Kd_C PCV_iLin_CUR PCV_Pwm.tiPer_C PCV_Pwm.stLvl_C PCV_Pwm.rMaxDty_C
      PCV_Pwm.rPerUn_C PCV_Pwm.tiPh_C PCV_PwmOut.rMin_C PCV_PwmOut.rMax_C PCV_PwmOut.tiBtwTstSCB_C PCV_PwmOut.tiBtwTstOT_C
      PCV_PwmOut.numTstMax_C PCV_PwmOut.swtBattCor_C PCV_PwmOut.swtPsInv_C PCV_resCoil_C PCV_rSetLin_CUR PCV_rTst_C
      PCV_SRC.uMin_C PCV_SRC.uMax_C PCV_stPwrStgActv_C PCV_stPwrStgDia_C PCV_tiTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_facCor BattU_uRated CoEng_st DevLib_stPwrStgEnaCond PCV_iSet
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      PCV_iActVal PCV_rPs PCV_rSet
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      PCV_rSetDT1_mp PCV_rSetLin_mp PCV_uRaw_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    PCV_SetPTst
    ""

    /begin DEF_CHARACTERISTIC
      PCV_swtActvSetPTst_C PCV_tiMaxSetPTst_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      PCV_iSetMax_C PCV_iSetMin_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Brk_st Clth_st Epm_nEng PCV_iSet PT_stTraType VehV_v
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      PCV_cntTrgOffSetPTst_mp PCV_iEndLimSetPTst_mp PCV_iEndSetPTst PCV_iOfsSetPTst PCV_iOldSetPTst_mp PCV_iStrtLimSetPTst_mp
      PCV_iStrtSetPTst PCV_iSubstSetPTst PCV_stEffectSetPTst PCV_stParSetPTst PCV_stRefSetPTst PCV_stStMSetPTst
      PCV_tiDlySetPTst PCV_tiStpMeasSetPTst_mp PCV_tiStpSetPTst PCV_tiTotSetPTst_mp PCV_trgSigSetPTst_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    PCV_VDCo
    ""

    /begin DEF_CHARACTERISTIC
      PCV_CrntCtlI.Ki_C PCV_CrntCtlI.KiPos_C PCV_CrntCtlI.KiNeg_C PCV_CrntCtlI.WinPos_C PCV_CrntCtlI.WinNeg_C PCV_diNoStrtRmpSlp_C
      PCV_facCrntCtlInit_CUR PCV_facCrntCtlMax_C PCV_facCrntCtlMin_C PCV_iCnvPres_CUR PCV_iSetClose_CUR PCV_iSetMaxBattHi_C
      PCV_iSetMax_C PCV_iSetMinNoStrt_C PCV_iSetMin_C PCV_nSetClose_C PCV_numNoStrt_C PCV_swtClose_C
      PCV_tiCrntCtlInit_C PCV_tiDurClose_C PCV_tiFlt1PT1_C PCV_tiFlt2PT1_C PCV_tiFltPT1Init_C PCV_tiNoClose_C
      PCV_tiNoStrt_C PCV_tiSetCloseMax_C PCV_uBattHi_C PCV_uBattLo_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      Rail_stCtlLoopSel_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_u CoEng_st DevLib_stMonActrPrt EpmHCrS_stSigMode Epm_nEng FuelT_tFlSys
      PCV_facAdapt PCV_facAdaptFlow RailP_pFlt Rail_stCtlLoop Strt_st SyC_stMn
      SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      PCV_iDvt PCV_iSet PCV_iSetFlt PCV_pSet PCV_stNoStrt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      PCV_ctNoStrtAct_mp PCV_ctNoStrtLstCyc_mp PCV_facCrntCtlLim_mp PCV_iActFlt_mp PCV_iAct_mp PCV_iCnvPresAdapt_mp
      PCV_iCnvPres_mp PCV_iSetClose_mp PCV_iSetMax_mp PCV_iSetMin_mp PCV_stActrCtl PCV_stEngStrtMov_mp
      PCV_stSetClose_mp PCV_swtCtlState PCV_tiNoStrt_mp PCV_tiSetCloseMax_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    PCV_VDLeak
    ""

    /begin DEF_CHARACTERISTIC
      PCV_dvolLeak_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Rail_pSetPoint
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      PCV_dvolLeak_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Pmd
    ""


/end FUNCTION

/begin FUNCTION

    Port
    ""


/end FUNCTION

/begin FUNCTION

    PwmHal
    ""


/end FUNCTION

/begin FUNCTION

    PwmIn
    ""


/end FUNCTION

/begin FUNCTION

    PwmOut
    ""


/end FUNCTION

/begin FUNCTION

    Pwr
    ""


/end FUNCTION

/begin FUNCTION

    QWC_Co
    ""

    /begin DEF_CHARACTERISTIC
      QWC_facFTS_MAP QWC_qNorm_CUR QWC_stActv_C QWC_tCor_MAP QWC_tDflCEngDsT_C QWC_tDflFuelT_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CEngDsT_t FuelT_t RailP_pFlt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      QWC_facFTS QWC_qNorm QWC_st QWC_tCor
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      QWC_CEngDsT_mp QWC_FuelT_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    QWC_Lib
    ""

    /begin DEF_CHARACTERISTIC
      QWC_facCor1_MAP QWC_facCor2_MAP QWC_facPiI2PiI1_C QWC_facPiI2_C QWC_qCor1_MAP QWC_qCor2_MAP
      QWC_qMax_C QWC_qMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      InjCrv_qMI1Des InjCrv_qPiI1Des_mp InjCrv_qPoI2Des_mp RailP_pCurr_mp
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      QWC_qMI1 QWC_qPiI1 QWC_qPoI2
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      QWC_facMI1PoI2_mp QWC_facPiI2PiI1_mp QWC_facPiIMI1_mp QWC_qMI1PoI2_mp QWC_qPiI1MI1_mp QWC_qPiI2MI1_mp
      QWC_qPiI2PiI1_mp QWC_rMI1Norm_mp QWC_tiMI1PoI2Cor_mp QWC_tiMI1PoI2_mp QWC_tiPiI1MI1Cor_mp QWC_tiPiI1MI1_mp
      QWC_tiPiI2MI1Cor_mp QWC_tiPiI2MI1_mp QWC_tiPiI2PiI1Cor_mp QWC_tiPiI2PiI1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    QWC_TDiffHyd
    ""

    /begin DEF_CHARACTERISTIC
      QWC_swtDiffHydInSel_C QWC_tiDiffHyd_MAP
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      QWC_pCurrInDiffHyd_mp QWC_qDesInDiffHyd_mp QWC_tiMI1DiffHydCor_mp QWC_tiPiI1DiffHydCor_mp QWC_tiPiI2DiffHydCor_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    R2S2
    ""

    /begin DEF_CHARACTERISTIC
      R2S2_xUsedDev_CW
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    RailP_DDCo
    ""

    /begin DEF_CHARACTERISTIC
      RailP_AdcMaxVal_C RailP_pLin_CUR RailP_SRC.uMin_C RailP_SRC.uMax_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      RailP_pLin RailP_uRaw
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      RailP_pLinCurr_mp RailP_stSRCCurr_mp RailP_uRawMax RailP_uRawNoCorCur_mp RailP_uRawNoCor_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    RailP_MeasTst
    ""

    /begin IN_MEASUREMENT
      RailP_pFlt RailP_pLin Rail_pDvt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      RailP_stStMMeasTst
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      RailP_numPerMeasTst RailP_swtMeasTyp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    RailP_VDCo
    ""

    /begin DEF_CHARACTERISTIC
      RailP_pFltWinNeg_CUR RailP_swtFlt_C RailP_tiFlt1PT1_C RailP_tiFlt2PT1_C RailP_tiFlt3PT1_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      InjCtl_qSetUnBal RailP_pLin Rail_pSetPoint
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      RailP_pFlt RailP_stSubsVal
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      RailP_pCurr_mp RailP_pFltWinNeg_mp RailP_tiFltPT1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    RailP_VDGradMon
    ""

    /begin DEF_CHARACTERISTIC
      RailP_dpMaxHyd_C RailP_numGradExcdMax_C RailP_tidPresRst_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      EngDa_tiEngOffInit_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st RailP_pLin
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      RailP_stGrad
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      RailP_ctGradExcd_mp RailP_tidPresRst_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    RailP_VDOfsTst
    ""

    /begin DEF_CHARACTERISTIC
      RailP_swtOfsTst_C RailP_swtSSpMon_C RailP_tiEngOff_C RailP_tiEvalDel_C RailP_tiOfsTstAftRun_C RailP_tiOfsTstDel_CUR
      RailP_tiOfsTstStrt_C RailP_tiStrErrDel_C RailP_tOfsTstAftRun_C RailP_tOfsTstDec_C RailP_tOfsTstInc_C RailP_tOfsTstStrt_C
      RailP_uOfsAftRunMax_C RailP_uOfsAftRunMin_C RailP_uOfsStrtMax_C RailP_uOfsStrtMin_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      EngDa_tiEngOffInit_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CEngDsT_t CoEng_st EngDa_tiEngOff EpmHCrS_stSigMode Epm_nEng FuelT_tFlSys
      PCV_stNoStrt RailP_pFlt RailP_uRaw SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      RailP_uOfsStrt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      RailP_stEngStrtMov_mp RailP_stEpmTested_mp RailP_stMon_mp RailP_stOfsTstMon RailP_stOfsTstXPostDrv_mp RailP_tClntLstCyc_mp
      RailP_tiOfsTstDel_mp RailP_uOfsAftRun RailP_uOfsAftRunMax RailP_uOfsAftRunMin RailP_uOfsStrtMax RailP_uOfsStrtMin
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_CtlLoop
    ""

    /begin DEF_CHARACTERISTIC
      MeUn_dvolSet_C MeUn_swtDvolSet_C PCV_pSet_C PCV_swtPSet_C Rail_dpPCVSetShOffDec_C Rail_dvolDvtLim_C
      Rail_dvolMeUnClose_CUR Rail_dvolMeUnCtlInitI_CUR Rail_dvolMeUnOpn_CUR Rail_dvolMeUnShutOffErr_C Rail_dvolMeUnShutOff_C Rail_dvolOff_C
      Rail_dvolPCVClose_CUR Rail_dvolPCVOpn_CUR Rail_dvolStrt_C Rail_facMeUnDvt_CUR Rail_facMeUnSetPoint_MAP Rail_facPCVDvt_CUR
      Rail_facPCVFast_C Rail_nCloseCtl_C Rail_nMeUnFrzI_C Rail_nThresStrt_C Rail_numRevDel_C Rail_numRevPlaus_C
      Rail_pCloseCtl_C Rail_pDiffCloseCtl_C Rail_pDvtFltMin_C Rail_pMeUnPreCtlOff_C Rail_pMeUnPreCtlOn_C Rail_pOpnCtl_C
      Rail_pPCVInitI_MAP Rail_pSetMin_CUR Rail_stCtlLoopSel_C Rail_swtMeUnCtlIInit_C Rail_swtPCVInitI_C Rail_tiFrzIDel_C
      Rail_tiMeUnRmpDur_CUR Rail_tiPT1CPCDvt_C Rail_tiShutOffDblCtl_C Rail_tiSwtCPCMax_C Rail_tiSwtToMeUnCtl_C Rail_vMeUnThresShutOff_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st CoEng_stShutOffPath Epm_nEng FlSys_stDeflateFin FuelT_tFlSys InjCtl_qSetUnBal
      MeUn_dvolSet PCV_pSet RailP_pFlt Rail_pSetPoint Rail_stCtlType Rail_swtCtlSel
      Rail_swtPreCtl Rail_swtPress Rail_swtWindUp VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Rail_dvolEstAged Rail_dvolMeUnCtlI Rail_dvolMeUnCtlUpLim Rail_dvolPreCtl Rail_pDvt Rail_stCPC
      Rail_stCtlLoop Rail_stPCVWindUp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_dvolCPCDvtFlt_mp Rail_dvolCPCDvt_mp Rail_dvolMeUnCtlDT1_mp Rail_dvolMeUnCtlP_mp Rail_dvolMeUnCtl_mp Rail_dvolMeUnDvt
      Rail_dvolMeUnShutOff_mp Rail_dvolSetPoint_mp Rail_facMeUnTiRmpVal_mp Rail_pDvtFltLim_mp Rail_pMeUnDvt Rail_pMeUnDvtPre_mp
      Rail_pPCVCPCOfs_mp Rail_pPCVCtlDT1_mp Rail_pPCVCtlI_mp Rail_pPCVCtlPILim_mp Rail_pPCVCtlP_mp Rail_pPCVDvt
      Rail_pPCVDvtPre_mp Rail_pPCVInitI_mp Rail_pPT1Flt_mp Rail_pSetMin_mp Rail_pWindUp_mp Rail_stMeUnFrzI_mp
      Rail_stPCVFrzI_mp Rail_tiMeUnRmpDur_mp Rail_tiSwtCPC_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_CtlLoopLimMeUn
    ""

    /begin DEF_CHARACTERISTIC
      Rail_dvolMeUnCtlLoLim_C Rail_dvolMeUnCtlUpLim_C Rail_dvolMeUnCtlUpLim_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_CtlLoopLimPCV
    ""

    /begin DEF_CHARACTERISTIC
      Rail_pPCVCtlLoLimStrt_C Rail_pPCVCtlLoLim_C Rail_pPCVCtlUpLimStrt_C Rail_pPCVCtlUpLim_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_pPCVCtlLoLim_mp Rail_pPCVCtlUpLim_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_CtlLoopParaMeUn
    ""

    /begin DEF_CHARACTERISTIC
      Rail_facMeUnCtlICor_CUR Rail_facMeUnCtlPCor_CUR Rail_facOvrMeUnNegIncr_C Rail_MeUnCtlDKd_CUR Rail_MeUnCtlIKiHpTst_CUR Rail_MeUnCtlIKiNeg_CUR
      Rail_MeUnCtlIKiPos_CUR Rail_MeUnCtlIKi_CUR Rail_MeUnCtlPKpHpTst_CUR Rail_MeUnCtlPKpNeg_CUR Rail_MeUnCtlPKpPos_CUR Rail_MeUnCtlPKp_CUR
      Rail_pMeUnCtlIWinNeg_C Rail_pMeUnCtlIWinPos_C Rail_pMeUnCtlPWinNeg_C Rail_pMeUnCtlPWinPos_C Rail_pOvrMeUnThresHigh_C Rail_pOvrMeUnThresLow_C
      Rail_tiMeUnCtlDT1_CUR Rail_tiMeUnCtlPT1_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng FuelT_tFlSys RailP_pFlt
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_facMeUnCtlICor_mp Rail_facMeUnCtlPCor_mp Rail_MeUnCtlDKd_mp Rail_MeUnCtlIKiHpTst_mp Rail_MeUnCtlIKiNeg_mp Rail_MeUnCtlIKiPos_mp
      Rail_MeUnCtlIKi_mp Rail_MeUnCtlPKpHpTst_mp Rail_MeUnCtlPKpNeg_mp Rail_MeUnCtlPKpPos_mp Rail_MeUnCtlPKp_mp Rail_tiMeUnCtlDT1_mp
      Rail_tiMeUnCtlPT1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_CtlLoopParaPCV
    ""

    /begin DEF_CHARACTERISTIC
      Rail_facOvrPCVNegIncr_C Rail_PCVCtlDKd_CUR Rail_PCVCtlIKiNeg_CUR Rail_PCVCtlIKiPos_CUR Rail_PCVCtlIKi_CUR Rail_PCVCtlPKpNeg_CUR
      Rail_PCVCtlPKpPos_CUR Rail_PCVCtlPKp_CUR Rail_pOvrPCVThresHigh_C Rail_pOvrPCVThresLow_C Rail_pPCVCtlIWinNeg_C Rail_pPCVCtlIWinPos_C
      Rail_pPCVCtlPWinNeg_C Rail_pPCVCtlPWinPos_C Rail_tiPCVCtlDT1_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng RailP_pFlt
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_PCVCtlDKd_mp Rail_PCVCtlIKiNeg_mp Rail_PCVCtlIKiPos_mp Rail_PCVCtlIKi_mp Rail_PCVCtlPKpNeg_mp Rail_PCVCtlPKpPos_mp
      Rail_PCVCtlPKp_mp Rail_tiPCVCtlDT1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_CtlTypeSwt
    ""

    /begin DEF_CHARACTERISTIC
      Rail_dvolMeUnCtlType_CUR Rail_pMeUnCtlTypeHi_C Rail_pMeUnCtlTypeLo_C Rail_pSwtCPCHi_C Rail_pSwtCPCLo_C Rail_qCPCtlTypeHys_C
      Rail_qCPCtlTypeRgnHys_C Rail_qCPCtlTypeRgn_CUR Rail_qCPCtlType_CUR Rail_qMeUnCtlTypeHys_C Rail_qMeUnCtlType_CUR Rail_stOpModeRgn_C
      Rail_swtCtlType_C Rail_tiSwtCtlTypeDel_C Rail_tMeUnCtlTypeHi_C Rail_tMeUnCtlTypeLo_C Rail_tSwtCPCHi_C Rail_tSwtCPCLo_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st CoEOM_stOpModeAct Epm_nEng FlSys_p FuelT_tFlSys InjCtl_qCurr
      MeUn_dvolSet PCV_stAdaptMeUn Rail_pSetPoint Rail_stCtlLoop Rail_swtCtlSel
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_dvolMeUnCtlType_mp Rail_qCPCtlTypeRgn_mp Rail_qCPCtlType_mp Rail_qMeUnCtlType_mp Rail_stSwtCon_mp Rail_stSwtCPCCon_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_ErrDet
    ""

    /begin IN_MEASUREMENT
      VehV_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_HiPresTst
    ""

    /begin DEF_CHARACTERISTIC
      Rail_iMeUnClsHpTst_C Rail_nDiffMaxHpTst_C Rail_nHpTst_CA Rail_pDiffMaxHpTst_C Rail_pDlt5StpHpTst_C Rail_pDltHiHpTst_C
      Rail_pDltTmrUpHpTst_C Rail_pSetMaxHpTst_C Rail_pSetMinHpTst_C Rail_pSetZLHpTst_C Rail_pStepHpTst_C Rail_pTmrDwn1HpTst_C
      Rail_pTmrDwn2HpTst_C Rail_qDiffMaxHpTst_C Rail_rAccPedHpTst_C Rail_stMskCoEOMOpModeHpTst_C Rail_swt5StepHpTst_C Rail_swtCtlParHpTst_C
      Rail_swtNoChkRefHpTst_C Rail_tClntMinHpTst_C Rail_tiBuildUpMaxHpTst_CA Rail_tiDropMaxHpTst_CA Rail_tiDropMinHpTst_CA Rail_tiStepHpTst_C
      Rail_tiStrtHpTst_C Rail_tiWaitAftDropHpTst_C Rail_tiWaitHiHpTst_C Rail_tiWaitLoHpTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      APP_rUnFlt Brk_st CEngDsT_t Clth_st CoEOM_stOpModeAct Epm_nEng
      HLSDem_nSetPLo InjCtl_qSetUnBal PT_stTraType RailP_pFlt Rail_pMaxSetSubst Rail_stCtlLoop
      VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Rail_nSubsHpTst
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_cntHpTst_mp Rail_cntInjHpTst_mp Rail_iMeUnClsHpTst Rail_nHpTst Rail_nSetPntHpTst_mp Rail_pDltTmrUpHpTst
      Rail_pMinRailSetPnt_mp Rail_pSetHiHpTst Rail_pSetMaxHpTst Rail_pSetMinHpTst Rail_pSetPntHpTst_mp Rail_pSetZLHpTst
      Rail_pStepHpTst Rail_pTmrDwn1HpTst Rail_pTmrDwn2HpTst Rail_pTmrUpHpTst_mp Rail_qAvrgHpTst_mp Rail_stDwn1HpTst
      Rail_stDwn2HpTst Rail_stDwn3HpTst Rail_stDwnHpTst Rail_stEffectHpTst Rail_stRefHpTst Rail_stStMHpTst
      Rail_stUp1HpTst Rail_stUpHpTst Rail_swt5StepHpTst Rail_swtCtlParHpTst Rail_swtTstParHpTst Rail_tiDrop5StpHpTst
      Rail_tiDwnHpTst Rail_tiHpTst_mp Rail_tiRmpHpTst_mp Rail_tiUpHpTst
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_MonCPC
    ""

    /begin DEF_CHARACTERISTIC
      Rail_nCPCMin_C Rail_pCPCFltMax_C Rail_pCPCFltMin_CUR Rail_pCPCSetMax_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng PCV_pSet RailP_pFlt Rail_dpSetPointDec Rail_dpSetPointInc Rail_pSetPoint
      Rail_stCPC Rail_stCtlLoop Rail_swtCtlSel
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_pCPCFltMin_mp Rail_pCPCSetMax_mp Rail_stCPCMon1_mp Rail_stCPCMon3_mp Rail_stCPCMon4_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_MonLib
    ""


/end FUNCTION

/begin FUNCTION

    Rail_MonMeUn
    ""

    /begin DEF_CHARACTERISTIC
      Rail_dvolMeUnLimFst_CUR Rail_MeUnMon.dvolSetMin_C Rail_MeUnMon.pFltMax_C Rail_MeUnMon.pFltMax2_C Rail_MeUnMon.pDvtMax_C Rail_MeUnMon.qLoIdl_C
      Rail_MeUnMon.tLoIdl_C Rail_MeUnMon.stRls_C Rail_pMeUnDvtFst_CUR Rail_pMeUnDvtMax_CUR Rail_pMeUnDvtMin2_CUR Rail_pMeUnDvtMin_CUR
      Rail_pMeUnFltMin_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng FuelT_tFlSys InjCtl_qSetUnBal MeUn_dvolSet RailP_pFlt Rail_dpSetPointDec
      Rail_dpSetPointInc Rail_dvolMeUnCtlUpLim Rail_pDvt Rail_stCtlLoop
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_dvolMeUnLimFst_mp Rail_pMeUnDvtFst_mp Rail_pMeUnDvtMax_mp Rail_pMeUnDvtMin2_mp Rail_pMeUnDvtMin_mp Rail_pMeUnFltMin_mp
      Rail_stMeUnMon0_mp Rail_stMeUnMon1_mp Rail_stMeUnMon2_mp Rail_stMeUnMon3_mp Rail_stMeUnMon4_mp Rail_tiMeUn0Deb_mp
      Rail_tiMeUn1Deb_mp Rail_tiMeUn2Deb_mp Rail_tiMeUn3Deb_mp Rail_tiMeUn4Deb_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_MonPCV
    ""

    /begin DEF_CHARACTERISTIC
      Rail_PCVMon.pDvtMax_C Rail_PCVMon.pDvtMin_C Rail_PCVMon.pDvtMin2_C Rail_PCVMon.pSetMin_C Rail_PCVMon.pFltMax_C Rail_PCVMon.pFltMax2_C
      Rail_PCVMon.stRls_C Rail_pPCVDvtMax_CUR Rail_pPCVFltMin_CUR Rail_pPCVSetMax_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng PCV_pSet RailP_pFlt Rail_dpSetPointDec Rail_dpSetPointInc Rail_pDvt
      Rail_pSetPoint Rail_stCtlLoop
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_pPCVDvtMax_mp Rail_pPCVFltMin_mp Rail_pPCVSetMax_mp Rail_stPCVMon0_mp Rail_stPCVMon1_mp Rail_stPCVMon2_mp
      Rail_stPCVMon3_mp Rail_stPCVMon4_mp Rail_tiPCV0Deb_mp Rail_tiPCV1Deb_mp Rail_tiPCV2Deb_mp Rail_tiPCV3Deb_mp
      Rail_tiPCV4Deb_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_PGovSetup
    ""

    /begin IN_MEASUREMENT
      CoEng_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Rail_stCtlType Rail_swtCtlSel Rail_swtPreCtl Rail_swtPress Rail_swtWindUp
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_PreCtlMeUn
    ""

    /begin DEF_CHARACTERISTIC
      Rail_dvolLeak_MAP Rail_dvolPreCtlBas_MAP Rail_dvolPreCtlOfs_MAP Rail_dvolPreCtlPoI1_MAP Rail_dvolPreCtlPoI2_MAP Rail_dvolPreCtl_C
      Rail_facLeakAged_C Rail_stPreCtlMeUnSel_C Rail_swtDvolPreCtl_C Rail_volInjVlvCtl_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st Epm_ctCyl Epm_nEng Epm_numCyl FuelT_tFlSys InjCrv_qPoI1Des
      InjCrv_qPoI1Des_mp InjCrv_qPoI2Des InjCrv_qPoI2Des_mp InjCrv_stInjCharActVal InjCtl_qCurr InjCtl_qSetUnBal
      Rail_pSetPoint
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Rail_dvolPreCtlAdaptPCV
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_dvolInjVlvCtl_mp Rail_dvolLeak_mp Rail_dvolPreCtlBas_mp Rail_dvolPreCtlInit_mp Rail_dvolPreCtlInj_mp Rail_dvolPreCtlOfs_mp
      Rail_dvolPreCtlPoI1_mp Rail_dvolPreCtlPoI2_mp Rail_qPreCtlBas_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_PreCtlPCV
    ""

    /begin DEF_CHARACTERISTIC
      Rail_dvolRedOfsLimHi_C Rail_dvolRedOfsLimLo_C Rail_nRedOfsLimHi_C Rail_nRedOfsLimLo_C Rail_pDvtRedOfsLimHi_C Rail_pDvtRedOfsLimLo_C
      Rail_pPCVCloseOfs_CUR Rail_pPCVRedOfs_CUR Rail_pPreCtl_C Rail_pPreCtl_MAP Rail_pRedOfsLim_C Rail_qRedOfsLimHi_C
      Rail_qRedOfsLimLo_C Rail_swtPPreCtl_C Rail_tiDvtPressRedOfsPT1_C Rail_tiPCVRmpDur_CUR Rail_tiPCVRmpToOfs_C Rail_tiPCVRmpToRedOfs_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng HLSDem_nSetPLo InjCtl_qCurr PthSet_stOvrRun RailP_pFlt Rail_pSetPoint
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_facPCVTiRmpVal_mp Rail_facTiRmpVal_mp Rail_pPCVClose_mp Rail_pPCVOfs_mp Rail_pPCVRedOfs_mp Rail_pPreCtl_mp
      Rail_stPCVRedOfs_mp Rail_stZFCDem_mp Rail_tiPCVRmpDur_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_SetPoint
    ""

    /begin DEF_CHARACTERISTIC
      Rail_dpSetPointDec_CUR Rail_dpSetPointIncLim_MAP Rail_dpSetPointInc_MAP Rail_pSetPointInit_C Rail_pSetPoint_C Rail_stSetPointSel_C
      Rail_swtNoChkPSetPoint_C Rail_swtPSetPoint_C Rail_swtqIncSel_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_u Epm_nEng InjCtl_qCurr InjCtl_qSetUnBal InjSys_qTot RailP_pFlt
      Rail_pSetPointMax Rail_pSetPointMin Rail_pSetPointRSA Rail_pSetPointSubst Rail_stCtlLoop Rail_stCtlType
      Tra_numGear
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Rail_dpSetPointDec Rail_dpSetPointInc Rail_dpSetPointIncLim Rail_pSetPoint
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_pSetPointDec_mp Rail_pSetPointInc_mp Rail_pSetPointLim_mp Rail_pSetPointZFCLim_mp Rail_pSetPointZFC_mp Rail_qSetPointInc_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_SetPointAddCor
    ""

    /begin DEF_CHARACTERISTIC
      Rail_pSetPointMaxDef_C Rail_pSetPointMax_MAP Rail_pSetPointMinDef_C Rail_pSetPointMin_MAP
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng FuelT_t InjCtl_qCurr InjSys_qTot
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Rail_pSetPointMax Rail_pSetPointMin
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_SetPointTst
    ""

    /begin DEF_CHARACTERISTIC
      Rail_rAccPedSetPointTst_C Rail_tiMaxSetPointTst_C Rail_tMinSetPointTst_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      Rail_pMaxSetSubst_CUR Rail_pMinSetSubst_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      APP_rUnFlt Brk_st CEngDsT_t Clth_st Epm_nEng PT_stTraType
      Rail_pMaxSetSubst Rail_pSetPoint VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Rail_pSubstSetPointTst
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_cntTrgOffSetPointTst_mp Rail_pEndLimSetPointTst_mp Rail_pEndSetPointTst Rail_pOfsSetPointTst Rail_pOldSetPointTst_mp Rail_pStrtLimSetPointTst_mp
      Rail_pStrtSetPointTst Rail_stEffectSetPointTst Rail_stParSetPointTst Rail_stRefSetPointTst Rail_stStMSetPointTst Rail_tiDelSetPointTst
      Rail_tiStpMeasSetPointTst_mp Rail_tiStpSetPointTst Rail_tiTotSetPointTst_mp Rail_trgSigSetPointTst_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_SetSubst
    ""

    /begin DEF_CHARACTERISTIC
      Rail_nEngSpdLim_C Rail_pMaxSetSubst_CUR Rail_pMinSetSubst_C Rail_qSetSubstLim_C Rail_tiMaxSetSubst_C Rail_vVehSpdLim_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng InjCtl_qSetUnBal Rail_stCtlLoop VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Rail_pMaxSetSubst Rail_pSetPointSubst
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_stSetSubstCond_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_TempLim
    ""

    /begin DEF_CHARACTERISTIC
      Rail_dqLimRmp.Pos_C Rail_dqLimRmp.Neg_C Rail_facFlPLimFTSCor_CUR Rail_qFlPLim_MAP Rail_qFlTempLimMeUn_MAP Rail_qFlTempLimPCV_MAP
      Rail_stQLimFlSysActv_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng FlSys_p FuelT_t Rail_stCtlLoop
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Rail_qLim
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_facFlPLimFTSCor_mp Rail_qFlPLimCor_mp Rail_qFlPLim_mp Rail_qFlTempLim_mp Rail_stQLim_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rail_ZFCLib
    ""

    /begin DEF_CHARACTERISTIC
      Rail_pFltMinZFC_C Rail_pSetPointZFCMax_C Rail_pSetPointZFCMin_C Rail_rFltMinSlpZFC_C Rail_rZFCInitDwn_CUR Rail_rZFCInitUp_CUR
      Rail_tiZFCDemDel_C Rail_tiZFCPT1_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      RailP_pFlt ZFC_pRailSetPoint_mp
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Rail_pZFCInit_mp Rail_stPresMinZFC_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Reg
    ""


/end FUNCTION

/begin FUNCTION

    Reset
    ""

    /begin DEF_CHARACTERISTIC
      Reset_rstFlMRErrBuf_C Reset_rstTrapErrIntrBuf_C Reset_xGrpId_C Reset_xTrgId_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Reset_Env.adLoc Reset_Env.xUserValue Reset_Env.xId Reset_Env.xGrp Reset_Env.ctRst Reset_FlMRErrBuf
      Reset_TrapErrIntrBuf Reset_xHistBuf Reset_xId
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Reset_MoCADC_st Reset_MoCADC_uTst Reset_MoCCom_st Reset_MoCMem_st Reset_MoCSOP_st Reset_MoFESpd_nEngShftd
      Reset_Mo_ctRst Reset_Mo_stMoC Reset_Vxx_acel_pdl_sens_v1 Reset_Vxx_tqi_fim_tot
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Rtmo
    ""

    /begin DEF_CHARACTERISTIC
      Rtmo_adCalling_u32 Rtmo_adData_u32 Rtmo_stSampleTime_u8 Rtmo_swLoadMode_u8 Rtmo_swMode_u8 Rtmo_tiIntOverhead_Tick
      Rtmo_tiOverhead_Tick
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Rtmo_ctInterrupt_u16 Rtmo_ctReentrantSample_u32 Rtmo_ctSampleProc_u8 Rtmo_ctSample_u16 Rtmo_flState_u8 Rtmo_tiAvrg_Tick
      Rtmo_tiLoad_u16 Rtmo_tiMaxCalldist_Tick Rtmo_tiMaxLoadRun_u16 Rtmo_tiMaxLoad_u16 Rtmo_tiMax_Tick Rtmo_tiMinCalldist_Tick
      Rtmo_tiMin_Tick Rtmo_tiSampleDuration_Tick
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    SBAm160
    ""


/end FUNCTION

/begin FUNCTION

    SBAm320
    ""


/end FUNCTION

/begin FUNCTION

    SBCan
    ""


/end FUNCTION

/begin FUNCTION

    SBCpu
    ""


/end FUNCTION

/begin FUNCTION

    SBDlite
    ""


/end FUNCTION

/begin FUNCTION

    SBFlash
    ""


/end FUNCTION

/begin FUNCTION

    SBIfxFlash
    ""


/end FUNCTION

/begin FUNCTION

    SBMain
    ""


/end FUNCTION

/begin FUNCTION

    SBPOTest
    ""


/end FUNCTION

/begin FUNCTION

    SBRBProg
    ""


/end FUNCTION

/begin FUNCTION

    SBReset
    ""


/end FUNCTION

/begin FUNCTION

    SBServices
    ""


/end FUNCTION

/begin FUNCTION

    SBStm58
    ""


/end FUNCTION

/begin FUNCTION

    SBTarget
    ""


/end FUNCTION

/begin FUNCTION

    SBTsw
    ""


/end FUNCTION

/begin FUNCTION

    Signals
    ""

    /begin DEF_CHARACTERISTIC
      Signals_Mode1Pid_CA Signals_Mode1SigNum_CA
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    Spi
    ""


/end FUNCTION

/begin FUNCTION

    SrvA
    ""

    /begin SUB_FUNCTION
      SrvA_Ascet
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    SrvA_Ascet
    ""


/end FUNCTION

/begin FUNCTION

    SrvB
    ""


/end FUNCTION

/begin FUNCTION

    SrvF
    ""


/end FUNCTION

/begin FUNCTION

    SrvX
    ""


/end FUNCTION

/begin FUNCTION

    SSwtS_GetSwt
    ""


/end FUNCTION

/begin FUNCTION

    SSwtS_SetSwt
    ""

    /begin DEF_CHARACTERISTIC
      SSwtS_swtGlbTyp_C SSwtS_Val.AFS_swtVal_C SSwtS_Val.ETClb_swtCorActvVal_C SSwtS_Val.GlwCtl_swtPreGlw_C SSwtS_Val.GlwCtl_swtGlwPlgMode_C SSwtS_Val.PCV_swtCtlStateVal_C
      SSwtS_Val.Rail_swtPreCtlVal_C SSwtS_Val.Rail_swtWindUpVal_C SSwtS_Val.Rail_swtCtlSelVal_C SSwtS_Val.Rail_swtPressVal_C SSwtS_Val.ZFC_swtClbActvVal_C
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    Stm58Bw016
    ""


/end FUNCTION

/begin FUNCTION

    Stub2Rb
    ""

    /begin DEF_CHARACTERISTIC
      AC_trqMaxAC_C BattU_swtRated_C EngDa_tiEngOff_C EnvT_t_C FlSys_stDeflateFin_C Fl_volTnkQnt_C
      InjCrv_rTrqInrLimMax_C InjCrv_rTrqInrLimMin_C InjCrv_stInjCharComp_C InjCrv_stInjCharShOffTst_CA InjCrv_stMI1DurCSCFrz_C InjCrv_stMI1QntCSCCorActv_C
      InjCrv_stStMShOffTst_C InjCtl_qRaw_C InjSys_qOutrCmb_C InjUn_stSta_C PthSet_trqInrSet_C SpdGov_nSetPLo_C
      Strt_stPs_C Strt_st_C ThrVlv_rAct_C TrqInrCtl_r_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Air_tAFS Air_tCACDs
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      AC_trqMaxAC AirSys_tFld Air_tiRawTAFS ASMod_rLamRecExhMnfDs BattU_uRated Dspl_bFlTnk
      Dspl_volFlTnkQnt EGRVlv_stAdap EGRVlv_stMon EngDa_tiEngOff EnvT_t Exh_pPFltDiff
      FlSys_stDeflateFin Fl_volTnkQnt InjCrv_phiPiI3Des InjCrv_qPiI3Des InjCrv_rTrqInrLimMax InjCrv_rTrqInrLimMin
      InjCrv_stInjCharComp InjCrv_stInjCharShOffTst InjCrv_stMI1DurCSCFrz InjCrv_stMI1QntCSCCorActv InjCrv_stStMShOffTst InjCtl_qRaw
      InjSys_qOutrCmb InjUn_stSta PSP_st PthSet_trqInrSet SpdGov_nSetPLo Strt_st
      Strt_stPs T50_st ThrVlv_rAct ThrVlv_stAdap TrqInrCtl_r
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Stubb
    ""

    /begin DEF_CHARACTERISTIC
      Cbs_mil_flsh_req Cbx_gear_cge_tqe_sp_lim Cbx_n_rams_lim_spc_act_1 Cbx_n_rams_lim_spc_act_2 Cbx_ovt_ena Cbx_pwst_prs_stt
      Csx_brk_pdl_clos Csx_inj_ecu_vld Cxs_ovt_smk_appl Cxs_ovt_tq_appl Cxx_egb_n_lim Cxx_gear_cge_fmt
      Cxx_mat Cxx_sens_prop_down_v
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_alco_typ_cfm Vbx_diag_sta_vvtc_ena Vbx_ecm_mon_rst_req Vbx_gear_cge_tqe_sp_lim Vbx_it_stop_ena Vbx_mil_flsh_req
      Vbx_n_rams_lim_spc_act_1 Vbx_n_rams_lim_spc_act_2 Vbx_ovt_ena Vbx_pwst_prs_stt Vbx_rs_dyn_mod_cfm Vbx_wf_ac_req_cfm
      Vbx_wf_alt_cfm Vbx_wf_comp_cfa_cfm Vbx_wf_ptc_cfm Vsx_brk_pdl_clos Vsx_down_egr_cool_temp_vld Vsx_inj_ecu_vld
      Vsx_wpmp_egr_vld Vxx_diag_in_vvtc_n_sub_val Vxx_down_egr_cool_temp Vxx_egb_n_lim Vxx_gear_cge_fmt Vxx_mat
      Vxx_ovt_smk_appl Vxx_ovt_tq_appl Vxx_pft_vh_dist_max_rgn_err Vxx_sens_prop_down_v
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Stubb_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_alco_typ_cfm Vbx_diag_sta_vvtc_ena Vbx_ecm_mon_rst_req Vbx_gear_cge_tqe_sp_lim Vbx_it_stop_ena Vbx_mil_flsh_req
      Vbx_n_rams_lim_spc_act_1 Vbx_n_rams_lim_spc_act_2 Vbx_ovt_ena Vbx_pwst_prs_stt Vbx_rs_dyn_mod_cfm Vbx_wf_ac_req_cfm
      Vbx_wf_alt_cfm Vbx_wf_comp_cfa_cfm Vbx_wf_ptc_cfm Vsx_brk_pdl_clos Vsx_down_egr_cool_temp_vld Vsx_inj_ecu_vld
      Vsx_wpmp_egr_vld Vxx_diag_in_vvtc_n_sub_val Vxx_down_egr_cool_temp Vxx_egb_n_lim Vxx_gear_cge_fmt Vxx_mat
      Vxx_ovt_smk_appl Vxx_ovt_tq_appl Vxx_pft_vh_dist_max_rgn_err Vxx_sens_prop_down_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    supp_calls
    ""

    /begin DEF_CHARACTERISTIC
      InjCrv_numInjMaxSys_C InjCrv_numInjRtmLim_CUR InjCrv_phiDiffBnk_C InjCrv_phiMIMax_C InjCrv_phiPiIMax_C InjCrv_phiPoIMin_C
      InjCrv_qMin_CUR InjCrv_rRtmLimEngSpdHys_C InjCrv_tiPseElec_C InjCrv_tiPseHyd_MAP
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_ctCyl Epm_nEng Epm_numCyl FlSys_rhoFl InjCrv_stInjCharActVal InjCrv_tiPoI1SpltDiffMin
      InjVlv_numInjChrgBal InjVlv_tiPse InjVlv_volMI1CorCyc InjVlv_volPiI1CorCyc InjVlv_volPiI2CorCyc InjVlv_volPoI1CorCyc
      InjVlv_volPoI2CorCyc QWC_qMI1 QWC_qPiI1 QWC_qPoI2 RailP_pFlt Rail_qLim
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjCrv_qDiffCorAfter_mp InjCrv_qDiffCorPost_mp InjCrv_qDiffCorPreInj2_mp InjCrv_qMI1Min_mp InjCrv_qPiI1Min_mp InjCrv_qPoI2AfterMin_mp
      InjCrv_qPoI2PostMin_mp InjCrv_stAfterMinRls_mp InjCrv_stAfterTiMin InjCrv_stMI1AftrTiMin InjCrv_stMI1PostTiMin InjCrv_stMI1TiMin
      InjCrv_stPiI1MinRls_mp InjCrv_stPiI1TiMin InjCrv_stPiI2TiMin InjCrv_stPoI1Splt1TiMin InjCrv_stPoI1Splt2TiMin InjCrv_stPoI1TiMin
      InjCrv_stPoI2MinRls_mp InjCrv_stPoI2TiMin InjCrv_tiAfterET InjCrv_tiMI1AftrET InjCrv_tiMI1ET InjCrv_tiMI1PostET
      InjCrv_tiPiI1ET InjCrv_tiPiI2ET InjCrv_tiPoI1ET InjCrv_tiPoI1Splt1ET InjCrv_tiPoI1Splt2ET InjCrv_tiPoI2ET
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      InjCrv_numInjLim_mp InjCrv_numInjRtmLim_mp InjCrv_phiDiffBnkPoI1_mp InjCrv_phiDiffBnk_mp InjCrv_phiMIMax_mp InjCrv_phiPiIMax_mp
      InjCrv_phiPoI1Splt2Min_mp InjCrv_phiPoIMin_mp InjCrv_qAfterDesCor_mp InjCrv_qAfterDesRls_mp InjCrv_qAfterLimCor_mp InjCrv_qAfterMI1Min_mp
      InjCrv_qAfterMinCor_mp InjCrv_qAfterSum_mp InjCrv_qAfterTotMax_mp InjCrv_qMI1AftrDesCor_mp InjCrv_qMI1AftrDesRls_mp InjCrv_qMI1AftrMinCor_mp
      InjCrv_qMI1AftrSum_mp InjCrv_qMI1DesCor_mp InjCrv_qMI1DesRls_mp InjCrv_qMI1MinCor_mp InjCrv_qMI1PostDesCor_mp InjCrv_qMI1PostDesRls_mp
      InjCrv_qMI1PostMinCor_mp InjCrv_qMI1PostSum_mp InjCrv_qMI1Sum_mp InjCrv_qPause_mp InjCrv_qPiI1DesCor_mp InjCrv_qPiI1DesRls_mp
      InjCrv_qPiI1LimCor_mp InjCrv_qPiI1MI1Min_mp InjCrv_qPiI1MinCor_mp InjCrv_qPiI1TotMax_mp InjCrv_qPiI2Minp1_mp InjCrv_qPoI1Min_mp
      InjCrv_qPoI1Splt1Min_mp InjCrv_qPoI1Splt2Min_mp InjCrv_qPoI2After_mp InjCrv_qPoI2DesCor_mp InjCrv_qPoI2DesRls_mp InjCrv_qPoI2LimCor_mp
      InjCrv_qPoI2MI1Min_mp InjCrv_qPoI2MinCor_mp InjCrv_qPoI2Sum_mp InjCrv_qPoI2TotMax_mp InjCrv_stAfterMinQnt_mp InjCrv_stPiI1MinQnt_mp
      InjCrv_stPoI2MinQnt_mp InjCrv_stPoI2TiMin_mp InjCrv_tiPseAfter_mp InjCrv_tiPseLatePost_mp InjCrv_tiPseNxtCylPoI1_mp InjCrv_tiPseNxtCyl_mp
      InjCrv_tiPsePinj1Pinj2_mp InjCrv_tiPsePinj2Main_mp InjCrv_tiPsePoI1Splt2_mp InjCrv_tiPsePost_mp InjCrv_volAfterCor_mp InjCrv_volAfter_mp
      InjCrv_volMI1AftrCor_mp InjCrv_volMI1Aftr_mp InjCrv_volMI1Cor_mp InjCrv_volMI1PostCor_mp InjCrv_volMI1Post_mp InjCrv_volMI1_mp
      InjCrv_volPiI1Cor_mp InjCrv_volPiI1_mp InjCrv_volPiI2Cor_mp InjCrv_volPiI2_mp InjCrv_volPoI1Cor_mp InjCrv_volPoI1Splt1Cor_mp
      InjCrv_volPoI1Splt1_mp InjCrv_volPoI1Splt2Cor_mp InjCrv_volPoI1Splt2_mp InjCrv_volPoI1_mp InjCrv_volPoI2Cor_mp InjCrv_volPoI2_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    SyC_CalWakeup
    ""

    /begin IN_MEASUREMENT
      SyC_stMn SyC_stT15
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    SyC_Deadline
    ""

    /begin LOC_MEASUREMENT
      SyC_ctDeadline1msErr
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    SyC_Main
    ""

    /begin DEF_CHARACTERISTIC
      SyC_stTest_C SyC_swtTestEna_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCCom_stWDAActvMsg Mo_stIrvErrReacMsg SyC_stPostDrv SyC_stPreDrv T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      SyC_ctIrrSwOff SyC_stMn SyC_stMnOld SyC_stSub SyC_stSubOld SyC_stT15
      SyC_tiDrv SyC_tiFrst10ms SyC_tiPostDrv SyC_tiPreDrv
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      SyC_tiBoot_mp SyC_tiIniEnd_mp SyC_tiIniSyn_mp SyC_tiIni_mp SyC_tiShutdown_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    SyC_PostDrv
    ""

    /begin DEF_CHARACTERISTIC
      SyC_tiPostDrvMax_C SyC_tiPostDrvMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng MRly_st SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      SyC_stPostDrv
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      SyC_stPostDrvFin_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    SyC_PreDrv
    ""

    /begin DEF_CHARACTERISTIC
      SyC_swtPreDrv_C SyC_tiPreDrvMax_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCCom_ctErrMMMsg MRly_stAct SyC_stSub SyC_stT15 T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      SyC_stPreDrv
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      SyC_ctSwtOnCan_mp SyC_ctSwtOnEin_mp SyC_ctSwtOnStc_mp SyC_ctSwtOnWak_mp SyC_stSwtOn_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    SyC_Shutdown
    ""


/end FUNCTION

/begin FUNCTION

    SyC_StopCnt
    ""

    /begin DEF_CHARACTERISTIC
      SyC_tiDiaStopCnt_C SyC_tiStopCntMax_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      SyC_ctIrrSwOff SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      SyC_stVldTiEcuOff SyC_tiEcuOff
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      SyC_stStopCntXPostDrv_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    SyC_UnderVltg
    ""

    /begin LOC_MEASUREMENT
      SyC_ctInit_mp SyC_ctUnderVltg_mp SyC_tiUnderVltg_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    T15_DD
    ""

    /begin DEF_CHARACTERISTIC
      T15_DebRB.tiHiLo_C T15_DebRB.tiLoHi_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      T15_stRaw
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    T15_Rst
    ""


/end FUNCTION

/begin FUNCTION

    T15_VD
    ""

    /begin IN_MEASUREMENT
      T15_st T15_stRaw
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TAA_Adap
    ""

    /begin DEF_CHARACTERISTIC
      TAA_facDynMax_C TAA_facSinTab_CA TAA_nAdapMid_CA TAA_nAdapRng_CA TAA_numGapIpoInc_C TAA_numSinTab_C
      TAA_phiDiffMaxFst_CA TAA_phiDiffMax_CA TAA_stMainSpdRng_C TAA_stReqRstVal_C TAA_tiIncDvtFltFst_C TAA_tiIncDvtFlt_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      TAA_numIncGap_CA TAA_stAdapMode_C TAA_stTstMode_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      TAA_numActv TAA_stAdap TAA_stLrnMode
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      TAA_ctLrnCycl TAA_stFin
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      TAA_ctBufSect_mp TAA_facDyn_mp TAA_phiIncDvt_mp TAA_stAdapMode_mp TAA_stAdapVal TAA_stSpdRngWr_mp
      TAA_tiIncAvrg_mp TAA_tiInc_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TAA_Axispoints
    ""


/end FUNCTION

/begin FUNCTION

    TAA_Ctl
    ""

    /begin DEF_CHARACTERISTIC
      TAA_nMax_C TAA_nMin_C TAA_numActv_CA TAA_numIncGap_CA TAA_numRevCor_C TAA_rTrqMax_C
      TAA_stAdapMode_C TAA_stEvalFin_C TAA_stExtp_C TAA_stFstLrnMsk_C TAA_stTstMode_C TAA_tiEnaDel_C
      TAA_vMin_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      EpmSeq_phiInt_CA Epm_phiGap2Zero_C Epm_phiTdc1_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Brk_st Clth_st CoEng_st EpmSeq_numIncDiffInt EpmSeq_numInt EpmSyn_phiInt
      Epm_nEng Epm_numCyl Epm_phiDiffTDC Epm_stOpMode Epm_stSync PthSet_stOvrRunCoord
      PT_rTrq TAA_stFin VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      TAA_numActv TAA_stAdap TAA_stLrnMode
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      TAA_ctAngDvt_mp TAA_facIpo_mp TAA_nMinCalc_mp TAA_numIncBefGap_mp TAA_numIncIR_mp TAA_phiAngDvt_mp
      TAA_stEnaCond_mp TAA_stErr_mp TAA_stIdxSync_mp TAA_stIpoMode_mp TAA_stRev2Fin_mp TAA_stRlsOvrRunCo_mp
      TAA_stSpdRngRdHi_mp TAA_stSpdRngRdLo_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TEGRClrDs_DD
    ""

    /begin DEF_CHARACTERISTIC
      Air_SRCTEGRClrDs.uMin_C Air_SRCTEGRClrDs.uMax_C Air_swtSensPrsTEGRClrDs_C Air_tTransfTEGRClrDs_CUR
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Air_tSensTEGRClrDs Air_uRawTEGRClrDs
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ThrVlv_AxisPoints
    ""


/end FUNCTION

/begin FUNCTION

    ThrVlv_DD
    ""

    /begin DEF_CHARACTERISTIC
      ThrVlv_facCorStrt_C ThrVlv_HBrgPar.rTstDtyCyc_C ThrVlv_HBrgPar.tiDisblDiaTmpDef_C ThrVlv_HBrgPar.tiDisblDiaPermDef_C ThrVlv_HBrgPar.tiOpnLdDiaEna_C ThrVlv_HBrgPar.tiMaxOpnLdDiaEna_C
      ThrVlv_HBrgPar.rDtyCycPlausShCirGnd_C ThrVlv_HBrgPar.rDtyCycPlausShCirBatt_C ThrVlv_Pwm.tiPer_C ThrVlv_Pwm.stLvl_C ThrVlv_Pwm.rMaxDty_C ThrVlv_Pwm.rPerUn_C
      ThrVlv_Pwm.tiPh_C ThrVlv_PwmOut.rMin_C ThrVlv_PwmOut.rMax_C ThrVlv_PwmOut.tiBtwTstSCB_C ThrVlv_PwmOut.tiBtwTstOT_C ThrVlv_PwmOut.numTstMax_C
      ThrVlv_PwmOut.swtBattCor_C ThrVlv_PwmOut.swtPsInv_C ThrVlv_rActOpnLim_C ThrVlv_rCnv_CUR ThrVlv_rPwrStgDis_C ThrVlv_stChpEnaIniReq_C
      ThrVlv_stPwrStgDiaDis_C ThrVlv_stPwrStgDis_C ThrVlv_swtChpSel_C ThrVlv_swtHwSel_C ThrVlv_swtOpnLdDiaStrt_C ThrVlv_swtSelOvrCurrErr_C
      ThrVlv_tiBattCorFacFlt_C ThrVlv_tiChpEnaIni_C ThrVlv_tiVlvOpn_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_facCor CoEng_st DevLib_stPwrStgEnaCond ThrVlv_rAct ThrVlv_rTVA
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ThrVlv_rPs ThrVlv_stOpnLdDia
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ThrVlv_facCorFlt_mp ThrVlv_rCnv_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Tprot_Rp
    ""


/end FUNCTION

/begin FUNCTION

    Tprot_Std
    ""


/end FUNCTION

/begin FUNCTION

    TqSafTdm_Bipcixx
    ""

    /begin IN_MEASUREMENT
      MoFAPP_uRaw1 MoFBrk_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_sfty_sens_brk_pdl_open Vxx_sfty_acel_pdl_sens_v1
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTdm_Canmonx
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_sfty_asr_tqe_sp_msr_raw Cxx_sfty_mux_agb_tqe_nok_raw Cxx_sfty_mux_asr_tqe_nok_raw
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      Vbx_sfty_agb_tq_req Vbx_sfty_agb_tq_req_plau Vbx_sfty_msr_tq_req Vbx_sfty_msr_tq_req_plau
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTdm_Ccmonxx
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_sfty_cru_brk_nok_t Cxx_sfty_cru_brk_tout_1 Cxx_sfty_cru_brk_tout_2 Cxx_sfty_cru_brk_tout_long Cxx_sfty_cru_rest_max_v Cxx_sfty_cru_rest_min_v
      Cxx_sfty_cru_tq_req_t
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_sfty_cru_tq_req_plau
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_sfty_cru_brk Vbx_sfty_cru_brk_pdl_ok Vbx_sfty_cru_brk_pdl_ok_tmp Vbx_sfty_cru_forc_on Vbx_sfty_cru_on Vbx_sfty_cru_resu_acel_decl
      Vbx_sfty_cru_stt_act Vbx_sfty_cru_tq_req_plau_tmp_1 Vbx_sfty_cru_tq_req_plau_tmp_2 Vxx_sfty_cru_brk_t_1 Vxx_sfty_cru_brk_t_2 Vxx_sfty_cru_brk_t_long
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTdm_Drivmon
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_sfty_acel_pdl_off_sens_thd Cxx_sfty_acel_pdl_off_t_thd
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Mo_stCplChk Mo_stMoC Vxx_sfty_acel_pdl_sens_v1
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_sfty_acel_pdl_tq_req_plau
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_sfty_acel_pdl_off
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTdm_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_ajs_cut_mon
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTdm_Incanxx
    ""

    /begin OUT_MEASUREMENT
      Vxx_sfty_mux_agb_tqe_sp Vxx_sfty_mux_msr_tqe_sp
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTdm_Inspexx
    ""

    /begin LOC_MEASUREMENT
      Vxx_sfty_n
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTdm_Tdmcons
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_sfty_aftr_rst_ajs_cut_t Cxx_sfty_aftr_rst_tq_req_t Cxx_sfty_tq_req_ajs_cut_min_n Cxx_sfty_tq_req_ajs_cut_t Cxx_sfty_tq_req_min_n Cxx_sfty_tq_req_t
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Vbx_sfty_cru_tq_req_plau
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      ct_sfty_aftr_rst_ajs_cut ct_sfty_tq_req_ajs_cut ct_sfty_tq_req_plau Vbx_ajs_cut_mon Vbx_sfty_aftr_rst_ajs_cut Vbx_sfty_ajs_cut_mon
      Vbx_sfty_is_i_on Vbx_sfty_tq_req_plau Vxx_is_tqe_sp_old Vxx_sfty_n_old
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTrm_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_sfty_inj_no_tq_plau
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTrm_Injnotq
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_sfty_efy_no_nul_thd Cxx_sfty_fms_fim_no_nul_thd Cxx_sfty_fms_fim_nul_thd Cxx_sfty_tlp1_min
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_sfty_inj_no_tq_plau
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_sfty_lpos_inj Vbx_sfty_lpos_inj_no_tq Vbx_sfty_no_pinj_main_aftr Vbx_sfty_post_inj Vbx_sfty_post_inj_no_tq
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTsm_Bocboxx
    ""

    /begin IN_MEASUREMENT
      Etc_ctCurRunTst MoFETC_stTstMsg MoFOvR_stPlausInj Vbx_sfty_acel_pdl_tq_req_plau Vbx_sfty_mon_ena Vbx_sfty_sens_brk_pdl_open
      Vbx_sfty_supl_inj_nok_aftr_rst
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoFETC_stAPPIdlPos MoFETC_stBrkNotPressed MoFETC_v MoFOvR_stRls RsaETC_stEngTstActv Vbx_sfty_no_inj
      Vbx_sfty_supl_ext_ctrl_ok Vbx_sfty_supl_inj_mon_nok_mem Vbx_supl_ext_ctrl_ena
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTsm_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_sfty_supl_inj_nok_aftr_rst Vsx_sfty_tq_mon_vld
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTsm_Tsmxxxx
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_dfdec_sfty_tq_chr Cxx_dfdec_sfty_tq_clc_chr Cxx_dfdec_sfty_tq_fail Cxx_dfdec_sfty_tq_supl Cxx_dfinc_sfty_tq_chr Cxx_dfinc_sfty_tq_clc_chr
      Cxx_dfinc_sfty_tq_fail Cxx_dfinc_sfty_tq_supl Cxx_sfty_aut_eng_n_thd_h Cxx_sfty_aut_eng_n_thd_l Cxx_sfty_bch_mod_1 Cxx_sfty_bch_mod_2
      Cxx_sfty_diag_ena_eng_dly Cxx_sfty_ext_ctrl_bch_vs_thd Cxx_sfty_ext_ctrl_t Cxx_sfty_n_lim_max_thd Cxx_sfty_rst_t Cxx_sfty_stop_req_igk_rst_t
      Cxx_sfty_stop_req_t Cxx_sfty_tq_mon_t
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Vsx_ecm_mon_vld
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_sfty_tq_chr Vbx_df_sfty_tq_clc_chr Vbx_df_sfty_tq_fail Vbx_df_sfty_tq_supl Vbx_sfty_aftr_rst Vbx_sfty_aftr_rst_mem
      Vbx_sfty_eng_aut Vbx_sfty_moni_bch_ok Vbx_sfty_mon_ena Vbx_sfty_rst_req Vbx_sfty_stop_req Vbx_sfty_stop_req_aftr_rst
      Vbx_sfty_stop_req_mem Vbx_sfty_supl_inj_nok_aftr_rst Vbx_sfty_tq_mon_nok Vsx_sfty_tq_mon_vld
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TqSafTsm_Vfestxx
    ""

    /begin LOC_MEASUREMENT
      MoFICO_stPSShutOff
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TrbCh
    ""


/end FUNCTION

/begin FUNCTION

    TrbChPmp_DD
    ""

    /begin DEF_CHARACTERISTIC
      TrbChPmp_frqInactvThres_C TrbChPmp_frqSCGHiThres_C TrbChPmp_frqSCGLoThres_C TrbChPmp_stPsDiaDisbl_C TrbChPmp_stPsDisbl_C TrbChPmp_tiTurnOffDly_C
      TrbChPmp_tiTurnOnDly_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      DevLib_stPwrStgEnaCond TrbChPmp_frqPmp TrbChPmp_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      TrbChPmp_stFrqErr TrbChPmp_stPs TrbChPmp_stSCGErr
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TrbChPmp_FRQIn
    ""

    /begin IN_MEASUREMENT
      TrbChPmp_stPs
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      TrbChPmp_frqPmp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      TrbChPmp_tiPerRawVal_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    TrbCh_DD
    ""

    /begin DEF_CHARACTERISTIC
      TrbCh_Pwm.tiPer_C TrbCh_Pwm.stLvl_C TrbCh_Pwm.rMaxDty_C TrbCh_Pwm.rPerUn_C TrbCh_Pwm.tiPh_C TrbCh_PwmOut.rMin_C
      TrbCh_PwmOut.rMax_C TrbCh_PwmOut.tiBtwTstSCB_C TrbCh_PwmOut.tiBtwTstOT_C TrbCh_PwmOut.numTstMax_C TrbCh_PwmOut.swtBattCor_C TrbCh_PwmOut.swtPsInv_C
      TrbCh_rCnv_CUR TrbCh_stPsDiaDisbl_C TrbCh_stPsDisbl_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_facCor DevLib_stPwrStgEnaCond
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      TrbCh_r TrbCh_rPs
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    UaccAppl_Std
    ""


/end FUNCTION

/begin FUNCTION

    Uacc_Std
    ""


/end FUNCTION

/begin FUNCTION

    Uart
    ""


/end FUNCTION

/begin FUNCTION

    VfEstMng_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_eng_stop_srce_dft Vbx_eng_stop_srce_norm_driv Vbx_eng_stop_srce_norm_sys Vbx_eng_stop_srce_secu Vbx_it_stop_ena_act Vxx_crsh_det
      Vxx_crsh_mem Vxx_run_eng_ena
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    VfEstMng_ItClosx
    ""

    /begin IN_MEASUREMENT
      CoEng_stShutOffPath Vxx_run_eng_ena
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_it_stop_ena_act
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    VfEstMng_Mngtxxx
    ""

    /begin DEF_CHARACTERISTIC
      Cbx_rest_aftr_crsh_ena CoEng_stShutOffRSA_C Cxx_eng_stop_req_airb2_lvl1 Cxx_eng_stop_req_airb2_lvl2 Cxx_eng_stop_req_ccu Cxx_eng_stop_req_rgb
      Cxx_eng_stop_req_ssg Cxx_rest_aftr_crsh_dly
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      CoEng_stShutOffRSA Vbx_eng_stop_srce_dft Vbx_eng_stop_srce_norm_driv Vbx_eng_stop_srce_norm_sys Vbx_eng_stop_srce_secu Vxx_crsh_det
      Vxx_crsh_mem Vxx_run_eng_ena
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_crsh_lvl1_det Vbx_crsh_lvl2_det Vbx_crsh_lvl2_det_fmt Vbx_ini_dgtc Vxx_eng_run_ena_airb Vxx_eng_run_ena_ccu
      Vxx_eng_run_ena_rgb Vxx_eng_run_ena_ssg
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    VfEstMng_Schedul
    ""

    /begin SUB_FUNCTION
      VfEstMng_ItClosx VfEstMng_Mngtxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    vld_100ms
    ""


/end FUNCTION

/begin FUNCTION

    vld_10ms
    ""

    /begin OUT_MEASUREMENT
      Vsx_pcv_vld Vsx_vcv_vld
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ZFC_CldCmbCham
    ""

    /begin DEF_CHARACTERISTIC
      ZFC_tiCldCham_CUR ZFC_tiHotCham_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Air_tCACDs InjCtl_qSetUnBal
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ZFC_stCldCham
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ZFC_stCmbCham_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ZFC_Co
    ""

    /begin DEF_CHARACTERISTIC
      ZFC_dBPFacFBCG3_GMAP ZFC_dBPFacFBCG4_GMAP ZFC_dBPFacFBCG5_GMAP ZFC_dBPFacFBCG6_GMAP ZFC_dBPFacFBCG7_GMAP ZFC_dSegFBCCaSG3_GMAP
      ZFC_dSegFBCCaSG4_GMAP ZFC_dSegFBCCaSG5_GMAP ZFC_dSegFBCCaSG6_GMAP ZFC_dSegFBCCaSG7_GMAP ZFC_idxFBCElm_C ZFC_idxFBCVal_AXIS
      ZFC_nAvrgMax_C ZFC_nAvrgMin_C ZFC_nChngPRailMax_C ZFC_nFBCThresMax_C ZFC_nFBCVal_AXIS ZFC_nHyst_C
      ZFC_numPCLLSU_CA ZFC_pACMax_C ZFC_pBstMin_C ZFC_rAccPedMax_C ZFC_stACSel_C ZFC_stClthSel_C
      ZFC_stGearRls_CA ZFC_swtPCLActv_C ZFC_tAirThres_C ZFC_tEngThres_C ZFC_tFuelThresMax_C ZFC_tFuelThresMin_C
      ZFC_tiDelOvrRun_C ZFC_tiDelpRailLim_C ZFC_uBattMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      ACCtl_stOut AirC_pClnt Air_pCACDs Air_tCACDs BattU_u Clth_st
      EngDa_tEng Epm_nEng Epm_numCyl ETClb_stLimClbFrq FBC_Badpt FBC_ctSegInt
      FBC_dBPSum FBC_RegionChng FBC_stLearn FuelT_t PCR_stMon PthSet_stOvrRunCoord
      RailP_pFlt Tra_numGearDes TS_stMnSwtAC VehV_v ZFC_stCldCham
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ZFC_swtPCLActv
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ZFC_dpRailLim_mp ZFC_dpRail_mp ZFC_idxFBCElm_mp ZFC_pRailSetPoint_mp ZFC_stClbCond ZFC_stDem_mp
      ZFC_st_mp ZFC_swtClbActv ZFC_vStopClb_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ZFC_EvalEngSpd
    ""

    /begin IN_MEASUREMENT
      Epm_numCyl
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      ZFC_SigThres_mp ZFC_Sig_mp ZFC_stEvalSig_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ZFC_EvalLam
    ""

    /begin DEF_CHARACTERISTIC
      ZFC_rPCLBnk_C ZFC_swtPCLQnt_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AFS_mAirPerCyl Epm_numCyl FlSys_rhoFl LSU_rO2Adap
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      ZFC_ctPCLAccumulated_mp ZFC_qPCLAccumulated ZFC_qPCLThres_mp ZFC_qPCL_mp ZFC_stEvalPCL_mp ZFC_volPCLAccumulated
      ZFC_volPCLThres_mp ZFC_volPCL_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ZFC_Inj
    ""

    /begin DEF_CHARACTERISTIC
      ZFC_phiSet_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      ZFC_numCylInj_mp ZFC_phiInj_mp ZFC_stInj_mp ZFC_tiET_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin COMPU_METHOD

    Acc
    ""
    RAT_FUNC
    "%6.5"
    "m/s^2"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AccGrv
    ""
    RAT_FUNC
    "%6.4"
    "g"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ActAngle
    ""
    RAT_FUNC
    "%6.4"
    "deg"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ADDHTR_ACTRENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ADDHTR_ACTRENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ADDHTR_ACTRENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    AgCrSHiReso
    ""
    RAT_FUNC
    "%6.5"
    "deg CrS"

    COEFFS 0 5825.4222222208 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirFlow_egaf_RSA
    ""
    RAT_FUNC
    "%6.3"
    "m3/h"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirFlRat
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 200 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMass
    ""
    RAT_FUNC
    "%6.4"
    "g"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMassPerCyl
    ""
    RAT_FUNC
    "%6.3"
    "mg/Hub"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMassPerTime
    ""
    RAT_FUNC
    "%6.3"
    "Kg/h"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMassPerTimeMgScnd
    ""
    RAT_FUNC
    "%6.3"
    "mg/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMassPerTime_2
    ""
    RAT_FUNC
    "%7.6"
    "g/s"

    COEFFS 0 31250 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMassPerTime_float
    ""
    RAT_FUNC
    "%6.2"
    "Kg/h"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMass_2
    ""
    RAT_FUNC
    "%6.3"
    "g"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Airmass_float
    ""
    RAT_FUNC
    "%6.2"
    "g"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMass_mgStroke01_RSA
    ""
    RAT_FUNC
    "%6.3"
    "mg/stroke"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirSysDdT_ms
    ""
    RAT_FUNC
    "%12.3"
    "ms"

    COEFFS 0 0 1 0 9.31322574615479e-006 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirSysSwt
    ""
    RAT_FUNC
    "%10.9"
    "-"

    COEFFS 0 16384000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirSysSwt_S16
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 16384 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    AirTempFldSel
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AirTempFldSel
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AirTempFldSel
    ""
    TAB_VERB
    3
    0 "Air_tCACDs"
    1 "Air_tAFS"
    2 "EnvT_t"


/end COMPU_VTAB

/begin COMPU_METHOD

    AirVolPerTime
    ""
    RAT_FUNC
    "%6.3"
    "m^3/h"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    AIR_NUMTEMPSENSMON_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AIR_NUMTEMPSENSMON_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AIR_NUMTEMPSENSMON_SY_Compu
    ""
    TAB_VERB
    3
    3 "THREE"
    4 "FOUR"
    5 "FIVE"


/end COMPU_VTAB

/begin COMPU_METHOD

    AltChpTemp_q8p0_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "deg C"

    COEFFS 0 0.125 4 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AltCrntLim_A_q0p25_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "A"

    COEFFS 0 4 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AltCrntOut_A_q0p125_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "A"

    COEFFS 0 8 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AltLd_q3p125_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "%"

    COEFFS 0 0.32 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AltVltg_V_q0p1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "V"

    COEFFS 0 10 -106 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ampere
    ""
    RAT_FUNC
    "%6.3"
    "mA"

    COEFFS 0 5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ampere_q0p1_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "uA"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AMPTgPerSec
    ""
    RAT_FUNC
    "%6.4"
    "g/s"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AMPT_NOx
    ""
    RAT_FUNC
    "%8.7"
    "g/s"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AMPT_NOxLdUnld
    ""
    RAT_FUNC
    "%7.6"
    "g/s"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AMPT_NOxRgn
    ""
    RAT_FUNC
    "%6.5"
    "g/s"

    COEFFS 0 2000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AMPT_SOx1
    ""
    RAT_FUNC
    "%6.4"
    "mg/s"

    COEFFS 0 333.333333333333 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AngleCrS
    ""
    RAT_FUNC
    "%6.4"
    "deg CrS"

    COEFFS 0 45.5111111111 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AngleCrSRSA
    ""
    RAT_FUNC
    "%6.4"
    "deg CrS"

    COEFFS 0 50 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AngleIndexCpp
    ""
    RAT_FUNC
    "%6.2"
    "AgCA"

    COEFFS 0 -1 180 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AngleStWhl
    ""
    RAT_FUNC
    "%6.4"
    "deg StWhl"

    COEFFS 0 32 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AngleVelStWhl
    ""
    RAT_FUNC
    "%6.4"
    "deg StWhl/s"

    COEFFS 0 32 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Area
    ""
    RAT_FUNC
    "%6.5"
    "m*m"

    COEFFS 0 8192 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Area2EffGrad
    ""
    RAT_FUNC
    "%6.4"
    "1/(cm^2*s)"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Area_cm2
    ""
    RAT_FUNC
    "%6.5"
    "cm*cm"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Area_cm2_float
    ""
    RAT_FUNC
    "%6.2"
    "cm*cm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Area_cm2_Low
    ""
    RAT_FUNC
    "%6.4"
    "cm*cm"

    COEFFS 0 250 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AshEGMassPerTime
    ""
    RAT_FUNC
    "%6.5"
    "mg/s"

    COEFFS 0 2000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AshMassPerTime
    ""
    RAT_FUNC
    "%6.4"
    "mg/s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AshMs_g_p0q1_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "g"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AshMs_mg_p0q0016_COMPU
    ""
    RAT_FUNC
    "%6.4"
    "mg"

    COEFFS 0 625 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ASMod_HtFlw
    ""
    RAT_FUNC
    "%6.2"
    "J/s"

    COEFFS 0 0.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Bar01_RSA
    ""
    RAT_FUNC
    "%6.3"
    "bar"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    bicbiueg_dgdgtdat_rich_prop_up
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 32787 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    BOOT_FSH_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF BOOT_FSH_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    BOOT_FSH_SY_Compu
    ""
    TAB_VERB
    2
    0 "INT_FSH"
    1 "EXT_FSH"


/end COMPU_VTAB

/begin COMPU_METHOD
    brk_states
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF brk_states
    
/end COMPU_METHOD

/begin COMPU_VTAB

    brk_states
    ""
    TAB_VERB
    2
    0 "Nsx_brk_pdl_off"
    1 "Nsx_brk_pdl_on"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD

    Calory
    ""
    RAT_FUNC
    "%6.2"
    "J/g"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CalVal_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "MJ/Kg"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Capacity_PA
    ""
    RAT_FUNC
    "%6.5"
    "uF"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    CASTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CASTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CASTYP_SY_Compu
    ""
    TAB_VERB
    5
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_ADAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_ADAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_ADAP_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_MOUNTCHK_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_MOUNTCHK_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_MOUNTCHK_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    CERADD_TNKLVLSENS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CERADD_TNKLVLSENS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CERADD_TNKLVLSENS_SY_Compu
    ""
    TAB_VERB
    2
    0 "SENSOR_ABSENT"
    1 "SENSOR_PRESENT"


/end COMPU_VTAB

/begin COMPU_METHOD

    Charge_PA
    ""
    RAT_FUNC
    "%6.2"
    "uC"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CMBMON_OFS_FLOAT
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CmbNoi
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1024 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    CMBTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CMBTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CMBTYP_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    CnvtCoeffCatAir
    ""
    RAT_FUNC
    "%6.4"
    "J/K/s/m^2"

    COEFFS 0 50 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CnvtCoeff_Fl
    ""
    RAT_FUNC
    "%6.2"
    "J/m^2/K/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CoeffA
    ""
    RAT_FUNC
    "%6.4"
    "1/(s*Nm)"

    COEFFS 0 204.8 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CoEOMSwt
    ""
    RAT_FUNC
    "%10.9"
    "-"

    COEFFS 0 16384000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CoEOMSwt_S16
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 16384 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    COEOM_AFSQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_AFSQNTNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_AFSQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_AFSTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_AFSTRQNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_AFSTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_AIRCTLQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_AIRCTLQNTNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_AIRCTLQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_AIRCTLTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_AIRCTLTRQNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_AIRCTLTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_EGRCLGQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_EGRCLGQNTNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_EGRCLGQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_EGRCLGTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_EGRCLGTRQNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_EGRCLGTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_INJCRVPOI13NUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_INJCRVPOI13NUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_INJCRVPOI13NUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_PCRQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_PCRQNTNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_PCRQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_PCRTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_PCRTRQNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_PCRTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD

    COEOM_PSCNUMOPMODE_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    COEOM_TYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_TYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_TYP_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_VSWCTLQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_VSWCTLQNTNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_VSWCTLQNTNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    COEOM_VSWCTLTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_VSWCTLTRQNUMMAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_VSWCTLTRQNUMMAP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD

    COMassPerTime
    ""
    RAT_FUNC
    "%6.4"
    "mg/s"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CppFacCylVol
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 32768 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CppOfsFact
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 256 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    CPP_NUMMAXMEASTST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CPP_NUMMAXMEASTST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CPP_NUMMAXMEASTST_SY_Compu
    ""
    TAB_VERB
    1
    0 "32"


/end COMPU_VTAB

/begin COMPU_METHOD
    CPP_SWTINVSTDIA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CPP_SWTINVSTDIA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CPP_SWTINVSTDIA_SY_Compu
    ""
    TAB_VERB
    2
    0 "(ZERO)"
    1 "(ONE)"


/end COMPU_VTAB

/begin COMPU_METHOD

    CrSRev2CrSInc
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 60 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    CRSSENSTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRSSENSTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRSSENSTYP_SY_Compu
    ""
    TAB_VERB
    3
    0 "CRSSENS_STD"
    1 "CRSSENS_ITL"
    2 "CRSSENS_ABS"


/end COMPU_VTAB

/begin COMPU_METHOD
    CSC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CSC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CSC_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    CubMtrPerHr
    ""
    RAT_FUNC
    "%6.3"
    "m^3/h"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Curr
    ""
    RAT_FUNC
    "%6.2"
    "mA"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    CurRefPump
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF CurRefPump
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CurRefPump
    ""
    TAB_VERB
    16
    0 "0 uA"
    1 "10 uA"
    2 "20 uA"
    3 "30 uA"
    4 "40 uA"
    5 "50 uA"
    6 "60 uA"
    7 "70 uA"
    8 "80 uA"
    9 "90 uA"
    10 "100 uA"
    11 "110 uA"
    12 "120 uA"
    13 "130 uA"
    14 "140 uA"
    15 "150 uA"


/end COMPU_VTAB

/begin COMPU_METHOD

    Curr_A
    ""
    RAT_FUNC
    "%6.4"
    "A"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CylFltPrm
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 32767 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CylHtRls
    ""
    RAT_FUNC
    "%6.3"
    "J"

    COEFFS 0 4 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CylHtRlsRate
    ""
    RAT_FUNC
    "%6.4"
    "J/AgCA"

    COEFFS 0 64 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CylinderVolumeCpp
    ""
    RAT_FUNC
    "%9.8"
    "m^3"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CylK1
    ""
    RAT_FUNC
    "%6.4"
    "10^-5m^3/AgCA"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CylK2
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 16384 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CylPres
    ""
    RAT_FUNC
    "%6.4"
    "bar"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    CylPresVolt
    ""
    RAT_FUNC
    "%6.2"
    "mV"

    COEFFS 0 1.24090909090909 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DCSOVRDSDFFTLPRT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DCSOVRDSDFFTLPRT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DCSOVRDSDFFTLPRT_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DCSOVRDSENGPRT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DCSOVRDSENGPRT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DCSOVRDSENGPRT_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DCSOVRDSTRAPRT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DCSOVRDSTRAPRT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DCSOVRDSTRAPRT_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DCSOVRDSTSCDEC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DCSOVRDSTSCDEC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DCSOVRDSTSCDEC_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    DDRCTime_ms
    ""
    RAT_FUNC
    "%8.2"
    "ms"

    COEFFS 0 1 0 0 0 10 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Dens
    ""
    RAT_FUNC
    "%6.3"
    "Kg/m^3"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DensFine
    ""
    RAT_FUNC
    "%6.4"
    "Kg/m^3"

    COEFFS 0 500 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DEVLIB_4WINDIACMPNENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_4WINDIACMPNENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_4WINDIACMPNENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_ACTRPRTCMPNENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_ACTRPRTCMPNENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_ACTRPRTCMPNENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_DBG_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_DBG_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_DBG_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_DIACTLLINECMPNENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_DIACTLLINECMPNENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_DIACTLLINECMPNENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DevLib_HBrgChpSel
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DevLib_HBrgChpSel
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DevLib_HBrgChpSel
    ""
    TAB_VERB
    4
    0 "CJ230_1/TLE7209_1"
    1 "CJ230_2/TLE7209_2"
    2 "CJ230_3/TLE7209_3"
    3 "CJ230_4/TLE7209_4"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_HBRGENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_HBRGENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_HBRGENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_PSOFFOPNLD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_PSOFFOPNLD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_PSOFFOPNLD_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    DFC_OneToOne
    ""
    RAT_FUNC
    "%8.3"
    "NO"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DFC_Verb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DFC_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFC_Verb
    ""
    TAB_VERB
    304
    0 "DFC_Unused"
    1 "DFC_Cy320SpiCom"
    2 "DFC_MonUMaxSupply1"
    3 "DFC_MonUMinSupply1"
    4 "DFC_R2S2_MscComm1"
    5 "DFC_RailCPC1"
    6 "DFC_RailCPC3"
    7 "DFC_RailCPC4"
    8 "DFC_RailMeUn0"
    9 "DFC_RailMeUn1"
    10 "DFC_RailMeUn2"
    11 "DFC_RailMeUn3"
    12 "DFC_RailMeUn4"
    13 "DFC_RailPCV0"
    14 "DFC_RailPCV1"
    15 "DFC_RailPCV2"
    16 "DFC_RailPCV3"
    17 "DFC_RailPCV4"
    18 "DFC_SSpMon1"
    19 "DFC_SSpMon2"
    20 "DFC_SSpMon3"
    21 "DFC_ETClbETFltMax_0"
    22 "DFC_ETClbETFltMax_1"
    23 "DFC_ETClbETFltMax_2"
    24 "DFC_ETClbETFltMax_3"
    25 "DFC_ETClbETFltMax_4"
    26 "DFC_ETClbETFltMax_5"
    27 "DFC_ETClbETFltMin_0"
    28 "DFC_ETClbETFltMin_1"
    29 "DFC_ETClbETFltMin_2"
    30 "DFC_ETClbETFltMin_3"
    31 "DFC_ETClbETFltMin_4"
    32 "DFC_ETClbETFltMin_5"
    33 "DFC_LSUHtCoupSig"
    34 "DFC_AFSOffsDrftMax"
    35 "DFC_AFSOffsDrftMin"
    36 "DFC_AFSSRCCorMax"
    37 "DFC_AFSSRCCorMin"
    38 "DFC_AFSSRCRawMax"
    39 "DFC_AFSSRCRawMin"
    40 "DFC_AirCCmprOL"
    41 "DFC_AirCCmprRedTrqOL"
    42 "DFC_AirCCmprRedTrqSCB"
    43 "DFC_AirCCmprRedTrqSCG"
    44 "DFC_AirCCmprSCB"
    45 "DFC_AirCCmprSCG"
    46 "DFC_DSMDummy"
    47 "DFC_DevLibBattUHi"
    48 "DFC_DevLibBattULo"
    49 "DFC_ECBVlvOL"
    50 "DFC_ECBVlvOvrTemp"
    51 "DFC_ECBVlvSCB"
    52 "DFC_ECBVlvSCG"
    53 "DFC_EGRCPmpOL"
    54 "DFC_EGRCPmpSCB"
    55 "DFC_EGRCPmpSCG"
    56 "DFC_EGRVlvHBrgOpnLd"
    57 "DFC_EGRVlvHBrgOvrCurr"
    58 "DFC_EGRVlvHBrgOvrTemp"
    59 "DFC_EGRVlvHBrgShCirBatt1"
    60 "DFC_EGRVlvHBrgShCirBatt2"
    61 "DFC_EGRVlvHBrgShCirGnd1"
    62 "DFC_EGRVlvHBrgShCirGnd2"
    63 "DFC_EGRVlvHBrgShCirOvrLd"
    64 "DFC_EGRVlvHBrgTempOvrCurr"
    65 "DFC_EGRVlvHBrgUndrVltg"
    66 "DFC_EGRVlvOL"
    67 "DFC_EGRVlvOvrTemp"
    68 "DFC_EGRVlvSCB"
    69 "DFC_EGRVlvSCG"
    70 "DFC_FuelTSRCMax"
    71 "DFC_FuelTSRCMin"
    72 "DFC_GlwPlgLVSOL"
    73 "DFC_GlwPlgLVSOvrTemp"
    74 "DFC_GlwPlgLVSSCB"
    75 "DFC_GlwPlgLVSSCG"
    76 "DFC_GlwPlgOL"
    77 "DFC_GlwPlgOvrTemp"
    78 "DFC_GlwPlgPLUGErrHi"
    79 "DFC_GlwPlgPLUGErrLo"
    80 "DFC_GlwPlgPLUGErrNPL"
    81 "DFC_GlwPlgSCB"
    82 "DFC_GlwPlgSCG"
    83 "DFC_HCInjOL"
    84 "DFC_HCInjSCB"
    85 "DFC_HCInjSCG"
    86 "DFC_HCVlvOL"
    87 "DFC_HCVlvSCB"
    88 "DFC_HCVlvSCG"
    89 "DFC_InjVlvPresMin"
    90 "DFC_LSUCircNernstSig"
    91 "DFC_LSUCircPmpCurSig"
    92 "DFC_LSUCircVirtGndSig"
    93 "DFC_LSUHtrMax"
    94 "DFC_LSUHtrMin"
    95 "DFC_LSUHtrNpl"
    96 "DFC_LSUHtrSig"
    97 "DFC_LSUO2Max"
    98 "DFC_LSUO2Min"
    99 "DFC_LSUSPIBattLowMin"
    100 "DFC_LSUWireSCB"
    101 "DFC_LSUWireSCG"
    102 "DFC_LSUtExcMax"
    103 "DFC_LSUtExcMin"
    104 "DFC_MeUnOL"
    105 "DFC_MeUnOT"
    106 "DFC_MeUnSCB"
    107 "DFC_MeUnSCG"
    108 "DFC_MeUnSRCMax"
    109 "DFC_MeUnSRCMin"
    110 "DFC_PCVOL"
    111 "DFC_PCVOT"
    112 "DFC_PCVSCB"
    113 "DFC_PCVSCG"
    114 "DFC_PCVSRCMax"
    115 "DFC_PCVSRCMin"
    116 "DFC_RailPSRCMax"
    117 "DFC_RailPSRCMin"
    118 "DFC_TEGRClrDsSRCMax"
    119 "DFC_TEGRClrDsSRCMin"
    120 "DFC_ThrVlvHBrgOpnLd"
    121 "DFC_ThrVlvHBrgOvrCurr"
    122 "DFC_ThrVlvHBrgOvrTemp"
    123 "DFC_ThrVlvHBrgShCirBatt1"
    124 "DFC_ThrVlvHBrgShCirBatt2"
    125 "DFC_ThrVlvHBrgShCirGnd1"
    126 "DFC_ThrVlvHBrgShCirGnd2"
    127 "DFC_ThrVlvHBrgShCirOvrLd"
    128 "DFC_ThrVlvHBrgTempOvrCurr"
    129 "DFC_ThrVlvHBrgUndrVltg"
    130 "DFC_ThrVlvOL"
    131 "DFC_ThrVlvOvrTemp"
    132 "DFC_ThrVlvSCB"
    133 "DFC_ThrVlvSCG"
    134 "DFC_TrbChOL"
    135 "DFC_TrbChSCB"
    136 "DFC_TrbChSCG"
    137 "DFC_WaHtElOL_0"
    138 "DFC_WaHtElOL_1"
    139 "DFC_WaHtElOL_2"
    140 "DFC_WaHtElOvrTemp_0"
    141 "DFC_WaHtElOvrTemp_1"
    142 "DFC_WaHtElOvrTemp_2"
    143 "DFC_WaHtElSCB_0"
    144 "DFC_WaHtElSCB_1"
    145 "DFC_WaHtElSCB_2"
    146 "DFC_WaHtElSCG_0"
    147 "DFC_WaHtElSCG_1"
    148 "DFC_WaHtElSCG_2"
    149 "DFC_IVActrEnrgMax_0"
    150 "DFC_IVActrEnrgMax_1"
    151 "DFC_IVActrEnrgMax_2"
    152 "DFC_IVActrEnrgMax_3"
    153 "DFC_IVActrEnrgMax_4"
    154 "DFC_IVActrEnrgMax_5"
    155 "DFC_IVActrEnrgMax_6"
    156 "DFC_IVActrEnrgMax_7"
    157 "DFC_IVActrEnrgMin_0"
    158 "DFC_IVActrEnrgMin_1"
    159 "DFC_IVActrEnrgMin_2"
    160 "DFC_IVActrEnrgMin_3"
    161 "DFC_IVActrEnrgMin_4"
    162 "DFC_IVActrEnrgMin_5"
    163 "DFC_IVActrEnrgMin_6"
    164 "DFC_IVActrEnrgMin_7"
    165 "DFC_IVActrEnrgPlaus_0"
    166 "DFC_IVActrEnrgPlaus_1"
    167 "DFC_IVActrEnrgPlaus_2"
    168 "DFC_IVActrEnrgPlaus_3"
    169 "DFC_IVActrEnrgPlaus_4"
    170 "DFC_IVActrEnrgPlaus_5"
    171 "DFC_IVActrEnrgPlaus_6"
    172 "DFC_IVActrEnrgPlaus_7"
    173 "DFC_IVActrUChSRCMax"
    174 "DFC_IVActrUChSRCMin"
    175 "DFC_IVActrVltgSRCMax"
    176 "DFC_IVActrVltgSRCMin"
    177 "DFC_IVCtlTiDiff_0"
    178 "DFC_IVCtlTiDiff_1"
    179 "DFC_IVCtlTiDiff_2"
    180 "DFC_IVCtlTiDiff_3"
    181 "DFC_IVCtlTiDiff_4"
    182 "DFC_IVCtlTiDiff_5"
    183 "DFC_IVCtlUDiffUp_0"
    184 "DFC_IVCtlUDiffUp_1"
    185 "DFC_IVCtlUDiffUp_2"
    186 "DFC_IVCtlUDiffUp_3"
    187 "DFC_IVCtlUDiffUp_4"
    188 "DFC_IVCtlUDiffUp_5"
    189 "DFC_IVCtlUUp_0"
    190 "DFC_IVCtlUUp_1"
    191 "DFC_IVCtlUUp_2"
    192 "DFC_IVCtlUUp_3"
    193 "DFC_IVCtlUUp_4"
    194 "DFC_IVCtlUUp_5"
    195 "DFC_IVDiaBnkShCir"
    196 "DFC_IVDiaBnkShCirChSwt"
    197 "DFC_IVDiaChp"
    198 "DFC_IVDiaCylNoCls_0"
    199 "DFC_IVDiaCylNoCls_1"
    200 "DFC_IVDiaCylNoCls_2"
    201 "DFC_IVDiaCylNoCls_3"
    202 "DFC_IVDiaCylNoCls_4"
    203 "DFC_IVDiaCylNoCls_5"
    204 "DFC_IVDiaCylNoLd_0"
    205 "DFC_IVDiaCylNoLd_1"
    206 "DFC_IVDiaCylNoLd_2"
    207 "DFC_IVDiaCylNoLd_3"
    208 "DFC_IVDiaCylNoLd_4"
    209 "DFC_IVDiaCylNoLd_5"
    210 "DFC_IVDiaCylShCir_0"
    211 "DFC_IVDiaCylShCir_1"
    212 "DFC_IVDiaCylShCir_2"
    213 "DFC_IVDiaCylShCir_3"
    214 "DFC_IVDiaCylShCir_4"
    215 "DFC_IVDiaCylShCir_5"
    216 "DFC_IVDiaCylShCirHSLS_0"
    217 "DFC_IVDiaCylShCirHSLS_1"
    218 "DFC_IVDiaCylShCirHSLS_2"
    219 "DFC_IVDiaCylShCirHSLS_3"
    220 "DFC_IVDiaCylShCirHSLS_4"
    221 "DFC_IVDiaCylShCirHSLS_5"
    222 "DFC_IVDiaCylShCirMeas_0"
    223 "DFC_IVDiaCylShCirMeas_1"
    224 "DFC_IVDiaCylShCirMeas_2"
    225 "DFC_IVDiaCylShCirMeas_3"
    226 "DFC_IVDiaCylShCirMeas_4"
    227 "DFC_IVDiaCylShCirMeas_5"
    228 "DFC_IVPSplyStopDCDC"
    229 "DFC_LSUDynChk"
    230 "DFC_LSUDynChkDIUMPR"
    231 "DFC_LSUO2ClbMax"
    232 "DFC_LSUO2ClbMin"
    233 "DFC_LSUO2PlausMaxFLd"
    234 "DFC_LSUO2PlausMaxOvrRun"
    235 "DFC_LSUO2PlausMaxPartLd"
    236 "DFC_LSUO2PlausMinFLd"
    237 "DFC_LSUO2PlausMinOvrRun"
    238 "DFC_LSUO2PlausMinPartLd"
    239 "DFC_LSUPresCompMax"
    240 "DFC_LSUPresCompMin"
    241 "DFC_LSURiClbMax"
    242 "DFC_LSURiClbMin"
    243 "DFC_LSUTempCompMax"
    244 "DFC_LSUTempCompMin"
    245 "DFC_LSUWireIPSig"
    246 "DFC_PCVNoStrt"
    247 "DFC_RailPGradMon"
    248 "DFC_AdcIADC0Cal"
    249 "DFC_AdcIADC0Conv"
    250 "DFC_FMAErrModMax"
    251 "DFC_FMAErrModMin"
    252 "DFC_FlSysTnkLo"
    253 "DFC_IVAdjDiaIVAdj_0"
    254 "DFC_IVAdjDiaIVAdj_1"
    255 "DFC_IVAdjDiaIVAdj_2"
    256 "DFC_IVAdjDiaIVAdj_3"
    257 "DFC_IVAdjDiaIVAdj_4"
    258 "DFC_IVAdjDiaIVAdj_5"
    259 "DFC_IVAdjIVA_0"
    260 "DFC_IVAdjIVA_1"
    261 "DFC_IVAdjIVA_2"
    262 "DFC_IVAdjIVA_3"
    263 "DFC_IVAdjIVA_4"
    264 "DFC_IVAdjIVA_5"
    265 "DFC_IVPSplyDCDCOff"
    266 "DFC_LSUSPISig"
    267 "DFC_PCVfacAdaptMax"
    268 "DFC_PCVfacAdaptMin"
    269 "DFC_EEPEraseErr"
    270 "DFC_EEPRdErr"
    271 "DFC_EEPWrErr"
    272 "DFC_EpmCaSI1ErrSig"
    273 "DFC_EpmCaSI1NoSig"
    274 "DFC_EpmCaSI1OfsErr"
    275 "DFC_EpmCrSErrSig"
    276 "DFC_EpmCrSNoSig"
    277 "DFC_MRlyErlyOpng"
    278 "DFC_MRlyStk"
    279 "DFC_MoCADCNTP"
    280 "DFC_MoCADCTst"
    281 "DFC_MoCADCVltgRatio"
    282 "DFC_MoCComErrCnt"
    283 "DFC_MoCComSPI"
    284 "DFC_MoCROMErrXPg"
    285 "DFC_MoCSOPErrMMRespByte"
    286 "DFC_MoCSOPErrNoChk"
    287 "DFC_MoCSOPErrRespTime"
    288 "DFC_MoCSOPErrSPI"
    289 "DFC_MoCSOPHwNoRdy"
    290 "DFC_MoCSOPLoLi"
    291 "DFC_MoCSOPMM"
    292 "DFC_MoCSOPOSTimeOut"
    293 "DFC_MoCSOPPSIniTimeOut"
    294 "DFC_MoCSOPTimeOut"
    295 "DFC_MoCSOPUpLi"
    296 "DFC_MoFESpd"
    297 "DFC_MoFRailP"
    298 "DFC_RailPOfsTstMax"
    299 "DFC_RailPOfsTstMin"
    300 "DFC_SWReset_0"
    301 "DFC_SWReset_1"
    302 "DFC_SWReset_2"
    303 "DFC_StopCntTmr"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_COMMILDEB_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_COMMILDEB_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_COMMILDEB_SY_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_EXTDFLT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_EXTDFLT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_EXTDFLT_SY_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_SIMCOND_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_SIMCOND_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_SIMCOND_SY_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFFTLPRTOVRDSTSCINC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFFTLPRTOVRDSTSCINC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFFTLPRTOVRDSTSCINC_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    dFlConsum
    ""
    RAT_FUNC
    "%6.4"
    "l/h/s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DIAGCOM_BOOTPART_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAGCOM_BOOTPART_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAGCOM_BOOTPART_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIAGCOM_RDPI_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAGCOM_RDPI_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAGCOM_RDPI_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIAGCOM_RESPONEVT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAGCOM_RESPONEVT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAGCOM_RESPONEVT_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIAGCOM_RINGBUF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAGCOM_RINGBUF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAGCOM_RINGBUF_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    Diag_OBDPtcol_Val
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Diag_OBDPtcol_Val
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Diag_OBDPtcol_Val
    ""
    TAB_VERB
    4
    0 "INACTIVE"
    1 "CAN_15765"
    2 "KLINE_CARB_9141"
    3 "KLINE_14230"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIATST_ENBL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIATST_ENBL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIATST_ENBL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    DifCoef_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "J/m/K/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DifCoef_q0p0001_COMPU
    ""
    RAT_FUNC
    "%7.6"
    "J/m_57K/s"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DINH_DSQVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DINH_DSQVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DINH_DSQVerb
    ""
    TAB_VERB
    37
    0 "DSQ_Unused"
    304 "DSQ_DSMInhibitAlways"
    305 "DSQ_ECBVlvActr"
    306 "DSQ_EGRVlvActr"
    307 "DSQ_FuelT"
    308 "DSQ_GlwPLg"
    309 "DSQ_HCIVlvActr"
    310 "DSQ_HCVlv"
    311 "DSQ_IVDiast"
    312 "DSQ_IVPSplyDCDCOff"
    313 "DSQ_IVPlausComprTst"
    314 "DSQ_IVPlausRunUpTst"
    315 "DSQ_InjVlvInjCo"
    316 "DSQ_InjVlvPresMin"
    317 "DSQ_LSUHtPerfOK"
    318 "DSQ_LSUO2"
    319 "DSQ_MRly"
    320 "DSQ_MeUnActr"
    321 "DSQ_MeUnActrTst"
    322 "DSQ_MeUnSetPTst"
    323 "DSQ_NSCDsRLamO2"
    324 "DSQ_PCVActr"
    325 "DSQ_PCVActrTst"
    326 "DSQ_PCVSetPTst"
    327 "DSQ_RailHpTst"
    328 "DSQ_RailSetPointTst"
    329 "DSQ_RailShutOffDblCtl"
    330 "DSQ_SOPTstInjShOff"
    331 "DSQ_ThrVlvActr"
    332 "DSQ_TrbChActr"
    333 "DSQ_TrbnDsRLamO2"
    334 "DSQ_WaHtElActr_0"
    335 "DSQ_WaHtElActr_1"
    336 "DSQ_WaHtElActr_2"
    337 "DSQ_stHtgLSU"
    338 "DSQ_stLSUSrvTstDem"
    339 "DSQ_stSrvOpLSUAdap"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD

    DINH_OneToOne
    ""
    RAT_FUNC
    "%8.3"
    "NO"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DINH_SbxCfVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DINH_SbxCfVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DINH_SbxCfVerb
    ""
    TAB_VERB
    252
    0 "Sbx_cf_ac_prs_h"
    1 "Sbx_cf_ac_prs_l"
    2 "Sbx_cf_acel_pdl_chr"
    3 "Sbx_cf_acel_pdl_secu_1"
    4 "Sbx_cf_acel_pdl_secu_2"
    5 "Sbx_cf_acel_pdl_tot"
    6 "Sbx_cf_acel_pdl_v1_h"
    7 "Sbx_cf_acel_pdl_v1_l"
    8 "Sbx_cf_acel_pdl_v2_h"
    9 "Sbx_cf_acel_pdl_v2_l"
    10 "Sbx_cf_actr_rly_oc"
    11 "Sbx_cf_actr_rly_scg"
    12 "Sbx_cf_actr_rly_scw"
    13 "Sbx_cf_agb_data_chr"
    14 "Sbx_cf_agb_data_seq_ctr"
    15 "Sbx_cf_agb_data_tout"
    16 "Sbx_cf_agb_no_frm"
    17 "Sbx_cf_cata_nok_cge"
    18 "Sbx_cf_clu_cnt_nok"
    19 "Sbx_cf_doc1_utp_chr"
    20 "Sbx_cf_doc1_utp_h"
    21 "Sbx_cf_doc1_utp_l"
    22 "Sbx_cf_efi_inj_oc"
    23 "Sbx_cf_efi_inj_scg"
    24 "Sbx_cf_efi_inj_scw"
    25 "Sbx_cf_emtv_flow_meca"
    26 "Sbx_cf_emtv_hbdg_el"
    27 "Sbx_cf_emtv_hbdg_ovh"
    28 "Sbx_cf_emtv_ofs_no_norm"
    29 "Sbx_cf_emtv_reg_blk"
    30 "Sbx_cf_emtv_reg_blk_open"
    31 "Sbx_cf_emtv_reg_dirt"
    32 "Sbx_cf_esp_data_chr"
    33 "Sbx_cf_esp_data_seq_ctr"
    34 "Sbx_cf_esp_no_frm"
    35 "Sbx_cf_ex_prs_no_lk"
    36 "Sbx_cf_ex_prs_nok"
    37 "DFC_GlwPlgLVSOL"
    38 "DFC_GlwPlgLVSSCG"
    39 "DFC_GlwPlgLVSSCB"
    40 "DFC_IVDiaCylNoLd_0"
    41 "DFC_IVDiaCylNoLd_3"
    42 "DFC_IVDiaCylNoLd_1"
    43 "DFC_IVDiaCylNoLd_2"
    44 "Sbx_cf_it_hbdg_el"
    45 "Sbx_cf_it_hbdg_ovh"
    46 "Sbx_cf_it_ofs_no_norm"
    47 "Sbx_cf_it_reg_blk"
    48 "Sbx_cf_it_reg_blk_clos"
    49 "Sbx_cf_it_reg_blk_open"
    50 "Sbx_cf_it_reg_dirt"
    51 "Sbx_cf_maf_reg_neg_err"
    52 "Sbx_cf_pft_dirt"
    53 "Sbx_cf_pft_dirt_lkg"
    54 "Sbx_cf_pft_no_lk"
    55 "Sbx_cf_pft_utp_chr"
    56 "Sbx_cf_pft_utp_h"
    57 "Sbx_cf_pft_utp_l"
    58 "Sbx_cf_pft_utp_neg_err"
    59 "Sbx_cf_pft_utp_pos_err"
    60 "Sbx_cf_pws_1_h"
    61 "Sbx_cf_pws_1_l"
    62 "Sbx_cf_pws_2_h"
    63 "Sbx_cf_pws_2_l"
    64 "Sbx_cf_pws_3_h"
    65 "Sbx_cf_pws_3_l"
    66 "Sbx_cf_sens_amp_h"
    67 "Sbx_cf_sens_amp_l"
    68 "Sbx_cf_sens_emtv_nok"
    69 "Sbx_cf_sens_ex_prs_h"
    70 "Sbx_cf_sens_ex_prs_l"
    71 "Sbx_cf_sens_it_nok"
    72 "Sbx_cf_sens_maf_h"
    73 "Sbx_cf_sens_maf_l"
    74 "Sbx_cf_sens_map_h"
    75 "Sbx_cf_sens_map_l"
    76 "Sbx_cf_sens_tco_h"
    77 "Sbx_cf_sens_tco_l"
    78 "Sbx_cf_sens_tia_h"
    79 "Sbx_cf_sens_tia_l"
    80 "Sbx_cf_spg_reg_apl_down"
    81 "Sbx_cf_spg_reg_apl_up"
    82 "Sbx_cf_tbt_chr"
    83 "Sbx_cf_tbt_h"
    84 "Sbx_cf_tbt_l"
    85 "Sbx_cf_tbt_reg_neg_err"
    86 "Sbx_cf_thpl_cmd1_oc"
    87 "Sbx_cf_thpl_cmd1_scg"
    88 "Sbx_cf_thpl_cmd1_scw"
    89 "Sbx_cf_thpl_cmd2_oc"
    90 "Sbx_cf_thpl_cmd2_scg"
    91 "Sbx_cf_thpl_cmd2_scw"
    92 "Sbx_cf_thpl_cmd3_oc"
    93 "Sbx_cf_thpl_cmd3_scg"
    94 "Sbx_cf_thpl_cmd3_scw"
    95 "Sbx_cf_vb_h"
    96 "Sbx_cf_vb_l"
    97 "Sbx_cf_vb_rly_oc_scg"
    98 "Sbx_cf_vb_rly_scw"
    99 "DFC_FuelTSRCMin"
    100 "DFC_FuelTSRCMax"
    101 "DFC_MoFRailP"
    102 "Sbx_cf_rail_prs_h_lvl"
    103 "DFC_RailPSRCMin"
    104 "DFC_RailPSRCMax"
    105 "DFC_RailPGradMon"
    106 "Sbx_cf_bgin_clu_cmp"
    107 "Sbx_cf_bgin_clu_nok"
    108 "Sbx_cf_brk_pdl_cmp"
    109 "Sbx_cf_cru_cmp"
    110 "Sbx_cf_cru_sl_swi_chr"
    111 "Sbx_cf_cru_sl_tot"
    112 "Sbx_cf_cru_vs_cmp"
    113 "Sbx_cf_cru_whl_cmd_nok"
    114 "Sbx_cf_cru_whl_cmd_oc_scw"
    115 "Sbx_cf_cru_whl_cmd_oor"
    116 "Sbx_cf_efi_sldv_oc"
    117 "Sbx_cf_efi_sldv_scg"
    118 "Sbx_cf_efi_sldv_scw"
    119 "DFC_MeUnSCG"
    120 "Sbx_cf_ff_actr_blk_open"
    121 "DFC_MeUnSRCMax"
    122 "DFC_RailMeUn4"
    123 "DFC_RailMeUn3"
    124 "DFC_RailMeUn2"
    125 "DFC_RailMeUn0"
    126 "Sbx_cf_fprs_actr_blk_clos"
    127 "DFC_PCVSCG"
    128 "DFC_PCVSRCMax"
    129 "Sbx_cf_fprs_fct_dirt_lkg"
    130 "DFC_RailPCV4"
    131 "DFC_RailPCV3"
    132 "DFC_RailPCV2"
    133 "DFC_RailPCV0"
    134 "Sbx_cf_inj1_chk_sum"
    135 "Sbx_cf_inj1_crt_intv"
    136 "Sbx_cf_inj2_chk_sum"
    137 "Sbx_cf_inj2_crt_intv"
    138 "Sbx_cf_inj3_chk_sum"
    139 "Sbx_cf_inj3_crt_intv"
    140 "Sbx_cf_inj4_chk_sum"
    141 "Sbx_cf_inj4_crt_intv"
    142 "Sbx_cf_unk_thpl_chr"
    143 "Sbx_cf_unk_thpl1_chr"
    144 "Sbx_cf_unk_thpl2_chr"
    145 "Sbx_cf_unk_thpl3_chr"
    146 "Sbx_cf_unk_thpl4_chr"
    147 "Sbx_cf_wpmp_tcr_oc"
    148 "Sbx_cf_wpmp_tcr_scg"
    149 "Sbx_cf_wpmp_tcr_scw"
    150 "Sbx_cf_crk_chr"
    151 "Sbx_cf_crk_cyc"
    152 "Sbx_cf_in_cam_chr"
    153 "Sbx_cf_in_cam_crk_cmp"
    154 "Sbx_cf_in_cam_no_sig"
    155 "Sbx_cf_sens_wfl_oc"
    156 "Sbx_cf_egr_byp_h"
    157 "Sbx_cf_egr_byp_l"
    158 "Sbx_cf_vnt_h"
    159 "Sbx_cf_vnt_l"
    160 "Sbx_cf_sens_rup_l"
    161 "Sbx_cf_sens_rup_h"
    162 "Sbx_cf_rup_dirt_lkg"
    163 "Sbx_cf_rup_nok"
    164 "Sbx_cf_sfty_tq_chr"
    165 "Sbx_cf_sfty_tq_clc_chr"
    166 "DFC_MeUnSRCMin"
    167 "DFC_PCVSRCMin"
    168 "DFC_RailPCV1"
    169 "Sbx_cf_tbt_reg_apl_up"
    170 "Sbx_cf_crk_no_sig"
    171 "Sbx_cf_ecm_err_itl"
    172 "Sbx_cf_glow_cmd_fail"
    173 "DFC_IVDiaCylShCir_0"
    174 "DFC_ETClbETFltMax_0"
    175 "DFC_IVDiaCylShCirMeas_0"
    176 "DFC_ETClbETFltMin_0"
    177 "DFC_IVDiaCylShCirHSLS_0"
    178 "Sbx_cf_inj1_shp"
    179 "DFC_IVDiaCylShCir_3"
    180 "DFC_ETClbETFltMax_3"
    181 "DFC_IVDiaCylShCirMeas_3"
    182 "DFC_ETClbETFltMin_3"
    183 "DFC_IVDiaCylShCirHSLS_3"
    184 "Sbx_cf_inj2_shp"
    185 "DFC_IVDiaCylShCir_1"
    186 "DFC_ETClbETFltMax_1"
    187 "DFC_IVDiaCylShCirMeas_1"
    188 "DFC_ETClbETFltMin_1"
    189 "DFC_IVDiaCylShCirHSLS_1"
    190 "Sbx_cf_inj3_shp"
    191 "DFC_IVDiaCylShCir_2"
    192 "DFC_ETClbETFltMax_2"
    193 "DFC_IVDiaCylShCirMeas_2"
    194 "DFC_ETClbETFltMin_2"
    195 "DFC_IVDiaCylShCirHSLS_2"
    196 "Sbx_cf_inj4_shp"
    197 "Sbx_cf_ip_lght_tco_ovh"
    198 "Sbx_cf_map_nok"
    199 "Sbx_cf_tbf_fct_apl_down"
    200 "Sbx_cf_tbf_fct_apl_up"
    201 "Sbx_cf_in_cam_nok"
    202 "Sbx_cf_in_cam_cyc"
    203 "Sbx_cf_crk_cmp"
    204 "Sbx_cf_crk_shp"
    205 "Sbx_cf_crk_oc"
    206 "DFC_IVDiaBnkShCir"
    207 "DFC_IVDiaChp"
    208 "Sbx_cf_ecm_mon_secu_1"
    209 "Sbx_cf_ecm_mon_secu_2"
    210 "Sbx_cf_pft_nok_cge"
    211 "Sbx_cf_tqi_cor_chr"
    212 "DFC_RailCPC3"
    213 "DFC_RailCPC4"
    214 "DFC_RailCPC1"
    215 "DFC_RailMeUn1"
    216 "Sbx_cf_ecm_inj_cpt_blk"
    217 "Sbx_cf_ecm_inj_no_norm"
    218 "Sbx_cf_ecm_err_no_norm"
    219 "Sbx_cf_amp_reg_chr"
    220 "Sbx_cf_ups_ro2_oor"
    221 "Sbx_cf_ups_ro2_slow_trs"
    222 "Sbx_cf_ups_tip_oor"
    223 "Sbx_cf_sens_tco_sig_mcut"
    224 "Sbx_cf_inj_cpt_blk"
    225 "DFC_MeUnOT"
    226 "DFC_PCVOT"
    227 "Sbx_cf_sfty_tq_supl"
    228 "Sbx_cf_ups_uo2_oor"
    229 "Sbx_cf_ups_ecu_oor"
    230 "Sbx_cf_ups_ecu_itl"
    231 "Sbx_cf_ups_ecu_chr"
    232 "Sbx_cf_sens_ups_wire_scw"
    233 "Sbx_cf_sens_ups_virt_oc"
    234 "Sbx_cf_sens_ups_pump_oc"
    235 "Sbx_cf_sens_ups_lamb_oc"
    236 "Sbx_cf_sens_ups_heat_oc"
    237 "Sbx_cf_sens_ups_heat_ovh"
    238 "Sbx_cf_sens_ups_heat_scg"
    239 "Sbx_cf_sens_ups_heat_scw"
    240 "Sbx_cf_sens_ups_wire_scg"
    241 "Sbx_cf_wpmp_tcr_blk"
    242 "Sbx_cf_egr_byp_blk"
    243 "Sbx_cf_sfty_tq_fail"
    244 "Sbx_cf_spg_cmd_blk_clos"
    245 "Sbx_cf_sens_egr_temp_h"
    246 "Sbx_cf_sens_egr_temp_l"
    247 "Sbx_cf_mafs_apl_down"
    248 "Sbx_cf_mafs_apl_up"
    249 "Sbx_cf_oil_dil_nok"
    250 "Sbx_cf_pft_rgn_dirt"
    65535 "Sbx_not_used"
    DEFAULT_VALUE "Sbx_not_used"
/end COMPU_VTAB

/begin COMPU_METHOD

    dmNOx_mg_p_s
    ""
    RAT_FUNC
    "%6.3"
    "mg/s"

    COEFFS 0 6.66666666666667 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    dmOilAsh_mg_p_s
    ""
    RAT_FUNC
    "%6.4"
    "mg/s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    dmSoot_mg_p_s
    ""
    RAT_FUNC
    "%6.4"
    "mg/s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    dPres_hPa_p_s
    ""
    RAT_FUNC
    "%6.2"
    "hPa/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    drLamRec_Persec
    ""
    RAT_FUNC
    "%6.4"
    "1/s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DRV_T15RST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DRV_T15RST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DRV_T15RST_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_FIdExcCauseVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DSCHED_FIdExcCauseVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_FIdExcCauseVerb
    ""
    TAB_VERB
    11
    0 "No_exclusion"
    1 "FId_InhibitAlways"
    2 "FId_CoordALS"
    3 "FId_CoordFBC"
    4 "FId_CoordTAA"
    5 "FId_CoordZFC"
    6 "FId_IVPlausRunUpTstActv"
    7 "FId_RailHpTstActv"
    253 "NO_PRIO"
    254 "MODE_IMPOSSIBLE"
    255 "NO_RUN"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_FIdExcVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DSCHED_FIdExcVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_FIdExcVerb
    ""
    TAB_VERB
    8
    0 "FId_Unused"
    1 "FId_InhibitAlways"
    2 "FId_CoordALS"
    3 "FId_CoordFBC"
    4 "FId_CoordTAA"
    5 "FId_CoordZFC"
    6 "FId_IVPlausRunUpTstActv"
    7 "FId_RailHpTstActv"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_FIdVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DSCHED_FIdVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_FIdVerb
    ""
    TAB_VERB
    8
    0 "FId_Unused"
    1 "FId_InhibitAlways"
    2 "FId_CoordALS"
    3 "FId_CoordFBC"
    4 "FId_CoordTAA"
    5 "FId_CoordZFC"
    6 "FId_IVPlausRunUpTstActv"
    7 "FId_RailHpTstActv"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD

    DSCHED_RmpSlp
    ""
    RAT_FUNC
    "%6.2"
    "counts/s"

    COEFFS 0 1 0 0 0 5 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DSCHED_StVerb
    ""
    TAB_VERB
    "%6.3"
    "NO"
    COMPU_TAB_REF DSCHED_StVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_StVerb
    ""
    TAB_VERB
    64
    0 "____________________________"
    2 "_____________________RawPerm"
    4 "_________________Act________"
    6 "_________________Act_RawPerm"
    8 "_____________Lck____________"
    10 "_____________Lck_____RawPerm"
    12 "_____________Lck_Act________"
    14 "_____________Lck_Act_RawPerm"
    32 "_________Val________________"
    34 "_________Val_________RawPerm"
    36 "_________Val_____Act________"
    38 "_________Val_____Act_RawPerm"
    40 "_________Val_Lck____________"
    42 "_________Val_Lck_____RawPerm"
    44 "_________Val_Lck_Act________"
    46 "_________Val_Lck_Act_RawPerm"
    64 "____Perm____________________"
    66 "____Perm_____________RawPerm"
    68 "____Perm_________Act________"
    70 "____Perm_________Act_RawPerm"
    72 "____Perm_____Lck____________"
    74 "____Perm_____Lck_____RawPerm"
    76 "____Perm_____Lck_Act________"
    78 "____Perm_____Lck_Act_RawPerm"
    96 "____Perm_Val________________"
    98 "____Perm_Val_________RawPerm"
    100 "____Perm_Val_____Act________"
    102 "____Perm_Val_____Act_RawPerm"
    104 "____Perm_Val_Lck____________"
    106 "____Perm_Val_Lck_____RawPerm"
    108 "____Perm_Val_Lck_Act________"
    110 "____Perm_Val_Lck_Act_RawPerm"
    128 "Rdy_________________________"
    130 "Rdy__________________RawPerm"
    132 "Rdy______________Act________"
    134 "Rdy______________Act_RawPerm"
    136 "Rdy__________Lck____________"
    138 "Rdy__________Lck_____RawPerm"
    140 "Rdy__________Lck_Act________"
    142 "Rdy__________Lck_Act_RawPerm"
    160 "Rdy______Val________________"
    162 "Rdy______Val_________RawPerm"
    164 "Rdy______Val_____Act________"
    166 "Rdy______Val_____Act_RawPerm"
    168 "Rdy______Val_Lck____________"
    170 "Rdy______Val_Lck_____RawPerm"
    172 "Rdy______Val_Lck_Act________"
    174 "Rdy______Val_Lck_Act_RawPerm"
    192 "Rdy_Perm____________________"
    194 "Rdy_Perm_____________RawPerm"
    196 "Rdy_Perm_________Act________"
    198 "Rdy_Perm_________Act_RawPerm"
    200 "Rdy_Perm_____Lck____________"
    202 "Rdy_Perm_____Lck_____RawPerm"
    204 "Rdy_Perm_____Lck_Act________"
    206 "Rdy_Perm_____Lck_Act_RawPerm"
    224 "Rdy_Perm_Val________________"
    226 "Rdy_Perm_Val_________RawPerm"
    228 "Rdy_Perm_Val_____Act________"
    230 "Rdy_Perm_Val_____Act_RawPerm"
    232 "Rdy_Perm_Val_Lck____________"
    234 "Rdy_Perm_Val_Lck_____RawPerm"
    236 "Rdy_Perm_Val_Lck_Act________"
    238 "Rdy_Perm_Val_Lck_Act_RawPerm"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMAUX_TCSORT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMAUX_TCSORT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMAUX_TCSORT_SY_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    Dspl_bFlTnk_VERB
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF Dspl_bFlTnk_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Dspl_bFlTnk_VERB
    ""
    TAB_VERB
    2
    0 "NOT_EMPTY"
    1 "EMPTY"


/end COMPU_VTAB

/begin COMPU_METHOD

    dTrq
    ""
    RAT_FUNC
    "%6.3"
    "Nm/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DTR_LEGIFC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DTR_LEGIFC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DTR_LEGIFC_SY_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD

    DtyCyc
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DtyCycSlp
    ""
    RAT_FUNC
    "%6.5"
    "%/s"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    dt_TempKelv_p_s
    ""
    RAT_FUNC
    "%6.3"
    "K/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ECBVLV_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ECBVLV_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ECBVLV_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ECUOFF_TMR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ECUOFF_TMR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ECUOFF_TMR_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    ECU_GENR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ECU_GENR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ECU_GENR_SY_Compu
    ""
    TAB_VERB
    4
    0 "Mx7"
    1 "Mx9"
    2 "Mx17"
    3 "EDC17"


/end COMPU_VTAB

/begin COMPU_METHOD
    ECU_TRICORE_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ECU_TRICORE_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ECU_TRICORE_SY_Compu
    ""
    TAB_VERB
    5
    0 "no_TriCore"
    1 "TriCore_Metis"
    2 "TriCore_LedaLight"
    3 "TriCore_Metis_flashless"
    4 "TriCore_LowEnd"


/end COMPU_VTAB

/begin COMPU_METHOD
    EECR_BLDPRC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EECR_BLDPRC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EECR_BLDPRC_SY_Compu
    ""
    TAB_VERB
    2
    0 "deactivated"
    1 "activated"


/end COMPU_VTAB

/begin COMPU_METHOD
    Eeebd_EeeStates_Verb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Eeebd_EeeStates_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Eeebd_EeeStates_Verb
    ""
    TAB_VERB
    4
    0 "EEEBD_EEE_NORMALRUN"
    1 "EEEBD_EEE_FIRSTINIT"
    2 "EEEBD_EEE_SECTORCHANGE"
    3 "EEEBD_EEE_MIGRATION"


/end COMPU_VTAB

/begin COMPU_METHOD
    Eep_MainStates_Verb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Eep_MainStates_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Eep_MainStates_Verb
    ""
    TAB_VERB
    12
    0 "EEP_INI_RUN"
    1 "EEP_SHUTDWN_RUN"
    2 "EEP_NORMAL_RUN"
    3 "EEP_BEGPD_REQUEST"
    4 "EEP_BEGPD_RUN"
    5 "EEP_ENDPD_REQUEST"
    6 "EEP_ENDPD_RUN"
    7 "EEP_PREDRV_REQUEST"
    8 "EEP_PREDRV_RUN"
    9 "EEP_FIRSTINIT_INI"
    10 "EEP_RAM_INI"
    11 "EEP_ENVRAM_INI"


/end COMPU_VTAB

/begin COMPU_METHOD
    Eep_PostDrvState_Verb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Eep_PostDrvState_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Eep_PostDrvState_Verb
    ""
    TAB_VERB
    5
    0 "EEP_POSTDRV_INI"
    1 "EEP_POSTDRV_SEARCHBLKIDX"
    2 "EEP_POEEP_POSTDRV_SAVEBLK"
    3 "EEP_POSTDRV_SAVEBLK_PENDING"
    4 "EEP_POSTDRV_WAIT"


/end COMPU_VTAB

/begin COMPU_METHOD

    EffGrad
    ""
    RAT_FUNC
    "%7.6"
    "1/s"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EffGradAr
    ""
    RAT_FUNC
    "%8.7"
    "1/s"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EffGradPrc
    ""
    RAT_FUNC
    "%8.7"
    "1/s"

    COEFFS 0 819200 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EGRVLVLP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLVLP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLVLP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGRVLVLP_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLVLP_TYPTWINFLW_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLVLP_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGRVLV_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLV_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLV_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGRVLV_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLV_TYPTWINFLW_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLV_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    EGTFact
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EGTSwt
    ""
    RAT_FUNC
    "%10.9"
    "-"

    COEFFS 0 16384000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EGTSwt_S16
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 16384 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Energy
    ""
    RAT_FUNC
    "%6.2"
    "kJ"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EnergyPerMolHigh
    ""
    RAT_FUNC
    "%6.2"
    "J/mol"

    COEFFS 0 0.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EnergyPerMolLow
    ""
    RAT_FUNC
    "%6.1"
    "J/mol"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Energy_J_HiRes
    ""
    RAT_FUNC
    "%6.2"
    "J"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Energy_q0p0001
    ""
    RAT_FUNC
    "%7.6"
    "kJ"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENGDA_TIENGONOBD_SY_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGDA_TIENGONOBD_SY_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGDA_TIENGONOBD_SY_COMPU_VERB
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    EngN
    ""
    RAT_FUNC
    "%6.3"
    "rpm"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EngN2tiIncPer
    ""
    RAT_FUNC
    "%8.0"
    "rpm"

    COEFFS 0 0 1 0 4.0000002e-007 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EngNCaS
    ""
    RAT_FUNC
    "%6.3"
    "CaSrpm"

    COEFFS 0 4 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EngNGrd
    ""
    RAT_FUNC
    "%6.3"
    "rpm/s"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EngNRmp_Hi
    ""
    RAT_FUNC
    "%6.3"
    "rpm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EngN_float
    ""
    RAT_FUNC
    "%6.2"
    "rpm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EngN_HiRes
    ""
    RAT_FUNC
    "%6.4"
    "rpm"

    COEFFS 0 32 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EngN_LRes
    ""
    RAT_FUNC
    "%6.1"
    "rpm"

    COEFFS 0 0.025 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENGRESTRT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGRESTRT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGRESTRT_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    ENGSPDLIMSTRT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGSPDLIMSTRT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGSPDLIMSTRT_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    EngTempFldSel
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EngTempFldSel
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EngTempFldSel
    ""
    TAB_VERB
    3
    0 "Coolant_Temperature"
    1 "Oil_Temperature"
    2 "EngDa_tEng"


/end COMPU_VTAB

/begin COMPU_METHOD

    EnrgPerMass
    ""
    RAT_FUNC
    "%6.3"
    "MJ/Kg"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EnrgPrMol_q0p001_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "J/mol"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EpmBCa_FacTstInj
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EpmBCa_stTstInj_State_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmBCa_stTstInj_State_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmBCa_stTstInj_State_t
    ""
    TAB_VERB
    5
    0 "EPMBCA_STVOID"
    1 "EPMBCA_STINJ"
    2 "EPMBCA_STCALC"
    3 "EPMBCA_STNOSYNC"
    4 "EPMBCA_STSYNC"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmBCr_stIntrCo_State_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmBCr_stIntrCo_State_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmBCr_stIntrCo_State_t
    ""
    TAB_VERB
    4
    0 "EPMBCR_STINTRCO_NOPOS"
    1 "EPMBCR_STINTRCO_CASEDGE"
    2 "EPMBCR_STINTRCO_SYNCRO"
    3 "EPMBCR_STINTRCO_WAIT"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmBCr_stPlaus_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmBCr_stPlaus_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmBCr_stPlaus_State
    ""
    TAB_VERB
    5
    0 "EPMBCR_NOSYNC"
    1 "EPMBCR_SYNC"
    2 "EPMBCR_SEG_AFTER_SYNC"
    3 "EPMBCR_SEG2_AFTER_SYNC"
    4 "EPMBCR_SEG"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmBCr_stPos_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmBCr_stPos_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmBCr_stPos_State
    ""
    TAB_VERB
    2
    0 "EPMBCR_STPOS_NOPOS"
    1 "EPMBCR_STPOS_POSFOUND"


/end COMPU_VTAB

/begin COMPU_METHOD

    EpmCaS_Fac_Adap
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EpmCaS_Fac_Plaus
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EpmCaS_stAdap_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmCaS_stAdap_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmCaS_stAdap_State
    ""
    TAB_VERB
    5
    0 "EPMCAS_STNOADAP"
    1 "EPMCAS_STERRADAP"
    2 "EPMCAS_STADAP"
    3 "EPMCAS_STADAPSTOP"
    4 "EPMCAS_STFULLADAP"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmCaS_stOfsErr_Val
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmCaS_stOfsErr_Val
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmCaS_stOfsErr_Val
    ""
    TAB_VERB
    6
    0 "EPMCAS_OFS_AMBI"
    1 "EPMCAS_OFS_NOEQUI_EDGE"
    2 "EPMCAS_OFS_LOWEQUI_EDGE"
    3 "EPMCAS_OFS_NOREFPOS"
    4 "EPMCAS_OFS_EXCEED"
    5 "EPMCAS_OFS_OK"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmCas_stOfs_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmCas_stOfs_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmCas_stOfs_State
    ""
    TAB_VERB
    2
    0 "EPMCAS_OFS_WAITSEG"
    1 "EPMCAS_OFS_SEGCALC"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmHCrS_stSigMode_State_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmHCrS_stSigMode_State_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmHCrS_stSigMode_State_t
    ""
    TAB_VERB
    9
    0 "RESET"
    1 "HALT"
    2 "WAITSIG"
    3 "IGNTIME"
    4 "IGNFRSTEDGE"
    5 "IGNEDGE"
    6 "WAITGAP"
    7 "GAPFOUND"
    8 "TIMERMODE"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMRRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMRRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMRRS_SY_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmSeq_numInt_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmSeq_numInt_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmSeq_numInt_Compu
    ""
    TAB_VERB
    8
    0 "S_0"
    1 "S_1"
    2 "S_0_FIRST"
    3 "S_1_FIRST"
    6 "S_0_FIRST_START"
    7 "S_1_FIRST_START"
    8 "S_EPM"
    16 "S_INI"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmSeq_stInt_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmSeq_stInt_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmSeq_stInt_Compu
    ""
    TAB_VERB
    5
    0 "ST_S_0"
    1 "ST_S_1"
    4 "ST_S_0_START"
    5 "ST_S_1_START"
    8 "ST_EPM"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmSrv_stCnvAgT2Ag_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmSrv_stCnvAgT2Ag_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmSrv_stCnvAgT2Ag_t
    ""
    TAB_VERB
    30
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"
    8 "8"
    9 "9"
    10 "10"
    11 "11"
    12 "12"
    13 "13"
    14 "14"
    15 "15"
    16 "16"
    17 "17"
    18 "18"
    19 "19"
    20 "20"
    21 "21"
    22 "22"
    23 "23"
    24 "24"
    25 "AVRGSPD"
    26 "EXTRAPOLATION"
    253 "ERRORSTGY"
    254 "ERRORCRS"
    255 "ERRORMIAP"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmSyn_EdgeFailTypes
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmSyn_EdgeFailTypes
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmSyn_EdgeFailTypes
    ""
    TAB_VERB
    3
    0 "EPMSYN_EDGE_OK"
    1 "EPMSYN_EDGE_EARLY"
    2 "EPMSYN_EDGE_LATE"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmSyn_stCaSEvalComp
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmSyn_stCaSEvalComp
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmSyn_stCaSEvalComp
    ""
    TAB_VERB
    5
    0 "NO_CASPOS"
    1 "SEARCH_CASPOS"
    2 "VERIFY_CASPOS"
    3 "SWTOFF_CASPOS"
    4 "EVAL_CASPOS"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmSyn_stCaSPosComp
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmSyn_stCaSPosComp
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmSyn_stCaSPosComp
    ""
    TAB_VERB
    9
    0 "EPMSYN_CASPOS_NOTVALID"
    1 "EPMSYN_SIGTAB_NOUPDATE"
    2 "EPMSYN_SIGTAB_AMBI"
    5 "EPMSYN_CASPOS_VALID"
    10 "EPMSYN_WRONG_SEG_LEN"
    11 "EPMSYN_SIGTAB_END"
    12 "EPMSYN_SIGTAB_SEQ"
    13 "EPMSYN_EXCEED_TOLC"
    20 "EPMSYN_CASPOS_SWTOFF"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmSyn_stCrSPos_State_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmSyn_stCrSPos_State_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmSyn_stCrSPos_State_t
    ""
    TAB_VERB
    4
    0 "EPMSYN_NO_SYNC"
    1 "EPMSYN_CRS_SYNC"
    2 "EPMSYN_CAS_SYNC"
    3 "EPMSYN_FULL_SYNC"


/end COMPU_VTAB

/begin COMPU_METHOD
    EpmSyn_stRRComp
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EpmSyn_stRRComp
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EpmSyn_stRRComp
    ""
    TAB_VERB
    2
    0 "EPMSYN_FORWARDS"
    1 "EPMSYN_BACKWARDS"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPM_FAC_PLAUS
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 16 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    Epm_stCmbTestReq_State_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Epm_stCmbTestReq_State_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Epm_stCmbTestReq_State_t
    ""
    TAB_VERB
    2
    0 "EPM_NO_CMBTEST"
    10 "EPM_CMBTEST"


/end COMPU_VTAB

/begin COMPU_METHOD
    Epm_stOpMode_State_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Epm_stOpMode_State_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Epm_stOpMode_State_t
    ""
    TAB_VERB
    8
    1 "EPM_MODE_WAIT"
    5 "EPM_MODE_LOCKRESYNC"
    20 "EPM_MODE_ALE"
    33 "EPM_MODE_VERIFY"
    36 "EPM_MODE_VERIFY_EXT"
    38 "EPM_MODE_BACKUP_CAS"
    48 "EPM_MODE_OK"
    60 "EPM_MODE_BACKUP_CRS"


/end COMPU_VTAB

/begin COMPU_METHOD
    Epm_stReSyncReason_State_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Epm_stReSyncReason_State_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Epm_stReSyncReason_State_t
    ""
    TAB_VERB
    6
    0 "EPM_RESYNC_NORESYNC"
    1 "EPM_RESYNC_NOCRS"
    2 "EPM_RESYNC_SYNCLOST"
    3 "EPM_RESYNC_BRK"
    4 "EPM_RESYNC_OFSERR"
    5 "EPM_RESYNC_CANERR"


/end COMPU_VTAB

/begin COMPU_METHOD
    Epm_stSpd_t
    "states of Epm_stSpd"
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Epm_stSpd_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Epm_stSpd_t
    "states of Epm_stSpd"
    TAB_VERB
    5
    0 "EPM_SPD_CRS"
    1 "EPM_SPD_HOLD"
    2 "EPM_SPD_ZERO"
    3 "EPM_SPD_CAS"
    4 "EPM_SPD_BACKUP"


/end COMPU_VTAB

/begin COMPU_METHOD
    Epm_stSync_State_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Epm_stSync_State_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Epm_stSync_State_t
    ""
    TAB_VERB
    4
    0 "EPM_NO_SYNC"
    10 "EPM_ALE_SYNC"
    20 "EPM_CAS_SYNC"
    30 "EPM_FULL_SYNC"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_SYNCSLV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_SYNCSLV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_SYNCSLV_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_stS1FrstSched_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_stS1FrstSched_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_stS1FrstSched_t
    ""
    TAB_VERB
    3
    0 "ESC_SX_SCHEDSTRT"
    1 "ESC_S1_SCHEDSTRT"
    2 "ESC_S0_SCHEDSTRT"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_stSchdSx_CntnrNames_t
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_stSchdSx_CntnrNames_t
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_stSchdSx_CntnrNames_t
    ""
    TAB_VERB
    19
    0 "ESC_syncPre_Cntnr"
    1 "ESC_syncCommon_Cntnr"
    2 "ESC_syncLiGov_Cntnr"
    3 "ESC_syncASD_Cntnr"
    4 "ESC_syncUpdate_Cntnr"
    5 "ESC_syncS0_A_Cntnr"
    6 "ESC_syncS0_B_Cntnr"
    7 "ESC_syncS1_A_Cntnr"
    8 "ESC_syncS1_B_Cntnr"
    9 "ESC_syncFBC_Cntnr"
    10 "ESC_syncJoint_Cntnr"
    11 "ESC_syncUnitInjector_Cntnr"
    12 "ESC_syncPost_Cntnr"
    13 "ESC_syncCPP_Cntnr"
    14 "ESC_syncPSC_Cntnr"
    15 "ESC_syncS0_Rmt_Cntnr"
    16 "ESC_syncS1_Rmt_Cntnr"
    17 "ESC_ERROR_UNDEF_CNTNR"
    255 "ESC_NoSched"


/end COMPU_VTAB

/begin COMPU_METHOD

    Eta
    ""
    RAT_FUNC
    "%6.4"
    "Nm/(mg/cyc)"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Eta0001_RSA
    ""
    RAT_FUNC
    "%6.5"
    "Nm/(mg/strk)"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Eta1
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Eta2
    ""
    RAT_FUNC
    "%6.4"
    ""

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Eta3
    ""
    RAT_FUNC
    "%6.4"
    "Nm/(mg/hub)"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ETClb_Eval_Rslt
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF ETClb_Eval_Rslt
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETClb_Eval_Rslt
    ""
    TAB_VERB
    3
    0 "ETCLB_ST_CLB_CONT"
    1 "ETCLB_ST_CLB_END"
    2 "ETCLB_ST_CLB_ERR"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETClb_Eval_State
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF ETClb_Eval_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETClb_Eval_State
    ""
    TAB_VERB
    3
    0 "ETCLB_ST_EVAL_INIT"
    1 "ETCLB_ST_EVAL_ADD"
    2 "ETCLB_ST_EVAL_SUB"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETCLB_NUMRAILPCLBPNT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETCLB_NUMRAILPCLBPNT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETCLB_NUMRAILPCLBPNT_SY_Compu
    ""
    TAB_VERB
    7
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETClb_State
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF ETClb_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETClb_State
    ""
    TAB_VERB
    4
    0 "ETCLB_ST_NOT_ACTV"
    1 "ETCLB_ST_START_ENERGIZE"
    2 "ETCLB_ST_MEASURE"
    3 "ETCLB_ST_EVALUATE"


/end COMPU_VTAB

/begin COMPU_METHOD

    ETCtlGovKi_fac
    ""
    RAT_FUNC
    "%8.7"
    "-"

    COEFFS 0 429496.7296 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETCtlGovKp_fac
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 25600 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETCtlGovRmp
    ""
    RAT_FUNC
    "%6.3"
    "s"

    COEFFS 0 0 1 0 0.0152587890625 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETCtlGov_p0q001
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ETCTL_NUMOPMODEMSK_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETCTL_NUMOPMODEMSK_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETCTL_NUMOPMODEMSK_SY_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    ExeCon_State_01
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ExeCon_State_01
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ExeCon_State_01
    ""
    TAB_VERB
    4
    0 "SYC_BOOT"
    1 "SYC_PROC_INIT"
    2 "SYC_PROC_EXEC"
    3 "SYC_SHUTDOWN"


/end COMPU_VTAB

/begin COMPU_METHOD
    ExeCon_State_02
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ExeCon_State_02
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ExeCon_State_02
    ""
    TAB_VERB
    7
    0 "SYC_INI"
    1 "SYC_INISYN"
    2 "SYC_INIEND"
    3 "SYC_PREDRIVE"
    4 "SYC_DRIVE"
    5 "SYC_POSTDRIVE"
    6 "SYC_POST_OS_EXIT"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHFLPLP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHFLPLP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHFLPLP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHFLPLP_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHFLPLP_TYPTWINFLW_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHFLPLP_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXH_NUMTEMPSENSMON_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXH_NUMTEMPSENSMON_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXH_NUMTEMPSENSMON_SY_Compu
    ""
    TAB_VERB
    5
    2 "TWO"
    3 "THREE"
    4 "FOUR"
    5 "FIVE"
    6 "SIX"


/end COMPU_VTAB

/begin COMPU_METHOD

    FacReactVel_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "mol/s/m"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FacReactVel_q100p0_COMPU
    ""
    RAT_FUNC
    "%6.0"
    "mol/s/m"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 8192 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact0002
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 5000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact1
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact10
    ""
    RAT_FUNC
    "%13.12"
    "-"

    COEFFS 0 10000000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact100
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact1000
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact256
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 256 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact26
    ""
    RAT_FUNC
    "%10.9"
    "-"

    COEFFS 0 67108864 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact3
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact4
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact5
    ""
    RAT_FUNC
    "%6.3"
    "-"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact6
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 500 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact7
    ""
    RAT_FUNC
    "%10.9"
    "-"

    COEFFS 0 10000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact8
    ""
    RAT_FUNC
    "%11.10"
    "-"

    COEFFS 0 100000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact9
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 5000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FactFine
    ""
    RAT_FUNC
    "%9.8"
    "-"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FactLow
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1024 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FactLow1
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 25 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FactPresLs_float
    ""
    RAT_FUNC
    "%6.2"
    "(hpa/(kg/h))^2/k"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FactR
    ""
    RAT_FUNC
    "%6.1"
    "-"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FactRev
    ""
    RAT_FUNC
    "%6.3"
    "-"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FacTrigoFunc
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 4096 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_10000
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_2pwr11
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 2048 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_EGT
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_NSC
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_NSCEff
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FACT_percent
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 327.67 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_PT1
    ""
    RAT_FUNC
    "%6.4"
    "W/K"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_q0p001
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FACT_Rlx
    ""
    RAT_FUNC
    "%6.3"
    "-"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_SOx1
    ""
    RAT_FUNC
    "%9.8"
    "-"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_VolNSC
    ""
    RAT_FUNC
    "%9.8"
    "-"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fac_q0p0001_COMPU
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FAN_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FAN_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FAN_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    FBC_BPfac
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 546.116666666667 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FBC_Dxs_s16
    ""
    RAT_FUNC
    "%7.6"
    "%"

    COEFFS 0 41943.04 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FBC_GvrnIKi_float
    ""
    RAT_FUNC
    "%6.2"
    "mg/((1/min^2)*s)"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FBC_GvrnPKp_float
    ""
    RAT_FUNC
    "%6.2"
    "mg/(1/min^2)"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FBC_RegionESpP_st
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF FBC_RegionESpP_st
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FBC_RegionESpP_st
    ""
    TAB_VERB
    13
    16 "SPDIDX0"
    1 "SPDIDX2"
    2 "SPDIDX4"
    3 "SPDIDX6"
    4 "SPDIDX8"
    5 "SPDIDX10"
    8 "SPDIDX1"
    9 "SPDIDX3"
    10 "SPDIDX5"
    11 "SPDIDX7"
    12 "SPDIDX9"
    13 "SPDIDXLO"
    14 "SPDIDXHI"


/end COMPU_VTAB

/begin COMPU_METHOD
    FBC_StateESpP_st
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF FBC_StateESpP_st
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FBC_StateESpP_st
    ""
    TAB_VERB
    5
    1 "INIT"
    2 "DX_WAIT"
    3 "LEARN"
    4 "APPLY"
    5 "DELAY"


/end COMPU_VTAB

/begin COMPU_METHOD

    FBC_Surge_Frq
    ""
    RAT_FUNC
    "%6.4"
    "Hz"

    COEFFS 0 240 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FLASH_CONFIG_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlConsum_l
    ""
    RAT_FUNC
    "%6.5"
    "l"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlConsum_l_h
    ""
    RAT_FUNC
    "%6.4"
    "l/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlConsum_l_s
    ""
    RAT_FUNC
    "%8.7"
    "l/s"

    COEFFS 0 360000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlConsum_ul
    ""
    RAT_FUNC
    "%6.2"
    "ul"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlConsum_ul_1
    ""
    RAT_FUNC
    "%6.5"
    "ul"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlConsum_ul_20ms
    ""
    RAT_FUNC
    "%6.2"
    "ul/20ms"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlConsum_ul_High_COMPU
    ""
    RAT_FUNC
    "%6.1"
    "ul"

    COEFFS 0 0.05 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlCons_lps_q0p0001
    ""
    RAT_FUNC
    "%7.6"
    "l/s"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FlSys_swtTnkInfo_VERB
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF FlSys_swtTnkInfo_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FlSys_swtTnkInfo_VERB
    ""
    TAB_VERB
    2
    0 "DIGITAL"
    1 "ANALOGOUS"


/end COMPU_VTAB

/begin COMPU_METHOD

    Fl_2
    ""
    RAT_FUNC
    "%6.1"
    "l"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fl_Half_L
    ""
    RAT_FUNC
    "%6.3"
    "l"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fl_L
    ""
    RAT_FUNC
    "%6.4"
    "l"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fl_Vol
    ""
    RAT_FUNC
    "%6.5"
    "l/100km"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fl_Vol_q0p05
    ""
    RAT_FUNC
    "%6.4"
    "l"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FMA_ENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FMA_ENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FMA_ENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    FMA_qCor_001_RSA
    ""
    RAT_FUNC
    "%6.1"
    "mg/Strk"

    COEFFS 0 100 32768 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FMA_SWTQNTAIRCTLCOR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FMA_SWTQNTAIRCTLCOR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FMA_SWTQNTAIRCTLCOR_SY_Compu
    ""
    TAB_VERB
    2
    0 "FUELLQUANTITY"
    1 "AIRMASS"


/end COMPU_VTAB

/begin COMPU_METHOD
    FMO_ENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FMO_ENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FMO_ENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    FMO_NUMNGRID_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FMO_NUMNGRID_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FMO_NUMNGRID_SY_Compu
    ""
    TAB_VERB
    5
    6 "6"
    7 "7"
    8 "8"
    9 "9"
    10 "10"


/end COMPU_VTAB

/begin COMPU_METHOD
    FMO_NUMQGRID_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FMO_NUMQGRID_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FMO_NUMQGRID_SY_Compu
    ""
    TAB_VERB
    5
    6 "6"
    7 "7"
    8 "8"
    9 "9"
    10 "10"


/end COMPU_VTAB

/begin COMPU_METHOD
    FMO_SWTEMICTL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FMO_SWTEMICTL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FMO_SWTEMICTL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FUELLQUANTITY"
    1 "AIRMASS"


/end COMPU_VTAB

/begin COMPU_METHOD
    FMO_SWTPGOVDVT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FMO_SWTPGOVDVT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FMO_SWTPGOVDVT_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    Force_Ofs_RSA
    ""
    RAT_FUNC
    "%7.0"
    "N"

    COEFFS 0 0.5 10000 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Force_RSA
    ""
    RAT_FUNC
    "%6.2"
    "N"

    COEFFS 0 0.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FrqCylPres
    ""
    RAT_FUNC
    "%6.2"
    "Hz"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FrqTDC
    ""
    RAT_FUNC
    "%6.4"
    "1/s"

    COEFFS 0 50 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FRTP_VAR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FRTP_VAR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FRTP_VAR_SY_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    FUELP_DYNPLAUSENBL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FUELP_DYNPLAUSENBL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FUELP_DYNPLAUSENBL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FUELP_DYNPLAUSENBL_DISBL"
    1 "FUELP_DYNPLAUSENBL_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD
    FUELP_INAVRGENBL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FUELP_INAVRGENBL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FUELP_INAVRGENBL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FUELP_INAVRGENBL_DISBL"
    1 "FUELP_INAVRGENBL_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD
    FUELP_OUTFLTENBL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FUELP_OUTFLTENBL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FUELP_OUTFLTENBL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FUELP_OUTFLTENBL_DISBL"
    1 "FUELP_OUTFLTENBL_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD

    GC_Volt
    ""
    RAT_FUNC
    "%6.2"
    "mV"

    COEFFS 0 0.2046 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    GDI_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GDI_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GDI_SY_Compu
    ""
    TAB_VERB
    2
    0 "GDI_NO"
    1 "GDI"


/end COMPU_VTAB

/begin COMPU_METHOD

    GearNum_RSA
    ""
    RAT_FUNC
    "%6.2"
    "-"

    COEFFS 0 1 1 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Gear_RSA
    ""
    RAT_FUNC
    "%6.2"
    "-"

    COEFFS 0 1 1 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    GlwCtl_RmpSqrVltg_1000_s
    ""
    RAT_FUNC
    "%6.4"
    "V^2s"

    COEFFS 0 65 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    GlwCtl_Time_ms
    ""
    RAT_FUNC
    "%6.0"
    "ms"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    GLWLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GLWLMP_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GLWLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    GLWPLG_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GLWPLG_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GLWPLG_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    GLWPLG_TCTL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GLWPLG_TCTL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GLWPLG_TCTL_SY_Compu
    ""
    TAB_VERB
    2
    0 "VOLTAGE"
    1 "TEMPERATURE"


/end COMPU_VTAB

/begin COMPU_METHOD

    GrpDlyTime
    ""
    RAT_FUNC
    "%6.3"
    "usec"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    GSSYS_TYPAIRSYS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPAIRSYS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPAIRSYS_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPEEXHFLW_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEEXHFLW_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEEXHFLW_SY_Compu
    ""
    TAB_VERB
    2
    1 "(HESRV_SNGLFLW)"
    2 "(HESRV_TWFLW)"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPEGRCLGLP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEGRCLGLP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEGRCLGLP_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPEGRCLG_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEGRCLG_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEGRCLG_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPEGRLP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEGRLP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEGRLP_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPEGR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEGR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEGR_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPENG_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPENG_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPENG_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPEPHC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEPHC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEPHC_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPEXHMNFLP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEXHMNFLP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEXHMNFLP_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPEXHMNF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEXHMNF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEXHMNF_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPINDVOL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPINDVOL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPINDVOL_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPINTMNFLP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPINTMNFLP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPINTMNFLP_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPINTMNF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPINTMNF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPINTMNF_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPNSC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPNSC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPNSC_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPOXIC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPOXIC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPOXIC_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPPCR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPPCR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPPCR_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPPFLT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPPFLT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPPFLT_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPTRBCHR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPTRBCHR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPTRBCHR_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPVSWCTL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPVSWCTL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPVSWCTL_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD

    g_min_RSA
    ""
    RAT_FUNC
    "%6.4"
    "g/min"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    HCMassPerTime
    ""
    RAT_FUNC
    "%6.3"
    "mg/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    HCMassPerTime_q0p0000004
    ""
    RAT_FUNC
    "%9.8"
    "kg/s"

    COEFFS 0 2500000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    HCMassPerTime_q0p4
    ""
    RAT_FUNC
    "%6.3"
    "mg/s"

    COEFFS 0 2.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    HCMassPerTime_q0p8
    ""
    RAT_FUNC
    "%6.2"
    "mg/s"

    COEFFS 0 1.25 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    HeatCapacity
    ""
    RAT_FUNC
    "%6.3"
    "J/K"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    HESRV_ENASCNDFLW_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HESRV_ENASCNDFLW_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HESRV_ENASCNDFLW_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    HESRV_HETYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HESRV_HETYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HESRV_HETYP_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_MASTERSLAVE"
    255 "HESRV_ONEBOX"

    DEFAULT_VALUE "incorrect_HETYP"

/end COMPU_VTAB

/begin COMPU_METHOD
    HESrv_SwtPOpVis
    "Verbal application for the bank selection"
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HESrv_SwtPOpVis
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HESrv_SwtPOpVis
    "Verbal application for the bank selection"
    TAB_VERB
    2
    0 "Bank 1"
    1 "Bank 2"


/end COMPU_VTAB

/begin COMPU_METHOD

    hPa_1_RSA
    ""
    RAT_FUNC
    "%6.2"
    "hPa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    hPa_RSA
    ""
    RAT_FUNC
    "%6.2"
    "hPa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    HtFlw_Fl
    ""
    RAT_FUNC
    "%6.2"
    "J/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    IAIRHT_NUM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IAIRHT_NUM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IAIRHT_NUM_SY_Compu
    ""
    TAB_VERB
    2
    1 "IAIRHT_SINGLE"
    2 "IAIRHT_DOUBLE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJCRV_DBLCOR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJCRV_DBLCOR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJCRV_DBLCOR_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJCRV_PII1SOECLBMODEEOM0_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJCRV_PII1SOECLBMODEEOM0_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJCRV_PII1SOECLBMODEEOM0_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJCRV_PII1SOECLBMODEEOMX_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJCRV_PII1SOECLBMODEEOMX_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJCRV_PII1SOECLBMODEEOMX_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJCRV_PII2SEPCOR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJCRV_PII2SEPCOR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJCRV_PII2SEPCOR_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJCRV_PII2SOECLBMODEEOM0_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJCRV_PII2SOECLBMODEEOM0_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJCRV_PII2SOECLBMODEEOM0_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJCRV_PII2SOECLBMODEEOMX_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJCRV_PII2SOECLBMODEEOMX_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJCRV_PII2SOECLBMODEEOMX_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJCRV_POI2SOECLBMODEEOM0_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJCRV_POI2SOECLBMODEEOM0_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJCRV_POI2SOECLBMODEEOM0_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJCRV_POI2SOECLBMODEEOMX_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJCRV_POI2SOECLBMODEEOMX_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJCRV_POI2SOECLBMODEEOMX_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    InjMass
    ""
    RAT_FUNC
    "%6.4"
    "mg/hub"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMassCyc
    ""
    RAT_FUNC
    "%6.4"
    "mg/cyc"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMassInj
    ""
    RAT_FUNC
    "%6.4"
    "mg/inj"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMassPerTime
    ""
    RAT_FUNC
    "%6.4"
    "Kg/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMassSec
    ""
    RAT_FUNC
    "%6.4"
    "mg/hub/s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMass_RSA
    ""
    RAT_FUNC
    "%6.4"
    "mg/Strk"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMsPrTime_q0p001_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "Kg/h"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjQnt
    ""
    RAT_FUNC
    "%6.3"
    "mm^3/hub"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjQntInj
    ""
    RAT_FUNC
    "%6.4"
    "mm^3/inj"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    INJSYS_CRS_MI1_ZFCEXTD_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_CRS_MI1_ZFCEXTD_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_CRS_MI1_ZFCEXTD_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_CRS_POI1_ZFCEXTD_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_CRS_POI1_ZFCEXTD_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_CRS_POI1_ZFCEXTD_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_CRS_POI2_ZFCEXTD_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_CRS_POI2_ZFCEXTD_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_CRS_POI2_ZFCEXTD_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_CRS_QWC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_CRS_QWC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_CRS_QWC_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_LAMPRECTL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_LAMPRECTL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_LAMPRECTL_SY_Compu
    ""
    TAB_VERB
    2
    0 "LAMPRECTL_OFF"
    1 "LAMPRECTL_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MI1SETPOINT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MI1SETPOINT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MI1SETPOINT_SY_Compu
    ""
    TAB_VERB
    9
    0 "No setpoint parameters removed"
    1 "EOM0 calibration parameters removed"
    2 "EOM1 calibration parameters removed"
    4 "EOM2 calibration parameters removed"
    8 "EOM3 calibration parameters removed"
    16 "EOM4 calibration parameters removed"
    32 "EOM5 calibration parameters removed"
    64 "EOM6 calibration parameters removed"
    128 "EOM7 calibration parameters removed"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONCPC1_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONCPC1_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONCPC1_SY_Compu
    ""
    TAB_VERB
    2
    0 "CPC1_OFF"
    1 "CPC1_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONCPC3_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONCPC3_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONCPC3_SY_Compu
    ""
    TAB_VERB
    2
    0 "CPC3_OFF"
    1 "CPC3_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONCPC4_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONCPC4_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONCPC4_SY_Compu
    ""
    TAB_VERB
    2
    0 "CPC4_OFF"
    1 "CPC4_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONMEUN1_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONMEUN1_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONMEUN1_SY_Compu
    ""
    TAB_VERB
    2
    0 "MEUN1_OFF"
    1 "MEUN1_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONMEUN22_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONMEUN22_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONMEUN22_SY_Compu
    ""
    TAB_VERB
    2
    0 "MEUN22_OFF"
    1 "MEUN22_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONMEUN3_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONMEUN3_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONMEUN3_SY_Compu
    ""
    TAB_VERB
    2
    0 "MEUN3_OFF"
    1 "MEUN3_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONMEUN42_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONMEUN42_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONMEUN42_SY_Compu
    ""
    TAB_VERB
    2
    0 "MEUN42_OFF"
    1 "MEUN42_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONMEUN5_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONMEUN5_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONMEUN5_SY_Compu
    ""
    TAB_VERB
    2
    0 "MEUN5_OFF"
    1 "MEUN5_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONMEUN7_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONMEUN7_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONMEUN7_SY_Compu
    ""
    TAB_VERB
    2
    0 "MEUN7_OFF"
    1 "MEUN7_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONMEUN9_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONMEUN9_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONMEUN9_SY_Compu
    ""
    TAB_VERB
    2
    0 "MEUN9_OFF"
    1 "MEUN9_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONPCV1_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONPCV1_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONPCV1_SY_Compu
    ""
    TAB_VERB
    2
    0 "PCV1_OFF"
    1 "PCV1_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONPCV22_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONPCV22_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONPCV22_SY_Compu
    ""
    TAB_VERB
    2
    0 "PCV22_OFF"
    1 "PCV22_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONPCV3_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONPCV3_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONPCV3_SY_Compu
    ""
    TAB_VERB
    2
    0 "PCV3_OFF"
    1 "PCV3_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONPCV42_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONPCV42_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONPCV42_SY_Compu
    ""
    TAB_VERB
    2
    0 "PCV42_OFF"
    1 "PCV42_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_MONTNKLO_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_MONTNKLO_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_MONTNKLO_SY_Compu
    ""
    TAB_VERB
    2
    0 "MONTNKLO_OFF"
    1 "MONTNKLO_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_NUMPOI1SPLT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_NUMPOI1SPLT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_NUMPOI1SPLT_SY_Compu
    ""
    TAB_VERB
    4
    1 "1"
    2 "2"
    3 "3"
    4 "4"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_PII1SETPOINT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_PII1SETPOINT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_PII1SETPOINT_SY_Compu
    ""
    TAB_VERB
    9
    0 "No setpoint parameters removed"
    1 "EOM0 calibration parameters removed"
    2 "EOM1 calibration parameters removed"
    4 "EOM2 calibration parameters removed"
    8 "EOM3 calibration parameters removed"
    16 "EOM4 calibration parameters removed"
    32 "EOM5 calibration parameters removed"
    64 "EOM6 calibration parameters removed"
    128 "EOM7 calibration parameters removed"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_PII2SETPOINT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_PII2SETPOINT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_PII2SETPOINT_SY_Compu
    ""
    TAB_VERB
    9
    0 "No setpoint parameters removed"
    1 "EOM0 calibration parameters removed"
    2 "EOM1 calibration parameters removed"
    4 "EOM2 calibration parameters removed"
    8 "EOM3 calibration parameters removed"
    16 "EOM4 calibration parameters removed"
    32 "EOM5 calibration parameters removed"
    64 "EOM6 calibration parameters removed"
    128 "EOM7 calibration parameters removed"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_PII3SETPOINT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_PII3SETPOINT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_PII3SETPOINT_SY_Compu
    ""
    TAB_VERB
    9
    0 "No setpoint parameters removed"
    1 "EOM0 calibration parameters removed"
    2 "EOM1 calibration parameters removed"
    4 "EOM2 calibration parameters removed"
    8 "EOM3 calibration parameters removed"
    16 "EOM4 calibration parameters removed"
    32 "EOM5 calibration parameters removed"
    64 "EOM6 calibration parameters removed"
    128 "EOM7 calibration parameters removed"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_PIIRLSSETPOINT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_PIIRLSSETPOINT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_PIIRLSSETPOINT_SY_Compu
    ""
    TAB_VERB
    9
    0 "No setpoint parameters removed"
    1 "EOM0 calibration parameters removed"
    2 "EOM1 calibration parameters removed"
    4 "EOM2 calibration parameters removed"
    8 "EOM3 calibration parameters removed"
    16 "EOM4 calibration parameters removed"
    32 "EOM5 calibration parameters removed"
    64 "EOM6 calibration parameters removed"
    128 "EOM7 calibration parameters removed"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_POI1SETPOINT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_POI1SETPOINT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_POI1SETPOINT_SY_Compu
    ""
    TAB_VERB
    9
    0 "No setpoint parameters removed"
    1 "EOM0 calibration parameters removed"
    2 "EOM1 calibration parameters removed"
    4 "EOM2 calibration parameters removed"
    8 "EOM3 calibration parameters removed"
    16 "EOM4 calibration parameters removed"
    32 "EOM5 calibration parameters removed"
    64 "EOM6 calibration parameters removed"
    128 "EOM7 calibration parameters removed"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_POI2EFFFUNC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_POI2EFFFUNC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_POI2EFFFUNC_SY_Compu
    ""
    TAB_VERB
    2
    0 "POI2EFF_FACMAP"
    1 "POI2EFF_FUNC"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_POI2SETPOINT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_POI2SETPOINT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_POI2SETPOINT_SY_Compu
    ""
    TAB_VERB
    9
    0 "No setpoint parameters removed"
    1 "EOM0 calibration parameters removed"
    2 "EOM1 calibration parameters removed"
    4 "EOM2 calibration parameters removed"
    8 "EOM3 calibration parameters removed"
    16 "EOM4 calibration parameters removed"
    32 "EOM5 calibration parameters removed"
    64 "EOM6 calibration parameters removed"
    128 "EOM7 calibration parameters removed"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_RAILSETPOINT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_RAILSETPOINT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_RAILSETPOINT_SY_Compu
    ""
    TAB_VERB
    9
    0 "No setpoint parameters removed"
    1 "EOM0 calibration parameters removed"
    2 "EOM1 calibration parameters removed"
    4 "EOM2 calibration parameters removed"
    8 "EOM3 calibration parameters removed"
    16 "EOM4 calibration parameters removed"
    32 "EOM5 calibration parameters removed"
    64 "EOM6 calibration parameters removed"
    128 "EOM7 calibration parameters removed"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJSYS_TYPINJCTL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJSYS_TYPINJCTL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJSYS_TYPINJCTL_SY_Compu
    ""
    TAB_VERB
    2
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD

    InjTimeHiRes_us
    ""
    RAT_FUNC
    "%6.4"
    "us"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjTime_us
    ""
    RAT_FUNC
    "%6.3"
    "us"

    COEFFS 0 2.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjTime_us_RSA
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    InjVlv_AgTi2AgMode
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF InjVlv_AgTi2AgMode
    
/end COMPU_METHOD

/begin COMPU_VTAB

    InjVlv_AgTi2AgMode
    ""
    TAB_VERB
    11
    0 "EXTRAPOLATION"
    1 "MIAP"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"
    8 "8"
    9 "9"
    10 "10"


/end COMPU_VTAB

/begin COMPU_METHOD
    IVDia_stErrDFC
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF IVDia_stErrDFC
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IVDia_stErrDFC
    ""
    TAB_VERB
    8
    0 "DFC_IVDiaCylShCirHSLS"
    1 "DFC_IVDiaCylNoLd"
    2 "DFC_IVDiaCylShCir"
    3 "DFC_IVDiaCylShCirMeas"
    4 "DFC_IVDiaBnkShCirChSwt"
    5 "DFC_IVDiaBnkShCir"
    6 "DFC_IVDiaChp"
    255 "No_DFC"


/end COMPU_VTAB

/begin COMPU_METHOD

    Kd
    ""
    RAT_FUNC
    "%7.6"
    "1/1"

    COEFFS 0 65536 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kd_1
    ""
    RAT_FUNC
    "%6.4"
    "1/1"

    COEFFS 0 512 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kd_Lin_16
    ""
    RAT_FUNC
    "%7.6"
    "1/1"

    COEFFS 0 32767 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kd_pRail2Q
    ""
    RAT_FUNC
    "%8.7"
    "mm^3/s/hPa"

    COEFFS 0 655360 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kd_pRail2Q_1
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s/hPa"

    COEFFS 0 40960 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kd_Temp_Kelv2Dcyc
    ""
    RAT_FUNC
    "%8.7"
    "%/K"

    COEFFS 0 655360 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    kg_0001_RSA
    ""
    RAT_FUNC
    "%7.6"
    "kg"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki
    ""
    RAT_FUNC
    "%6.5"
    "1/s"

    COEFFS 0 2147.483648 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_1
    ""
    RAT_FUNC
    "%6.4"
    "1/s"

    COEFFS 0 67.108864 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_Ampc2Prc
    ""
    RAT_FUNC
    "%7.6"
    "%/(mg/Hub Luft)/s"

    COEFFS 0 17592.186044416 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_curr2fact
    ""
    RAT_FUNC
    "%10.9"
    "1/mA*s"

    COEFFS 0 17592186.044416 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_InjTime_us2Curr
    ""
    RAT_FUNC
    "%6.4"
    "mA/us/s"

    COEFFS 0 858.9934592 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_Kelv_Sec
    ""
    RAT_FUNC
    "%6.4"
    "1/s"

    COEFFS 0 214.7483648 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_LamCtl
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 262.144 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_pRail2Q
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s^2/hPa"

    COEFFS 0 21474.83648 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_pRail2Q_1
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s^2/hPa"

    COEFFS 0 10737.41824 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_PrcEGRRmp_2_Prc
    ""
    RAT_FUNC
    "%7.6"
    "1/s"

    COEFFS 0 26843.5456 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_Temp2EGTFact
    ""
    RAT_FUNC
    "%8.7"
    "-"

    COEFFS 0 429496.7296 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_Temp_Kelv2Dcyc
    ""
    RAT_FUNC
    "%7.6"
    "%/(K*s)"

    COEFFS 0 21474.83648 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_Vltg_PA2Fact
    ""
    RAT_FUNC
    "%8.7"
    "1/V/s"

    COEFFS 0 175921.86044416 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_Vltg_PA2Vltg_PA
    ""
    RAT_FUNC
    "%6.5"
    "V/V/s"

    COEFFS 0 2147.483648 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    km_16_RSA
    ""
    RAT_FUNC
    "%6.1"
    "km"

    COEFFS 0 0.0625 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp
    ""
    RAT_FUNC
    "%7.6"
    "1/1"

    COEFFS 0 32768 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_1
    ""
    RAT_FUNC
    "%6.4"
    "1/1"

    COEFFS 0 64 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_InjTime_us2Curr
    ""
    RAT_FUNC
    "%7.6"
    "mA/us"

    COEFFS 0 13107.2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_LmbdRec2InjMass_1
    ""
    RAT_FUNC
    "%6.4"
    "mg/stroke"

    COEFFS 0 81.92 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_pRail2Q
    ""
    RAT_FUNC
    "%8.7"
    "mm^3/s/hPa"

    COEFFS 0 327680 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_pRail2Q_1
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s/hPa"

    COEFFS 0 81920 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_Temp_Kelv2Dcyc
    ""
    RAT_FUNC
    "%8.7"
    "%/K"

    COEFFS 0 327680 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_Vltg_PA2Fact
    ""
    RAT_FUNC
    "%9.8"
    "1/V"

    COEFFS 0 2684354.56 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_Vltg_PA2Vltg_PA
    ""
    RAT_FUNC
    "%7.6"
    "V/V"

    COEFFS 0 32768 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambda
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambdaRec
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambdaRecVal
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambdarecval_RSA
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambdaSec
    ""
    RAT_FUNC
    "%6.5"
    "1/s"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Lambda_DiffQuot
    ""
    RAT_FUNC
    "%6.4"
    "1/s"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Length
    ""
    RAT_FUNC
    "%6.2"
    "m"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Length1
    ""
    RAT_FUNC
    "%6.4"
    "m"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    LengthCpp
    ""
    RAT_FUNC
    "%8.7"
    "m"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    LengthFine
    ""
    RAT_FUNC
    "%6.5"
    "m"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    LengthKm
    ""
    RAT_FUNC
    "%6.1"
    "Km"

    COEFFS 0 0.05 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    LengthKm1
    ""
    RAT_FUNC
    "%6.2"
    "Km"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Length_fine
    ""
    RAT_FUNC
    "%6.5"
    "m"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    LSUSelSig_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LSUSelSig_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LSUSelSig_COMPU_VERB
    ""
    TAB_VERB
    5
    0 "LSU_rO2Raw"
    1 "LSU_rO2RawTempComp"
    2 "LSU_rO2PresComp"
    3 "LSU_rO2PresTempComp"
    4 "LSU_rO2Adap"


/end COMPU_VTAB

/begin COMPU_METHOD
    LSU_CT_SENSORS_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LSU_CT_SENSORS_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LSU_CT_SENSORS_Compu
    ""
    TAB_VERB
    4
    1 "1"
    2 "2"
    3 "3"
    4 "4"


/end COMPU_VTAB

/begin COMPU_METHOD
    LSU_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LSU_CT_SENSORS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LSU_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    4
    1 "1"
    2 "2"
    3 "3"
    4 "4"


/end COMPU_VTAB

/begin COMPU_METHOD
    LSU_PRESCOMPADAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LSU_PRESCOMPADAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LSU_PRESCOMPADAP_SY_Compu
    ""
    TAB_VERB
    2
    0 "(FALSE)"
    1 "(TRUE)"


/end COMPU_VTAB

/begin COMPU_METHOD
    Lsu_PresComp_St
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF Lsu_PresComp_St
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Lsu_PresComp_St
    ""
    TAB_VERB
    4
    1 "LSU_PRESCOMP_BREAK"
    2 "LSU_PRESCOMP_WAIT"
    3 "LSU_PRESCOMP_MEAS"
    4 "LSU_PRESCOMP_CALC"


/end COMPU_VTAB

/begin COMPU_METHOD
    LUB_CRITOILLVLMSK_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LUB_CRITOILLVLMSK_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LUB_CRITOILLVLMSK_SY_Compu
    ""
    TAB_VERB
    2
    1 "ONE"
    2 "TWO"


/end COMPU_VTAB

/begin COMPU_METHOD

    Mass
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mass2Temp_q0p000003
    ""
    RAT_FUNC
    "%8.7"
    "Kg/K"

    COEFFS 0 333333.333333333 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    MassPerTimeq0p001
    ""
    RAT_FUNC
    "%6.5"
    "g/s"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mass_q1
    ""
    RAT_FUNC
    "%6.2"
    "g"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MOCCPU_FIT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCCPU_FIT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCCPU_FIT_SY_Compu
    ""
    TAB_VERB
    2
    0 "CHISTE_TEST"
    1 "FIT_TEST"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCSOP_TSTMPENBL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCSOP_TSTMPENBL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCSOP_TSTMPENBL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    mOilAsh_g
    ""
    RAT_FUNC
    "%6.4"
    "g"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Molmass
    ""
    RAT_FUNC
    "%6.4"
    "g/mol"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_ang_crk_q0p02
    ""
    RAT_FUNC
    "%6.4"
    "°CRK"

    COEFFS 0 50 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_fac_q0p000122
    ""
    RAT_FUNC
    "%6.5"
    "1/1"

    COEFFS 0 8192 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_fac_q0p00098
    ""
    RAT_FUNC
    "%6.5"
    "1/1"

    COEFFS 0 1024 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_fac_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "1/1"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_inj_mass_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "mg/Strk"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_n_rpm_q32p0
    ""
    RAT_FUNC
    "%6.1"
    "rpm"

    COEFFS 0 1 0 0 0 32 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_n_rpm_q40p0
    ""
    RAT_FUNC
    "%6.1"
    "rpm"

    COEFFS 0 1 0 0 0 40 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_phi_degCrS_q0p02197
    ""
    RAT_FUNC
    "%6.4"
    "deg CrS"

    COEFFS 0 16383 0 0 0 360 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_p_hPa_q8000p0
    ""
    RAT_FUNC
    "%7.0"
    "hPa"

    COEFFS 0 1 0 0 0 8000 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_ti10ms_ms_q10p0
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 1 0 0 0 10 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_ti40ms_ms_q40p0
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 1 0 0 0 40 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_ti_s_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_ti_s_q0p04
    ""
    RAT_FUNC
    "%6.4"
    "s"

    COEFFS 0 25 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_ti_s_q1p0
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_ti_us_q0p4
    ""
    RAT_FUNC
    "%6.3"
    "us"

    COEFFS 0 1000 0 0 0 400 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_ti_us_q1p0
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_trq_nm_q0p32
    ""
    RAT_FUNC
    "%6.1"
    "Nm"

    COEFFS 0 32 12800 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_trq_nm_q0p320
    ""
    RAT_FUNC
    "%6.4"
    "Nm"

    COEFFS 0 32 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_u_mV_q19p53
    ""
    RAT_FUNC
    "%6.1"
    "mV"

    COEFFS 0 256 0 0 0 5000 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_u_mV_q1p0
    ""
    RAT_FUNC
    "%6.2"
    "mV"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_u_mV_q39p06
    ""
    RAT_FUNC
    "%6.1"
    "mV"

    COEFFS 0 128 0 0 0 5000 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_u_mV_q4p88
    ""
    RAT_FUNC
    "%6.2"
    "mV"

    COEFFS 0 1024 0 0 0 5000 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_u_mV_q9p77
    ""
    RAT_FUNC
    "%6.2"
    "mV"

    COEFFS 0 256 0 0 0 2500 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_v_kmh_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "km/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Mo_v_kmh_q1p0
    ""
    RAT_FUNC
    "%6.2"
    "km/h"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    mSoot_g
    ""
    RAT_FUNC
    "%6.4"
    "g"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    MsPerVol
    ""
    RAT_FUNC
    "%6.5"
    "g/l"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_kg_COMPU
    ""
    RAT_FUNC
    "%6.4"
    "kg"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_O2
    ""
    RAT_FUNC
    "%6.5"
    "g"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_O2_Fine
    ""
    RAT_FUNC
    "%8.7"
    "g"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_SOx
    ""
    RAT_FUNC
    "%6.5"
    "g"

    COEFFS 0 3278.68852459016 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_SOxLdTot
    ""
    RAT_FUNC
    "%6.3"
    "mg"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_SOxNOx
    ""
    RAT_FUNC
    "%8.7"
    "g"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    M_NOxLd
    ""
    RAT_FUNC
    "%8.7"
    "g"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    M_NOxLd_LoRes
    ""
    RAT_FUNC
    "%6.4"
    "g"

    COEFFS 0 250 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    M_NOxMsSOx
    ""
    RAT_FUNC
    "%6.5"
    "g"

    COEFFS 0 3276.8 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    nox
    ""
    RAT_FUNC
    "%6.2"
    "ppm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NOxFlwEG
    ""
    RAT_FUNC
    "%6.4"
    "Gram/s"

    COEFFS 0 40 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NOxLdPerFl
    ""
    RAT_FUNC
    "%6.5"
    "1/l"

    COEFFS 0 8192 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NOxMassFlw
    ""
    RAT_FUNC
    "%6.5"
    "mg/s"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NOxMassPerTime
    ""
    RAT_FUNC
    "%6.3"
    "mg/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NSCRGN_NUMAIRSYSMSK_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NSCRGN_NUMNSCWRMUPMSK_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NSCRGN_NUMPFLTRGNMSK_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NSCRgn_Time_S
    ""
    RAT_FUNC
    "%6.4"
    "S"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    NSC_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NSC_CT_SENSORS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NSC_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    5
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"


/end COMPU_VTAB

/begin COMPU_METHOD
    NSC_NSCHTGLAMDSOX_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NSC_NSCHTGLAMDSOX_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NSC_NSCHTGLAMDSOX_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    NSC_NUMLAMSETVAL_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NSC_NUMRMDSTHRESVLD_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NSC_NUMTEMPBRICK_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NSC_NUMTEMPSETVAL_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    NSC_THRESLDMODVAR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NSC_THRESLDMODVAR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NSC_THRESLDMODVAR_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMCYLACT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMCYLACT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMCYLACT_SY_Compu
    ""
    TAB_VERB
    8
    3 "3 cylinders"
    4 "4 cylinders"
    5 "5 cylinders"
    6 "6 cylinders"
    8 "8 cylinders"
    10 "10 cylinders"
    12 "12 cylinders"
    18 "18 cylinders"

    DEFAULT_VALUE "incorrect_number_of_cylinders"

/end COMPU_VTAB

/begin COMPU_METHOD
    NUMCYLMAX_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMCYLMAX_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMCYLMAX_SY_Compu
    ""
    TAB_VERB
    8
    3 "3 cylinders"
    4 "4 cylinders"
    5 "5 cylinders"
    6 "6 cylinders"
    8 "8 cylinders"
    10 "10 cylinders"
    12 "12 cylinders"
    18 "18 cylinders"

    DEFAULT_VALUE "incorrect_number_of_cylinders"

/end COMPU_VTAB

/begin COMPU_METHOD
    NUMFANS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMFANS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMFANS_SY_Compu
    ""
    TAB_VERB
    5
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    12 "12"


/end COMPU_VTAB

/begin COMPU_METHOD

    NumInjChrgBalRaw
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    NUMPSICBNK_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMPSICBNK_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMPSICBNK_SY_Compu
    ""
    TAB_VERB
    4
    1 "1"
    2 "2"
    3 "3"
    4 "4"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMPSICCHP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMPSICCHP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMPSICCHP_SY_Compu
    ""
    TAB_VERB
    2
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUM_WAHTPS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUM_WAHTPS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUM_WAHTPS_SY_Compu
    ""
    TAB_VERB
    3
    1 "1"
    2 "2"
    3 "3"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUM_WAHT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUM_WAHT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUM_WAHT_SY_Compu
    ""
    TAB_VERB
    4
    0 "0"
    1 "1"
    2 "2"
    3 "3"


/end COMPU_VTAB

/begin COMPU_METHOD

    O2
    ""
    RAT_FUNC
    "%8.7"
    "-"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    O2MassPerTime
    ""
    RAT_FUNC
    "%6.4"
    "Kg/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    O2MassPerTimeLo
    ""
    RAT_FUNC
    "%6.4"
    "Kg/h"

    COEFFS 0 50 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMassPerTime
    ""
    RAT_FUNC
    "%7.6"
    "mg/s"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMFl_mgps_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "mg/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMsPrc_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMs_mg
    ""
    RAT_FUNC
    "%6.2"
    "mg"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMs_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "g"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMs_q10
    ""
    RAT_FUNC
    "%6.1"
    "g"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Oil_lvl_mm_q0p004
    ""
    RAT_FUNC
    "%6.4"
    "mm"

    COEFFS 0 250 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OneToOne
    ""
    RAT_FUNC
    "%6.2"
    "-"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OneToOne_ms
    ""
    RAT_FUNC
    "%6.2"
    "ms"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OneToOne_us
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Period
    ""
    RAT_FUNC
    "%6.3"
    "ms"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PERMSPLYSYS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    Per_Dur
    ""
    RAT_FUNC
    "%6.2"
    "usec"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Per_Ratio
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 256 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PFLTLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PFLTLMP_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PFLTLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PFLTRGN_NUMREQMSK_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PFLTRGN_NUMREQMSK_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PFLTRGN_NUMREQMSK_SY_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    PFLTSTATS_ACTV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PFLTSTATS_ACTV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PFLTSTATS_ACTV_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    PFLT_NUMOPMODEMSKNMINSRV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PFLT_NUMOPMODEMSKNMINSRV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PFLT_NUMOPMODEMSKNMINSRV_SY_Compu
    ""
    TAB_VERB
    5
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"


/end COMPU_VTAB

/begin COMPU_METHOD
    PFLT_NUMOPMODEMSKNMIN_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PFLT_NUMOPMODEMSKNMIN_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PFLT_NUMOPMODEMSKNMIN_SY_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    PHYSRNGCHK_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PHYSRNGCHK_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PHYSRNGCHK_SY_Compu
    ""
    TAB_VERB
    2
    0 "PHYSRNGCHK_DISBL"
    1 "PHYSRNGCHK_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD

    PiIClb_AngleCrSS32
    ""
    RAT_FUNC
    "%9.8"
    "deg CrS"

    COEFFS 0 2982616.17777705 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PiIClb_InjMassS32
    ""
    RAT_FUNC
    "%9.8"
    "mg/hub"

    COEFFS 0 6553600 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PMaxCtlKi
    ""
    RAT_FUNC
    "%6.4"
    "deg CrS/(bar*s)"

    COEFFS 0 763.549741510925 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PMaxCtlKp
    ""
    RAT_FUNC
    "%7.6"
    "deg CrS/bar"

    COEFFS 0 11650.8444444416 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PMaxCtlKp_8
    ""
    RAT_FUNC
    "%6.5"
    "deg CrS/bar"

    COEFFS 0 1456.3555555552 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PmpQnt
    ""
    RAT_FUNC
    "%6.3"
    "mm^3/rev"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PosMCAirKi
    ""
    RAT_FUNC
    "%6.4"
    "(mg/str)/(%*s)"

    COEFFS 0 214.7483648 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PosMCAirKp
    ""
    RAT_FUNC
    "%6.5"
    "(mg/str)/%"

    COEFFS 0 3276.8 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PosMCAir_AMPC2Rat
    ""
    RAT_FUNC
    "%6.4"
    "1/mg/str"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    POSMCDES_NUMGMAPSNRM_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    POSMCDES_NUMGMAPSPHC_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PosMCKd
    ""
    RAT_FUNC
    "%8.7"
    "%/AgCA"

    COEFFS 0 144000.000000035 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PosMCKd_4
    ""
    RAT_FUNC
    "%7.6"
    "%/AgCA"

    COEFFS 0 36000.0000000088 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PosMCKi
    ""
    RAT_FUNC
    "%6.5"
    "%/(AgCA*s)"

    COEFFS 0 4718.59200000115 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PosMCKi_2
    ""
    RAT_FUNC
    "%6.5"
    "%/(AgCA*s)"

    COEFFS 0 2359.29600000058 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PosMCKp
    ""
    RAT_FUNC
    "%7.6"
    "%/AgCA"

    COEFFS 0 72000.0000000176 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PosMCKp_32
    ""
    RAT_FUNC
    "%6.5"
    "%/AgCA"

    COEFFS 0 2250.00000000055 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    POSTDRV_NOMAXTI_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF POSTDRV_NOMAXTI_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    POSTDRV_NOMAXTI_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    POSTDRV_SOFTRST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF POSTDRV_SOFTRST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    POSTDRV_SOFTRST_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    POSTDRV_T15RST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF POSTDRV_T15RST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    POSTDRV_T15RST_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Pos_Prc_float
    ""
    RAT_FUNC
    "%6.2"
    "%"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PPFLTDIFF_ATS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFF_ATS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFF_ATS_SY_Compu
    ""
    TAB_VERB
    2
    0 "ATS_DISABLED"
    1 "ATS_ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD

    Prc
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 81.92 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Prc001_Ofs_10_RSA
    ""
    RAT_FUNC
    "%6.3"
    "%"

    COEFFS 0 100 1000 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Prc001_RSA
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Prc2EffGrad
    ""
    RAT_FUNC
    "%7.6"
    "1/(%*s)"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PrcPerSec
    ""
    RAT_FUNC
    "%6.3"
    "%/s"

    COEFFS 0 1.6384 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PrcSlp
    ""
    RAT_FUNC
    "%6.4"
    "%/s"

    COEFFS 0 819.2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Prc_0392_RSA
    ""
    RAT_FUNC
    "%6.3"
    "%"

    COEFFS 0 2.55 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Prc_Fact100
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PREDRV_T15RST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PREDRV_T15RST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PREDRV_T15RST_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Pres
    ""
    RAT_FUNC
    "%6.3"
    "kPa"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PresAC_hPa
    ""
    RAT_FUNC
    "%6.2"
    "hPa"

    COEFFS 0 0.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PresBar_RSA
    ""
    RAT_FUNC
    "%6.2"
    "bar"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PreshPa_FnReso
    ""
    RAT_FUNC
    "%6.3"
    "hPa"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PreshPa_HiRes
    ""
    RAT_FUNC
    "%6.4"
    "hPa"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PreshPa_sec
    ""
    RAT_FUNC
    "%6.2"
    "hPa/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PreshPa_Sq
    ""
    RAT_FUNC
    "%6.2"
    "hPa*hPa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PresInv_hPa
    ""
    RAT_FUNC
    "%10.9"
    "1/hPa"

    COEFFS 0 10000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PresRail_sec
    ""
    RAT_FUNC
    "%6.0"
    "hPa/s"

    COEFFS 0 0.0025 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pres_hPa
    ""
    RAT_FUNC
    "%6.2"
    "hPa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pres_hPa_float
    ""
    RAT_FUNC
    "%6.2"
    "hPa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pres_LoRes_COMPU
    ""
    RAT_FUNC
    "%6.4"
    "MPa"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pres_Rail
    ""
    RAT_FUNC
    "%6.0"
    "hPa"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pres_SI
    ""
    RAT_FUNC
    "%6.0"
    "Pa"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PSC_Fact
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 32767 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PSC_LSIGIDXMAX_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PSC_LSIGIDXMAX_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PSC_LSIGIDXMAX_SY_Compu
    ""
    TAB_VERB
    15
    0 "(ZERO)"
    1 "(ONE)"
    2 "(TWO)"
    3 "(THREE)"
    4 "(FOUR)"
    5 "(FIVE)"
    6 "(SIX)"
    7 "(SEVEN)"
    8 "(EIGHT)"
    9 "(NINE)"
    10 "(TEN)"
    11 "(ELEVEN)"
    12 "(TWELVE)"
    13 "(THIRTEEN)"
    14 "(FOURTEEN)"


/end COMPU_VTAB

/begin COMPU_METHOD
    PSC_NRMPHCSPDIDXMAX_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PSC_NRMPHCSPDIDXMAX_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PSC_NRMPHCSPDIDXMAX_SY_Compu
    ""
    TAB_VERB
    14
    0 "(ZERO)"
    1 "(ONE)"
    2 "(TWO)"
    3 "(THREE)"
    4 "(FOUR)"
    5 "(FIVE)"
    6 "(SIX)"
    7 "(SEVEN)"
    8 "(EIGHT)"
    9 "(NINE)"
    10 "(TEN)"
    11 "(ELEVEN)"
    12 "(TWELVE)"
    13 "(THIRTEEN)"


/end COMPU_VTAB

/begin COMPU_METHOD
    PS_NUMSENS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PS_NUMSENS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PS_NUMSENS_SY_Compu
    ""
    TAB_VERB
    2
    0 "ZERO"
    1 "ONE"


/end COMPU_VTAB

/begin COMPU_METHOD
    PTPRTOVRDSSPDGOV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTPRTOVRDSSPDGOV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTPRTOVRDSSPDGOV_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    Pwr
    ""
    RAT_FUNC
    "%6.2"
    "W"

    COEFFS 0 0.10610329539459 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr1
    ""
    RAT_FUNC
    "%6.3"
    "W"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr2
    ""
    RAT_FUNC
    "%6.1"
    "W"

    COEFFS 0 0.0530516476972949 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr2Temp_q0p001
    ""
    RAT_FUNC
    "%6.4"
    "W/K"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr2Temp_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "W/K"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PwrSq2TempSq_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "W^2/K^2"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr_kW
    ""
    RAT_FUNC
    "%6.4"
    "kW"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr_PA
    ""
    RAT_FUNC
    "%6.2"
    "mW"

    COEFFS 0 0.2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr_q1
    ""
    RAT_FUNC
    "%6.2"
    "W"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    QntR
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1024 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Qp_mm3_sec
    ""
    RAT_FUNC
    "%6.1"
    "mm3/s"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    QWC_st_VERB
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF QWC_st_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    QWC_st_VERB
    ""
    TAB_VERB
    2
    0 "QWC_OFF"
    1 "QWC_ON"


/end COMPU_VTAB

/begin COMPU_METHOD

    R01_RSA
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatAirMass
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatAshMass
    ""
    RAT_FUNC
    "%8.7"
    "-"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatCOMass
    ""
    RAT_FUNC
    "%9.8"
    "-"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatFuelMass
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ratio_045_COMPU
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 655.36 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatMsNOx1
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatNOxMass
    ""
    RAT_FUNC
    "%10.9"
    "-"

    COEFFS 0 10000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatSotMass
    ""
    RAT_FUNC
    "%8.7"
    "-"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatSotSot
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 4000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatSOxMass
    ""
    RAT_FUNC
    "%11.10"
    "-"

    COEFFS 0 100000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatVolCocn_Fl
    ""
    RAT_FUNC
    "%6.2"
    "mol/m^3"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rat_00125_RSA
    ""
    RAT_FUNC
    "%6.3"
    "-"

    COEFFS 0 800 1 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rat_NOxMon
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RdcMass
    ""
    RAT_FUNC
    "%6.5"
    "g"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    Reset_GrpID
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Reset_GrpID
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Reset_GrpID
    ""
    TAB_VERB
    32
    0 "SWRESET_GRP_POWERON_E"
    1 "SWRESET_GRP_HWRESET_E"
    2 "SWRESET_GRP_WDT_E"
    3 "SWRESET_GRP_WAKEUP_E"
    4 "SWRESET_GRP_TRAP_E"
    5 "SWRESET_GRP_SB_E"
    6 "SWRESET_GRP_CB_E"
    7 "SWRESET_SOFTRESETGRP_E"
    8 "SWRESET_GRP_DUMMY_01"
    9 "SWRESET_GRP_DUMMY_02"
    10 "SWRESET_GRP_DUMMY_03"
    11 "RESET_SWRESET_ASW_01"
    12 "RESET_EEP_GRP_E"
    13 "RESET_SWRESET_EPM_E"
    14 "RESET_SWRESET_ESC_E"
    15 "RESET_EXECON_GRP_E"
    16 "RESET_ASWSTD_E"
    17 "RESET_SWRESET_INJVLV_E"
    18 "SWRESET_GRP_MO_PREICO"
    19 "RESET_SWRESET_MOC"
    20 "RESET_SWRESET_SOP"
    21 "RESET_SWRESET_MOFICO"
    22 "RESET_SWRESET_OS_01"
    23 "SWRESET_PCP_GRP_E"
    24 "RESET_HWEMONGRP_E"
    25 "RESET_ERRINTRGRP_E"
    26 "SWRESET_SYCGRP_E"
    27 "RESET_SWRESET_TAA"
    28 "RESET_SWRESET_TPROT"
    29 "RESET_DMA_E"
    30 "RESET_FLASH_E"
    31 "RESET_CIC751_E"


/end COMPU_VTAB

/begin COMPU_METHOD
    Reset_ID
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Reset_ID
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Reset_ID
    ""
    TAB_VERB
    131
    0 "SWRESET_POWERON_E"
    1 "SWRESET_POWERON_WDT_E"
    2 "SWRESET_POWERON_KL15_E"
    3 "SWRESET_HW_E"
    4 "SWRESET_WDT_E"
    5 "SWRESET_WAKEUP_E"
    6 "TRAP_MMU_VAF_E"
    7 "TRAP_MMU_VAP_E"
    8 "TRAP_INTPROT_PRIV_E"
    9 "TRAP_INTPROT_MPR_E"
    10 "TRAP_INTPROT_MPW_E"
    11 "TRAP_INTPROT_MPX_E"
    12 "TRAP_INTPROT_MPP_E"
    13 "TRAP_INTPROT_MPN_E"
    14 "TRAP_INTPROT_GRWP_E"
    15 "TRAP_INSTRERR_IOPC_E"
    16 "TRAP_INSTRERR_UOPC_E"
    17 "TRAP_INSTRERR_OPD_E"
    18 "TRAP_INSTRERR_ALN_E"
    19 "TRAP_INSTRERR_MEM_E"
    20 "TRAP_CONTMANA_FCD_E"
    21 "TRAP_CONTMANA_CDO_E"
    22 "TRAP_CONTMANA_CDU_E"
    23 "TRAP_CONTMANA_FCU_E"
    24 "TRAP_CONTMANA_CSU_E"
    25 "TRAP_CONTMANA_CTYP_E"
    26 "TRAP_CONTMANA_NEST_E"
    27 "TRAP_SYSBUSERR_PSE_E"
    28 "TRAP_SYSBUSERR_DSE_E"
    29 "TRAP_SYSBUSERR_DAE_E"
    30 "TRAP_ASSTRAP_OVF_E"
    31 "TRAP_ASSTRAP_SOVF_E"
    32 "TRAP_SYSCALL_SYS_E"
    33 "TRAP_NMI_EXT_E"
    34 "TRAP_NMI_PLL_E"
    35 "TRAP_NMI_WDT_E"
    36 "TRAP_NMI_PER_E"
    37 "TRAP_RES1_E"
    38 "TRAP_RES2_E"
    39 "SWRESET_POWERON_SIMU_E"
    40 "SWRESET_HRESET_SIMU_E"
    41 "SWRESET_RB_PROG_E"
    42 "SWRESET_SOFTRESET_5VUNDERVOLTAGE_E"
    43 "SWRESET_SOFTRESET_POSTDRV2PREDRV_E"
    44 "SWRESET_CBPROG_E"
    45 "SWRESET_CBCPU_E"
    46 "SWRESET_SBDUMMY_1_E"
    47 "SWRESET_SBDUMMY_2_E"
    48 "SWRESET_SBDUMMY_3_E"
    49 "SWRESET_SBDUMMY_4_E"
    50 "SWRESET_SBDUMMY_5_E"
    51 "SWRESET_SBDUMMY_6_E"
    52 "SWRESET_SBDUMMY_7_E"
    53 "SWRESET_SBDUMMY_8_E"
    54 "RESET_SWRESET_BYP_SHUTDOWN"
    55 "SWRST_EEPBANDGAP_E"
    56 "SWRST_EEPNODEBUGGER_E"
    57 "SWRST_EEPDELENVRAM_E"
    58 "SWRST_WRITE_ERRORS_SECTORCHANGE_E"
    59 "SWRST_EEPACTFIRSTINIT_E"
    60 "RESET_SWRESET_EPMHCRS_WAIT_PCP_RESET_E"
    61 "RESET_SWRESET_ESC_SCHED_RESET_E"
    62 "SWRST_EXECON_FAULTYSTATE_E"
    63 "SWRST_IVACTRGETMEAS_E"
    64 "RESET_SWRESET_IVPSPLY_DCDC_TIMEOUT_RESET_E"
    65 "RESET_SWRESET_ILLEGAL_OPCODE"
    66 "RESET_SWRESET_ILLEGAL_RETURN_TO_MAIN"
    67 "SWRESET_MOCADC_PREICO"
    68 "RESET_SWRESET_ILLEGAL_SW_PATH"
    69 "RESET_SWRESET_MOCCOM_SPI_ERROR"
    70 "RESET_SWRESET_MOCCOM_CTSOPTST"
    71 "RESET_SWRESET_MOCGPTA"
    72 "RESET_SWRESET_MOCMEM_CPLCHK_FAILED"
    73 "RESET_SWRESET_MOCMEM_CHKRAM_FAILED"
    74 "RESET_SWRESET_MOCMEM_CHKROM_FAILED"
    75 "RESET_SWRESET_MOCMEM_WTRAM_FAILED"
    76 "RESET_SWRESET_MOCMEM_WTROM_FAILED"
    77 "RESET_SWRESET_MOCPCP"
    78 "RESET_SWRESET_MOCRAM_WRI"
    79 "RESET_SWRESET_MOCRAM_CPL"
    80 "RESET_SWRESET_MOCRAM_RAMTAB"
    81 "RESET_SWRESET_MOCRAM_RSTPTRRAM"
    82 "RESET_SWRESET_MOCRAM_STACKRAM"
    83 "RESET_SWRESET_MOCRAM_CSARAM"
    84 "RESET_SWRESET_MOCRAM_XRAM"
    85 "RESET_SWRESET_MOCRAM_IRAM"
    86 "RESET_SWRESET_MOCRAM_EXRAM"
    87 "RESET_SWRESET_MOCRAM_PROTRAM"
    88 "RESET_SWRESET_MOCRAM_EEPCPL"
    89 "RESET_SWRESET_MOCRAM_REPEXOK"
    90 "RESET_SWRESET_MOCROM"
    91 "RESET_SWRESET_MOCROM_CPL"
    92 "RESET_SWRESET_MOCROM_INDEX"
    93 "RESET_SWRESET_ABEACT_DURINGSOPT"
    94 "RESET_SWRESET_MOCSOP_SPI_ERROR"
    95 "RESET_SWRESET_MOCSOP_OS_TIMEOUT_ERROR"
    96 "RESET_SWRESET_MOCSOP_TIRESPTIME_ERROR"
    97 "RESET_SWRESET_MOCSOP_MM_RESP_BYTES_ERROR"
    98 "RESET_SWRESET_SOPTEST_FAILED"
    99 "RESET_SWRESET_CPLCHK_FAILED"
    100 "SWRESET_MOFESPD_PREICO"
    101 "SWRESET_MOFICO_PREPSSHUTOFF"
    102 "SWRESET_MOFRAILP_PREICO"
    103 "SWRESET_MOFOVR_PREICO"
    104 "RESET_SWRESET_INTERRUPTLOCK_EXPECTED"
    105 "RESET_USERSTACKOVERFLOW_DETECTED"
    106 "SWRESET_PCP_ERROR_E"
    107 "SWRST_MEUNSETCRNT_E"
    108 "SWRST_IVADJQNT_E"
    109 "SWRST_PCVSETCRNT_E"
    110 "SWRST_RAILCTLLOOP_E"
    111 "SWRST_RAILPOFSTST_E"
    112 "SWRST_STSYSRMPMON_E"
    113 "SWRST_STSYSSTRTCUTOUTMON_E"
    114 "SWRST_HWEMONDEFAULT_E"
    115 "RESET_ERRINTR_E"
    116 "SWRESET_CALWAKEUP_E"
    117 "SWRESET_DEADLINE1MS_E"
    118 "SWRESET_DEADLINE10MS_E"
    119 "SWRESET_DEADLINEBG_E"
    120 "SWRESET_NMIDISABLED_E"
    121 "SWRESET_POSTDRIVE_E"
    122 "SWRESET_SOFTRESET_WAKEUP_E"
    123 "SWRESET_SOFTRESET_SHUTDOWN_E"
    124 "SWRESET_T15RSTSHUTDOWN_E"
    125 "SWRESET_UNDERVOLTAGE_E"
    126 "RESET_SWRESET_TAA_ILLEG_SWPATH"
    127 "RESET_SWRESET_SWOVER_DONE"
    128 "RESET_DMA_ERROR_E"
    129 "SWRST_FLASHCONFIG_E"
    130 "SWRST_CIC751_ERROR_E"


/end COMPU_VTAB

/begin COMPU_METHOD

    Reset_mg_stk
    ""
    RAT_FUNC
    "%6.4"
    "mg/stk"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Resist
    ""
    RAT_FUNC
    "%6.3"
    "Ohm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Resist_1
    ""
    RAT_FUNC
    "%6.2"
    "mOhm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    RESVCONST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RESVCONST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RESVCONST_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    RESVREL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RESVREL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RESVREL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    Res_hPaHrPerCM
    ""
    RAT_FUNC
    "%7.6"
    "hPa/(m^3/h)"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RevCnt
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 16 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ReynoldsNum
    ""
    RAT_FUNC
    "%6.0"
    "-"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ReynoldsNum1
    ""
    RAT_FUNC
    "%7.0"
    "-"

    COEFFS 0 0.001 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RhoFuel
    ""
    RAT_FUNC
    "%6.3"
    "kg/m^3"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    rhoOilAsh_g_p_l
    ""
    RAT_FUNC
    "%6.3"
    "g/l"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rho_q0p001_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "Kg/m^3"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rmp
    ""
    RAT_FUNC
    "%6.4"
    "1/s"

    COEFFS 0 65.536 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RmpCurr
    ""
    RAT_FUNC
    "%6.0"
    "mA/s"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RmpDtyCyc
    ""
    RAT_FUNC
    "%6.5"
    "%/s"

    COEFFS 0 6553.6 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RmpInjMass
    ""
    RAT_FUNC
    "%6.5"
    "(mg/stroke)/s"

    COEFFS 0 6553.6 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RmpPrc
    ""
    RAT_FUNC
    "%6.5"
    "%/s"

    COEFFS 0 5368.70912 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RmpTemp
    ""
    RAT_FUNC
    "%6.4"
    "K/s"

    COEFFS 0 655.36 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rmp_1
    ""
    RAT_FUNC
    "%6.5"
    "1/s"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rmp_Fact
    ""
    RAT_FUNC
    "%8.7"
    "1/s"

    COEFFS 0 536870.912 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rpm025_RSA
    ""
    RAT_FUNC
    "%6.3"
    "rpm"

    COEFFS 0 4 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rpm_1_32_RSA
    ""
    RAT_FUNC
    "%6.1"
    "rpm"

    COEFFS 0 0.03125 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rtmo_Percent_u16
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 65536 0 0 0 100 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Rtmo_Time_us
    ""
    RAT_FUNC
    "%6.4"
    "us"

    COEFFS 0 80 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    sec_001_RSA
    ""
    RAT_FUNC
    "%6.4"
    "s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SETPOINTCALC_TRQBASED_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SETPOINTCALC_TRQBASED_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SETPOINTCALC_TRQBASED_SY_Compu
    ""
    TAB_VERB
    2
    0 "(QUANTITY)"
    1 "(TORQUE)"


/end COMPU_VTAB

/begin COMPU_METHOD
    ShutOffTst_States
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ShutOffTst_States
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ShutOffTst_States
    ""
    TAB_VERB
    4
    0 "INJCRV_STTST_INACTV"
    1 "INJCRV_STTST_WAIT"
    2 "INJCRV_STTST_ACTV"
    4 "INJCRV_STTST_STOP"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    Signals_IntSigNumVerb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Signals_IntSigNumVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Signals_IntSigNumVerb
    ""
    TAB_VERB
    101
    0 "SIGNALS_Signals_Default"
    1 "SIGNALS_ETClb_ctLrn_mp_0"
    2 "SIGNALS_ETClb_ctLrn_mp_1"
    3 "SIGNALS_ETClb_ctLrn_mp_2"
    4 "SIGNALS_ETClb_dtiETFlt0_mp_0"
    5 "SIGNALS_ETClb_dtiETFlt0_mp_1"
    6 "SIGNALS_ETClb_dtiETFlt0_mp_2"
    7 "SIGNALS_ETClb_dtiETFlt0_mp_3"
    8 "SIGNALS_ETClb_dtiETFlt0_mp_4"
    9 "SIGNALS_ETClb_dtiETFlt0_mp_5"
    10 "SIGNALS_ETClb_dtiETFlt1_mp_0"
    11 "SIGNALS_ETClb_dtiETFlt1_mp_1"
    12 "SIGNALS_ETClb_dtiETFlt1_mp_2"
    13 "SIGNALS_ETClb_dtiETFlt1_mp_3"
    14 "SIGNALS_ETClb_dtiETFlt1_mp_4"
    15 "SIGNALS_ETClb_dtiETFlt1_mp_5"
    16 "SIGNALS_ETClb_dtiETFlt2_mp_0"
    17 "SIGNALS_ETClb_dtiETFlt2_mp_1"
    18 "SIGNALS_ETClb_dtiETFlt2_mp_2"
    19 "SIGNALS_ETClb_dtiETFlt2_mp_3"
    20 "SIGNALS_ETClb_dtiETFlt2_mp_4"
    21 "SIGNALS_ETClb_dtiETFlt2_mp_5"
    22 "SIGNALS_ETClb_pRailSet_0"
    23 "SIGNALS_ETClb_pRailSet_1"
    24 "SIGNALS_ETClb_pRailSet_2"
    25 "SIGNALS_ETClb_stCor"
    26 "SIGNALS_ETClb_stRlsCylCor_mp"
    27 "SIGNALS_ETClb_tiETAvrg_0"
    28 "SIGNALS_ETClb_tiETAvrg_1"
    29 "SIGNALS_ETClb_tiETAvrg_2"
    30 "SIGNALS_ETClb_tiETMax_0"
    31 "SIGNALS_ETClb_tiETMax_1"
    32 "SIGNALS_ETClb_tiETMax_2"
    33 "SIGNALS_ETClb_tiETMin_0"
    34 "SIGNALS_ETClb_tiETMin_1"
    35 "SIGNALS_ETClb_tiETMin_2"
    36 "SIGNALS_IVPlaus_nCyl_0"
    37 "SIGNALS_IVPlaus_nCyl_1"
    38 "SIGNALS_IVPlaus_nCyl_2"
    39 "SIGNALS_IVPlaus_nCyl_3"
    40 "SIGNALS_IVPlaus_nCyl_4"
    41 "SIGNALS_IVPlaus_nCyl_5"
    42 "SIGNALS_IVPlaus_qFBCCyl_0"
    43 "SIGNALS_IVPlaus_qFBCCyl_1"
    44 "SIGNALS_IVPlaus_qFBCCyl_2"
    45 "SIGNALS_IVPlaus_qFBCCyl_3"
    46 "SIGNALS_IVPlaus_qFBCCyl_4"
    47 "SIGNALS_IVPlaus_qFBCCyl_5"
    48 "SIGNALS_InjUn_stStrt"
    49 "SIGNALS_InjVlv_tiMI1ET_mp"
    50 "SIGNALS_InjVlv_tiPiI1ET_mp"
    51 "SIGNALS_InjVlv_volMI1_mp"
    52 "SIGNALS_InjVlv_volPiI1_mp"
    53 "SIGNALS_MeUn_dvolSet"
    54 "SIGNALS_MeUn_iActFlt_mp"
    55 "SIGNALS_MeUn_iSet"
    56 "SIGNALS_MeUn_rPs_mp"
    57 "SIGNALS_MeUn_uRaw_mp"
    58 "SIGNALS_PCV_facAdapt"
    59 "SIGNALS_PCV_iActFlt_mp"
    60 "SIGNALS_PCV_iSet"
    61 "SIGNALS_PCV_pSet"
    62 "SIGNALS_PCV_rPs"
    63 "SIGNALS_PCV_uRaw_mp"
    64 "SIGNALS_RailP_pFlt"
    65 "SIGNALS_RailP_pLin"
    66 "SIGNALS_RailP_uOfsAftRun"
    67 "SIGNALS_RailP_uOfsAftRunMax"
    68 "SIGNALS_RailP_uOfsAftRunMin"
    69 "SIGNALS_RailP_uOfsStrt"
    70 "SIGNALS_RailP_uOfsStrtMax"
    71 "SIGNALS_RailP_uOfsStrtMin"
    72 "SIGNALS_RailP_uRaw"
    73 "SIGNALS_Rail_dvolPreCtl"
    74 "SIGNALS_Rail_pDvt"
    75 "SIGNALS_Rail_pSetPoint"
    76 "SIGNALS_Rail_stCPC"
    77 "SIGNALS_Rail_stCtlLoop"
    78 "SIGNALS_EpmCaS_phiOfsCorr"
    79 "SIGNALS_Epm_nEng"
    80 "SIGNALS_Epm_stOpMode"
    81 "SIGNALS_Epm_stSync"
    82 "SIGNALS_FBC_qDvtCylPhys_01"
    83 "SIGNALS_FBC_qDvtCylPhys_02"
    84 "SIGNALS_FBC_qDvtCylPhys_03"
    85 "SIGNALS_FBC_qDvtCylPhys_04"
    86 "SIGNALS_FBC_qDvtCylPhys_05"
    87 "SIGNALS_FBC_qDvtCylPhys_06"
    88 "SIGNALS_FBC_qDvtCylPhys_07"
    89 "SIGNALS_FBC_qDvtCylPhys_08"
    90 "SIGNALS_FBC_qDvtCylPhys_09"
    91 "SIGNALS_FBC_qDvtCylPhys_10"
    92 "SIGNALS_InjCtl_qCurr"
    93 "SIGNALS_InjCtl_qSetUnBal"
    94 "SIGNALS_T15_stRaw"
    95 "SIGNALS_TAA_ctLrnCycl_0"
    96 "SIGNALS_TAA_ctLrnCycl_1"
    97 "SIGNALS_TAA_ctLrnCycl_2"
    98 "SIGNALS_TAA_stAdap"
    99 "SIGNALS_TAA_stAdapVal"
    100 "SIGNALS_TAA_stLrnMode"


/end COMPU_VTAB

/begin COMPU_METHOD

    Signals_OneToOne
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Soot_gPerLtr
    ""
    RAT_FUNC
    "%6.4"
    "g/l"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Soot_Mass_RSA
    ""
    RAT_FUNC
    "%6.3"
    "g"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SotMassPerTime
    ""
    RAT_FUNC
    "%6.4"
    "mg/s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SotMs_KgPrSec_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "kg/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SOxMassPerTime
    ""
    RAT_FUNC
    "%7.6"
    "mg/s"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SpaVel
    ""
    RAT_FUNC
    "%6.1"
    "l/h"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SpecHeat
    ""
    RAT_FUNC
    "%6.2"
    "J/Kg/K"

    COEFFS 0 0.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SpecHeatFine
    ""
    RAT_FUNC
    "%6.3"
    "J/Kg/K"

    COEFFS 0 5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SpecificHeat
    ""
    RAT_FUNC
    "%7.6"
    "J/g/K"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Speed_km_h_001_RSA
    ""
    RAT_FUNC
    "%6.4"
    "km/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Speed_km_h_1_RSA
    ""
    RAT_FUNC
    "%6.2"
    "km/h"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SPRT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SPRT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SPRT_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    SqrVltg_s
    ""
    RAT_FUNC
    "%6.3"
    "V^2s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    stroke_pml
    ""
    RAT_FUNC
    "%6.3"
    "1/ml"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    STSP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF STSP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    STSP_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    SVCrnt_mA_COMPU
    ""
    RAT_FUNC
    "%6.1"
    "mA"

    COEFFS 0 0.0341 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SyC_PostDrv_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SyC_PostDrv_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SyC_PostDrv_State
    ""
    TAB_VERB
    8
    0 "SYC_POSTDRV_INACTV"
    1 "SYC_POSTDRV_DSM_BGN"
    2 "SYC_POSTDRV_EEP_BGN"
    3 "SYC_POSTDRV_WAIT"
    4 "SYC_POSTDRV_DSM_END"
    5 "SYC_POSTDRV_EEP_END"
    6 "SYC_POSTDRV_MIN_TIME"
    7 "SYC_POSTDRV_DONE"


/end COMPU_VTAB

/begin COMPU_METHOD
    SyC_PreDrv_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SyC_PreDrv_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SyC_PreDrv_State
    ""
    TAB_VERB
    10
    0 "SYC_PREDRV_INI_DRV"
    1 "SYC_PREDRV_DONE"
    2 "SYC_PREDRV_INI_SHDWN"
    3 "SYC_PREDRV_PROLONG"
    4 "SYC_PREDRV_NWM"
    5 "SYC_PREDRV_EEP"
    6 "SYC_PREDRV_DSM"
    7 "SYC_PREDRV_MR"
    8 "SYC_PREDRV_MOM"
    9 "SYC_PREDRV_EXIT"


/end COMPU_VTAB

/begin COMPU_METHOD

    SyC_Time_100ms
    ""
    RAT_FUNC
    "%6.3"
    "s"

    COEFFS 0 1000 0 0 0 100 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SyC_Time_1s
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    T15_ATS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF T15_ATS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    T15_ATS_SY_Compu
    ""
    TAB_VERB
    2
    0 "ATS_DISABLED"
    1 "ATS_ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    TCSOVRDSTSCINC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TCSOVRDSTSCINC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TCSOVRDSTSCINC_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    TDC_Period
    ""
    RAT_FUNC
    "%8.7"
    "s"

    COEFFS 0 312500 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempC_float
    ""
    RAT_FUNC
    "%6.1"
    "deg C"

    COEFFS 0 1 273.14 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempC_RSA
    ""
    RAT_FUNC
    "%6.2"
    "deg C"

    COEFFS 0 10 400 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempDiff_Kelv
    ""
    RAT_FUNC
    "%6.3"
    "K"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempDiff_Kelv_1K
    ""
    RAT_FUNC
    "%6.2"
    "K"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempK_float
    ""
    RAT_FUNC
    "%6.2"
    "K"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Temp_Cels
    ""
    RAT_FUNC
    "%6.1"
    "deg C"

    COEFFS 0 10 2731.4 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Temp_Cels1
    ""
    RAT_FUNC
    "%6.1"
    "deg C"

    COEFFS 0 100 27314 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Temp_Cels_1deg
    ""
    RAT_FUNC
    "%6.1"
    "deg C"

    COEFFS 0 1 273.14 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Temp_Fahr
    ""
    RAT_FUNC
    "%6.1"
    "deg F"

    COEFFS 0 5.55555555555556 2553.62222222222 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Temp_Kelv
    ""
    RAT_FUNC
    "%6.3"
    "K"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Temp_Kelv_Sec
    ""
    RAT_FUNC
    "%6.4"
    "K/s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Temp_Kelv_Sec_CtT_Mon
    ""
    RAT_FUNC
    "%7.6"
    "deg C/s"

    COEFFS 0 40960 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ThermalCoEff
    ""
    RAT_FUNC
    "%6.3"
    "W/m/m/k"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ThmCnd
    ""
    RAT_FUNC
    "%6.5"
    "W/m/K"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    THRVLV_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF THRVLV_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    THRVLV_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    THRVLV_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF THRVLV_TYPTWINFLW_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    THRVLV_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    Thr_Cpty
    ""
    RAT_FUNC
    "%6.2"
    "J/K"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Thr_Cpty_ExhGs
    ""
    RAT_FUNC
    "%6.1"
    "J/kgK"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ti3us2_RSA
    ""
    RAT_FUNC
    "%6.4"
    "ms"

    COEFFS 0 312.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time100HrsEngOn
    ""
    RAT_FUNC
    "%6.2"
    "[100h]"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeCoEOMRmp
    ""
    RAT_FUNC
    "%6.3"
    "s"

    COEFFS 0 0 1 0 0.0152587890625 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeDeb
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeDelay_ms
    ""
    RAT_FUNC
    "%12.1"
    "ms"

    COEFFS 0 0 1 0 2.3283064365387e-007 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeDelay_s
    ""
    RAT_FUNC
    "%12.4"
    "s"

    COEFFS 0 0 1 0 0.00023283064365387 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeDelay_s_2
    ""
    RAT_FUNC
    "%9.4"
    "s"

    COEFFS 0 0 1 0 0.0596046447753906 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeDelay_s_Lin_16
    ""
    RAT_FUNC
    "%6.5"
    "s"

    COEFFS 0 6553.4 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeDelay_s_RSA
    ""
    RAT_FUNC
    "%12.8"
    "s"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeDT
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeEngOn
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeEngOnOBD
    ""
    RAT_FUNC
    "%6.2"
    "min"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeGPTATick
    ""
    RAT_FUNC
    "%6.4"
    "ns"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeGT0Tic
    ""
    RAT_FUNC
    "%6.5"
    "ns"

    COEFFS 0 2500 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeHrsEngOn
    ""
    RAT_FUNC
    "%6.0"
    "[100h]"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeRed
    ""
    RAT_FUNC
    "%6.3"
    "s"

    COEFFS 0 6.25 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_1s
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_Dt
    ""
    RAT_FUNC
    "%9.8"
    "s"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_Hr
    ""
    RAT_FUNC
    "%6.3"
    "h"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_min_q2_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "min"

    COEFFS 0 1 0 0 0 2 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_ms
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_msec_q10_COMPU
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 1 0 0 0 10 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_msec_q1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "ms"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_Period_HFM6
    ""
    RAT_FUNC
    "%7.6"
    "ms"

    COEFFS 0 20000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_PwmHigh
    ""
    RAT_FUNC
    "%6.4"
    "us"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_PzoChrgPse
    ""
    RAT_FUNC
    "%6.4"
    "us"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_PzoMeas
    ""
    RAT_FUNC
    "%6.4"
    "ms"

    COEFFS 0 18.3150183150183 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_s
    ""
    RAT_FUNC
    "%6.4"
    "s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_sec
    ""
    RAT_FUNC
    "%6.5"
    "s"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_Second
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_sec_1
    ""
    RAT_FUNC
    "%6.3"
    "s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_sec_q1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_s_1
    ""
    RAT_FUNC
    "%6.5"
    ""

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_s_float
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_usec_q1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_WLvlPWM
    ""
    RAT_FUNC
    "%6.4"
    "ms"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TIncPerDurHiReso_us
    ""
    RAT_FUNC
    "%6.5"
    "us"

    COEFFS 0 2560 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TIncPerDur_us
    ""
    RAT_FUNC
    "%6.3"
    "us"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    TOXICATUS_ATS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TOXICATUS_ATS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TOXICATUS_ATS_SY_Compu
    ""
    TAB_VERB
    2
    0 "ATS_DISABLED"
    1 "ATS_ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    TPFLTUS_ATS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TPFLTUS_ATS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TPFLTUS_ATS_SY_Compu
    ""
    TAB_VERB
    2
    0 "ATS_DISABLED"
    1 "ATS_ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD

    TransR
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrbChN_float
    ""
    RAT_FUNC
    "%6.2"
    "rpm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TRBCHPMP_FRQ
    ""
    RAT_FUNC
    "%6.4"
    "Hz"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TRBCHPMP_FRQ_RSA
    ""
    RAT_FUNC
    "%6.4"
    "Hz"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TRBCHPMP_PER
    ""
    RAT_FUNC
    "%6.4"
    "ms"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    TRBCH_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBCH_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBCH_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Trq
    ""
    RAT_FUNC
    "%6.3"
    "Nm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Trq132_no_Offs_RSA
    ""
    RAT_FUNC
    "%6.4"
    "Nm"

    COEFFS 0 32 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Trq132_RSA
    ""
    RAT_FUNC
    "%6.1"
    "Nm"

    COEFFS 0 32 12800 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrqInrKd
    ""
    RAT_FUNC
    "%8.7"
    "%/Nm"

    COEFFS 0 655360 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrqInrKd_16
    ""
    RAT_FUNC
    "%7.6"
    "%/Nm"

    COEFFS 0 40960 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrqInrKi
    ""
    RAT_FUNC
    "%7.6"
    "%/(Nm*s)"

    COEFFS 0 21474.83648 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrqInrKi_8
    ""
    RAT_FUNC
    "%6.5"
    "%/(Nm*s)"

    COEFFS 0 2684.35456 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrqInrKp
    ""
    RAT_FUNC
    "%8.7"
    "%/Nm"

    COEFFS 0 327680 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrqInrKp_128
    ""
    RAT_FUNC
    "%6.5"
    "%/Nm"

    COEFFS 0 2560 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrqPrp
    ""
    RAT_FUNC
    "%6.2"
    "Nm"

    COEFFS 0 0.625 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrqPrpHigh
    ""
    RAT_FUNC
    "%6.3"
    "Nm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TrqToNSqr
    ""
    RAT_FUNC
    "%10.9"
    "-"

    COEFFS 0 10000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TRQ_32_RSA
    ""
    RAT_FUNC
    "%6.4"
    "Nm"

    COEFFS 0 32 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    TRQ_WOTRAINTV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRQ_WOTRAINTV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRQ_WOTRAINTV_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    TurboN
    ""
    RAT_FUNC
    "%6.1"
    "rpm"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TVAVSADIA_FRQ
    ""
    RAT_FUNC
    "%6.3"
    "Hz"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    UDOSVLV_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UDOSVLV_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UDOSVLV_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    UI_Curr
    ""
    RAT_FUNC
    "%6.1"
    "mA"

    COEFFS 0 0.0341 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    UPMPMOT_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UPMPMOT_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UPMPMOT_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    V000122_RSA
    ""
    RAT_FUNC
    "%6.5"
    "V"

    COEFFS 0 8197 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    V01_RSA
    ""
    RAT_FUNC
    "%6.4"
    "V"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    V02_RSA
    ""
    RAT_FUNC
    "%6.3"
    "mV"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    V1_RSA
    ""
    RAT_FUNC
    "%6.2"
    "mV"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Vel
    ""
    RAT_FUNC
    "%6.4"
    "km/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Velocity
    ""
    RAT_FUNC
    "%6.4"
    "m/s"

    COEFFS 0 178.571428571429 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Velocity_Fl
    ""
    RAT_FUNC
    "%6.2"
    "m/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    VelToN
    ""
    RAT_FUNC
    "%8.7"
    "(km/h)/rpm"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Vel_SI
    ""
    RAT_FUNC
    "%6.4"
    "m/s"

    COEFFS 0 360 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    vld_states
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF vld_states
    
/end COMPU_METHOD

/begin COMPU_VTAB

    vld_states
    ""
    TAB_VERB
    2
    0 "Nsx_vld_nok_0"
    1 "Nsx_vld_ok_1"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    vld_states_2
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF vld_states_2
    
/end COMPU_METHOD

/begin COMPU_VTAB

    vld_states_2
    ""
    TAB_VERB
    3
    0 "Nsx_vld_nok_0"
    1 "Nsx_vld_ok_1"
    2 "Nsx_vld_fail_2"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    vld_states_3
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF vld_states_3
    
/end COMPU_METHOD

/begin COMPU_VTAB

    vld_states_3
    ""
    TAB_VERB
    4
    0 "Nsx_vld_nok_0"
    1 "Nsx_vld_ok_1"
    2 "Nsx_vld_fail_2"
    3 "Nsx_vld_fail_3"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    vld_states_4
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF vld_states_4
    
/end COMPU_METHOD

/begin COMPU_VTAB

    vld_states_4
    ""
    TAB_VERB
    5
    0 "Nsx_vld_nok_0"
    1 "Nsx_vld_ok_1"
    2 "Nsx_vld_fail_2"
    3 "Nsx_vld_fail_3"
    4 "Nsx_vld_fail_4"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    vld_states_5
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF vld_states_5
    
/end COMPU_METHOD

/begin COMPU_VTAB

    vld_states_5
    ""
    TAB_VERB
    6
    0 "Nsx_vld_nok_0"
    1 "Nsx_vld_ok_1"
    2 "Nsx_vld_fail_2"
    3 "Nsx_vld_fail_3"
    4 "Nsx_vld_fail_4"
    5 "Nsx_vld_fail_5"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD

    Vltg_PA
    ""
    RAT_FUNC
    "%6.4"
    "V"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    VlvVel
    ""
    RAT_FUNC
    "%6.3"
    "%/s"

    COEFFS 0 8.192 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    VMSLMTSWT_ATS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VMSLMTSWT_ATS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VMSLMTSWT_ATS_SY_Compu
    ""
    TAB_VERB
    2
    0 "ATS_DISABLED"
    1 "ATS_ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD

    vn_K_001_RSA
    ""
    RAT_FUNC
    "%6.4"
    "(km/h)/K*rpm"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Vol
    ""
    RAT_FUNC
    "%6.4"
    "l"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Vol1
    ""
    RAT_FUNC
    "%9.8"
    "l"

    COEFFS 0 3600000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    volAdd_ml
    ""
    RAT_FUNC
    "%6.3"
    "ml"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    volAdd_ml_fine
    ""
    RAT_FUNC
    "%6.5"
    "ml"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    VolEngCap_COMPU
    ""
    RAT_FUNC
    "%9.8"
    "m^3"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    volFilgLvl_ml
    ""
    RAT_FUNC
    "%6.2"
    "ml"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    VolFine
    ""
    RAT_FUNC
    "%7.6"
    "m^3"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt
    ""
    RAT_FUNC
    "%6.3"
    "mV"

    COEFFS 0 5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    VoltPres
    ""
    RAT_FUNC
    "%6.3"
    "mV*hPa"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    VoltPres_HiRes
    ""
    RAT_FUNC
    "%6.4"
    "mV*hPa"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    VoltToRes
    ""
    RAT_FUNC
    "%6.5"
    "Ohm/mV"

    COEFFS 0 2000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_Batt
    ""
    RAT_FUNC
    "%6.1"
    "mV"

    COEFFS 0 0.05 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_FnReso1
    ""
    RAT_FUNC
    "%6.3"
    "mV"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_FnReso2
    ""
    RAT_FUNC
    "%6.5"
    "mV"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_per_Pres
    ""
    RAT_FUNC
    "%6.5"
    "mV/hPa"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_q0p002_COMPU
    ""
    RAT_FUNC
    "%6.4"
    "V"

    COEFFS 0 500 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_RSA
    ""
    RAT_FUNC
    "%6.3"
    "mV"

    COEFFS 0 5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_Sq
    ""
    RAT_FUNC
    "%6.2"
    "mV*mV"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_Sq_HiRes
    ""
    RAT_FUNC
    "%6.3"
    "mV*mV"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Vol_float
    ""
    RAT_FUNC
    "%6.2"
    "l"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Vol_NSC
    ""
    RAT_FUNC
    "%7.6"
    "L"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    VSLIMLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VSLIMLMP_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VSLIMLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    VSWVLV_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VSWVLV_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VSWVLV_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    VSWVLV_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VSWVLV_TYPTWINFLW_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VSWVLV_TYPTWINFLW_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    v_01_RSA
    ""
    RAT_FUNC
    "%6.4"
    "km/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Watt_per_s_40_RSA
    ""
    RAT_FUNC
    "%6.1"
    "W/s"

    COEFFS 0 0.025 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Watt_RSA
    ""
    RAT_FUNC
    "%6.1"
    "W"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    WNTR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WNTR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WNTR_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    WU001_RSA
    ""
    RAT_FUNC
    "%6.5"
    "wu"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    WU1_RSA
    ""
    RAT_FUNC
    "%6.5"
    "wu"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    WU_RSA
    ""
    RAT_FUNC
    "%6.2"
    "wu"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    W_PA
    ""
    RAT_FUNC
    "%6.4"
    "mWs"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ZFC_BPfac
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 546.116666666667 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ZFC_EvalEngSpd_Rslt
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF ZFC_EvalEngSpd_Rslt
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ZFC_EvalEngSpd_Rslt
    ""
    TAB_VERB
    3
    0 "ZFC_ST_ALL_INJ_LOW"
    1 "ZFC_ST_DES_INJ_MAX"
    2 "ZFC_ST_ERR_INJ_MAX"


/end COMPU_VTAB

/begin COMPU_METHOD
    ZFC_Inj_State
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF ZFC_Inj_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ZFC_Inj_State
    ""
    TAB_VERB
    5
    0 "ZFC_ST_INJ_IDLE"
    16 "ZFC_ST_INJ_DEM"
    32 "ZFC_ST_INJ_PROG"
    48 "ZFC_ST_INJ_RES_OK"
    64 "ZFC_ST_INJ_RES_NOK"


/end COMPU_VTAB

/begin COMPU_METHOD

    ZFC_PerHalfRatio
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ZFC_State
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF ZFC_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ZFC_State
    ""
    TAB_VERB
    8
    1 "ZFC_ST_BREAK"
    2 "ZFC_ST_WAIT"
    3 "ZFC_ST_START_OVRRUN"
    4 "ZFC_ST_CHANGE_PRAIL"
    5 "ZFC_ST_CHECK_PRAIL"
    6 "ZFC_ST_ETCLB"
    7 "ZFC_ST_NVCLB"
    16 "ZFC_ST_SUBS_FUNC"


/end COMPU_VTAB

/begin COMPU_METHOD

    default
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    defaultAscii
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin RECORD_LAYOUT Axis_Xs16

    NO_AXIS_PTS_X     1 SWORD
    AXIS_PTS_X        2 SWORD INDEX_INCR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Axis_Xu16

    NO_AXIS_PTS_X     1 UWORD
    AXIS_PTS_X        2 UWORD INDEX_INCR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Axis_Xu8

    NO_AXIS_PTS_X     1 UBYTE
    AXIS_PTS_X        2 UBYTE INDEX_INCR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT CurG_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT CurG_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Cur_Xs16Ws16

    NO_AXIS_PTS_X     1 SWORD
    AXIS_PTS_X        2 SWORD INDEX_INCR DIRECT
    FNC_VALUES        3 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Kf_Xs16_Ys16_Ws16

    NO_AXIS_PTS_X     1 SWORD
    NO_AXIS_PTS_Y     2 SWORD
    AXIS_PTS_X        3 SWORD INDEX_INCR DIRECT
    AXIS_PTS_Y        4 SWORD INDEX_INCR DIRECT
    FNC_VALUES        5 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Kl_Xs16_Ws16

    NO_AXIS_PTS_X     1 SWORD
    AXIS_PTS_X        2 SWORD INDEX_INCR DIRECT
    FNC_VALUES        3 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Kw_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Kw_Ws32

    FNC_VALUES        1 SLONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Kw_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Kw_Wu32

    FNC_VALUES        1 ULONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Kw_Wu8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT MapG_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT MapG_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Map_Xs16Ys16Ws16

    NO_AXIS_PTS_X     1 SWORD
    NO_AXIS_PTS_Y     2 SWORD
    AXIS_PTS_X        3 SWORD INDEX_INCR DIRECT
