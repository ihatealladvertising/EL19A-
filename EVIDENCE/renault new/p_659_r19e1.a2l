/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_dly_avg
		"Duration for mean value calculation"
		VALUE
		0x800580a2
		RSA_RecordLayout_VALUE_UWORD
		1310.7
		xjpwlzd_oiewmrb_devberc_s_R0ooa
		0.
		1310.7
    DISPLAY_IDENTIFIER Cxx_rupc_dly_avg 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_dly_eng_stal
		"Duration for mean value calculation"
		VALUE
		0x800580a0
		RSA_RecordLayout_VALUE_UWORD
		1310.7
		xjpwlzd_oiewmrb_devberc_s_R0ooa
		0.
		1310.7
    DISPLAY_IDENTIFIER Cxx_rupc_dly_eng_stal 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_ftc_rup
		"Filter time constant for PFT relative upstream pressure"
		VALUE
		0x8005809e
		RSA_RecordLayout_VALUE_UWORD
		1310.7
		xjpwlzd_oiewmrb_devberc_s_R0ooa
		0.
		1310.7
    DISPLAY_IDENTIFIER Cxx_rupc_ftc_rup 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_plau_diag
		"Maximum value for difference between PFT relative pressure and zero"
		VALUE
		0x8005809c
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_rupc_plau_diag 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_tco_max
		"High coolant temperature over which the learning process is not allowed"
		VALUE
		0x8005809a
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_rupc_tco_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_tco_min
		"Low coolant temperature over which the learning process is not allowede"
		VALUE
		0x80058098
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_rupc_tco_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_tia_max
		"High ambient temperature over which the learning process is not allowed"
		VALUE
		0x80058096
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_rupc_tia_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_tia_min
		"Low ambient temperature under which the learning process is not allowed"
		VALUE
		0x80058094
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_rupc_tia_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rwhb
		"Rear wheelbase"
		VALUE
		0x80058ab7
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		ndwztoc_dvutqfb_rggeqyd_m__1o0a
		0.5
		3.05
    DISPLAY_IDENTIFIER Cxx_rwhb 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rwhs_fil
		"Time constant of the first order filter of the rear wheels speed"
		VALUE
		0x80058ab6
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		xjpwlzd_oiewmrb_devberc_s_R0ooa
		0.
		5.1
    DISPLAY_IDENTIFIER Cxx_rwhs_fil 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rwhs_max_tra_acel
		"Threshold of maximum rear wheel speed to calculate the transverse acceleration"
		VALUE
		0x80058ab5
		RSA_RecordLayout_VALUE_UBYTE
		255
		gbkklec_Fwupora_tbolFEa_khA_15a
		5.
		260.
    DISPLAY_IDENTIFIER Cxx_rwhs_max_tra_acel 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rwhs_min_tra_acel
		"Threshold of minimum rear wheel speed to calculate the transverse acceleration"
		VALUE
		0x80058ab4
		RSA_RecordLayout_VALUE_UBYTE
		255
		gbkklec_Fwupora_tbolFEa_khA_15a
		5.
		260.
    DISPLAY_IDENTIFIER Cxx_rwhs_min_tra_acel 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sat_thd_dft_vlv
		"Calibration of the valve position saturation threshold when a default on the valve is present"
		VALUE
		0x800618b8
		RSA_RecordLayout_VALUE_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_sat_thd_dft_vlv 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_amp_fail_val
		"Defaut value for ambiant pressure"
		VALUE
		0x8005769a
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_sens_amp_fail_val 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_cnbkocs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_brk_lk_vb_dly
		"Time to enable the open active brake switch conection status"
		VALUE
		0x800587fa
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_sens_brk_lk_vb_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_cnbkocs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_brk_lk_vb_thd
		"Minimum battery voltage to enable the open active brake switch conection status"
		VALUE
		0x800587f8
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_sens_brk_lk_vb_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbxxsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_clu_lk_vb_dly
		"Filter time to enable the begin clutch contactor connection detection"
		VALUE
		0x8006b240
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_sens_clu_lk_vb_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbxxsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_clu_lk_vb_thd
		"Minimum battery voltage to enable the begin cluch contactor connection detection"
		VALUE
		0x8006b23e
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_sens_clu_lk_vb_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1cs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_doc1_utp_dft
		"Default value of before oxydation 1 temperature"
		VALUE
		0x8005812c
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_sens_doc1_utp_dft 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_ex_prs_apc_dfdec
		"Ex man pres sens plausibility detected failure counter decrement in case of stopped engine"
		VALUE
		0x80057da6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_sens_ex_prs_apc_dfdec 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_ex_prs_apc_dfinc
		"Ex man pres sens plausibility detected failure counter increment in case of stopped engine"
		VALUE
		0x80057da4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_sens_ex_prs_apc_dfinc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_ex_prs_isr_dfdec
		"Ex man pres sens plausibility detected failure couter decrement"
		VALUE
		0x80057da2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_sens_ex_prs_isr_dfdec 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_ex_prs_isr_dfinc
		"Ex man pres sens plausibility detected failure couter increment"
		VALUE
		0x80057da0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_sens_ex_prs_isr_dfinc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_maf_fail_swi_neg_slop
		"Calibration for negative slope of mass air flow sensor failure mode switch"
		VALUE
		0x800573e2
		RSA_RecordLayout_VALUE_UWORD
		250000
		gkqcqfd_fDxenaa_ypqitmb_BsD_020
		-250000.
		0.
    DISPLAY_IDENTIFIER Cxx_sens_maf_fail_swi_neg_slop 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_maf_fail_swi_pos_slop
		"Calibration for positive slope of mass air flow sensor failure mode switch"
		VALUE
		0x800573e0
		RSA_RecordLayout_VALUE_UWORD
		250000
		rmrnjea_mqkhdia_FFkBoda_Bpp__20
		0.
		250000.
    DISPLAY_IDENTIFIER Cxx_sens_maf_fail_swi_pos_slop 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_maf_fail_val
		"Calibration for default value of mass air flow from sensor"
		VALUE
		0x800573de
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_sens_maf_fail_val 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_uprsabv_stbxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_pft_abv_up_prs
		"CSF upstream absolute pressure raw information"
		VALUE
		0x80058102
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_sens_pft_abv_up_prs 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_rup_fail_val
		"Pftrelprs sensor default value"
		VALUE
		0x80058092
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_sens_rup_fail_val 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtcsxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sens_tbt
		"replaced value of before turbine temperature if invalid value of sensor"
		VALUE
		0x80058358
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_sens_tbt 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_sge_emtv_tia_thd
		"Threshold value for antisurge inhibation in cold ambient air"
		VALUE
		0x80043b6c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_sge_emtv_tia_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_cmf_cut_forc_inc
		"Force increment/s for comfortable cut-of of speed limiter"
		VALUE
		0x80040164
		RSA_RecordLayout_VALUE_UWORD
		131070
		fdzoyza_nfCiiDb_dkpidrc_N___o0a
		0.
		131070.
    DISPLAY_IDENTIFIER Cxx_sl_cmf_cut_forc_inc 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_long_step
		"Value of requested speed step in speed limiter mode when accel or decel switch pressed continuously"
		VALUE
		0x800401b7
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_sl_long_step 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_long_step_mph
		"Value of requested speed step in Speed limiter mode when accel or decel switch pressed continuously in mph"
		VALUE
		0x800401b6
		RSA_RecordLayout_VALUE_UBYTE
		255
		fbhwiwa_ocsanpd_EFwyxCb_m_A_1oa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_sl_long_step_mph 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_max_forc
		"Maximum saturation value of the force request (greater than the minimum force feasible by the engine)"
		VALUE
		0x80040160
		RSA_RecordLayout_VALUE_SLONG
		131068
		akxoDid_fubczib_zregbrc_N_R05oa
		-20000.
		111068.
    DISPLAY_IDENTIFIER Cxx_sl_max_forc 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_ovs_warn_thd
		"Speed theshold to activate the warning in case of volontary speed limiter overspeed"
		VALUE
		0x800401aa
		RSA_RecordLayout_VALUE_SBYTE
		25.5
		lthgvjd_avbcmnd_vDEmpCc_khA_10a
		-12.8
		12.7
    DISPLAY_IDENTIFIER Cxx_sl_ovs_warn_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_ovs_warn_thd_mph
		"Speed theshold in mph to activate the warning in case of volontary speed limiter overspeed"
		VALUE
		0x800401a9
		RSA_RecordLayout_VALUE_SBYTE
		25.5
		bAngAbd_ajxybma_vfjmdrc_m___00a
		-12.8
		12.7
    DISPLAY_IDENTIFIER Cxx_sl_ovs_warn_thd_mph 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_sp_max_forc_dec
		"Force gradient  for comfortable speed limiter activation"
		VALUE
		0x8004015c
		RSA_RecordLayout_VALUE_ULONG
		131070
		fdzoyza_nfCiiDb_dkpidrc_N___o0a
		0.
		131070.
    DISPLAY_IDENTIFIER Cxx_sl_sp_max_forc_dec 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_svkl_ig
		"speed limiter integral gain"
		VALUE
		0x8004015a
		RSA_RecordLayout_VALUE_UWORD
		1953.09519763205
		xhkomjb_oEsFhsa_hslCgmd_1C_522a
		0.
		1953.09519763205
    DISPLAY_IDENTIFIER Cxx_sl_svkl_ig 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_svkl_max_i_cor
		"Maximum value of the integral correction for speed limiter"
		VALUE
		0x80040158
		RSA_RecordLayout_VALUE_SWORD
		124.998092651367
		Cnqgazb_fqFBleb_mEzjcxc_kA49o40
		-62.5
		62.4980926513672
    DISPLAY_IDENTIFIER Cxx_sl_svkl_max_i_cor 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_svkl_min_i_cor
		"Minimal value of the integral correction for speed limiter"
		VALUE
		0x80040156
		RSA_RecordLayout_VALUE_SWORD
		124.998092651367
		Cnqgazb_fqFBleb_mEzjcxc_kA49o40
		-62.5
		62.4980926513672
    DISPLAY_IDENTIFIER Cxx_sl_svkl_min_i_cor 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_svkl_pg
		"Speed limiter proportinal gain"
		VALUE
		0x80040154
		RSA_RecordLayout_VALUE_UWORD
		124.998092651367
		BAEcsta_ghvaACd_foyhjAa_1_0o00a
		0.
		124.998092651367
    DISPLAY_IDENTIFIER Cxx_sl_svkl_pg 
    FORMAT "%10.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sl_svkl_vs_thd
		"Speed threshold to activate servoing in case of the speed limiter"
		VALUE
		0x80040152
		RSA_RecordLayout_VALUE_SBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		-128.
		127.
    DISPLAY_IDENTIFIER Cxx_sl_svkl_vs_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_slow_dec_slop
		"Value for the slow decrease slope"
		VALUE
		0x800413f8
		RSA_RecordLayout_VALUE_UWORD
		65535
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		-65535.
		0.
    DISPLAY_IDENTIFIER Cxx_slow_dec_slop 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_slow_inc_slop
		"Value for the slow increase slope"
		VALUE
		0x800413f6
		RSA_RecordLayout_VALUE_UWORD
		65535
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_slow_inc_slop 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_pft_cold_fac_pr
		"Weighting factor on richness offset for takeoff in PR mode in cold driving condition for PFT"
		VALUE
		0x80041fe2
		RSA_RecordLayout_VALUE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_smk_pft_cold_fac_pr 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_pft_med_fac_pr
		"Weighting factor on richness offset for takeoff in PR mode in medium driving condition for PFT"
		VALUE
		0x80041fe1
		RSA_RecordLayout_VALUE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_smk_pft_med_fac_pr 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_pft_nul_fac_pr
		"Weighting factor on richness offset for takeoff in PR mode in critical driving condition for PFT"
		VALUE
		0x80041fe0
		RSA_RecordLayout_VALUE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_smk_pft_nul_fac_pr 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_rich_agb_ofs
		"Richness offset value during automatic gearbox shifting"
		VALUE
		0x800431b0
		RSA_RecordLayout_VALUE_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cxx_smk_rich_agb_ofs 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_rich_agb_t
		"Time value"
		VALUE
		0x800431ae
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_smk_rich_agb_t 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_rich_agb_vs_thd
		"Vehicule speed threshold"
		VALUE
		0x800431ac
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_smk_rich_agb_vs_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_rich_lim_comb_neg_slop
		"Negative gradient value used for richness transition"
		VALUE
		0x800431aa
		RSA_RecordLayout_VALUE_UWORD
		4
		bauhfwa_Bqxetgb_xFDtpAa_n__a00a
		-4.
		0.
    DISPLAY_IDENTIFIER Cxx_smk_rich_lim_comb_neg_slop 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_rich_lim_comb_pos_slop
		"Positive gradient value used for richness transition"
		VALUE
		0x800431a8
		RSA_RecordLayout_VALUE_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cxx_smk_rich_lim_comb_pos_slop 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_rich_lim_sta
		"Smoke limitation richness during Starting Combustion Mode"
		VALUE
		0x800431a6
		RSA_RecordLayout_VALUE_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cxx_smk_rich_lim_sta 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_tkof_neg_slop_pr
		"Minimum gradient to decrease richness offset for takeoff in PR mode"
		VALUE
		0x80041fde
		RSA_RecordLayout_VALUE_UWORD
		30
		oztfsAd_CwctBpb_rFDnrpa_1__000a
		-30.
		0.
    DISPLAY_IDENTIFIER Cxx_smk_tkof_neg_slop_pr 
    FORMAT "%8.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_tkof_neg_slop_rij
		"Maximum gradient to increase richness offset for takeoff in RIJ mode"
		VALUE
		0x800422e0
		RSA_RecordLayout_VALUE_UWORD
		30
		oztfsAd_CwctBpb_rFDnrpa_1__000a
		-30.
		0.
    DISPLAY_IDENTIFIER Cxx_smk_tkof_neg_slop_rij 
    FORMAT "%8.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_tkof_pos_slop_pr
		"Maximum gradient to increase richness offset for takeoff in PR mode"
		VALUE
		0x80041fdc
		RSA_RecordLayout_VALUE_UWORD
		30
		FhAkxid_mcktvDd_ysgmcea_1__000a
		0.
		30.
    DISPLAY_IDENTIFIER Cxx_smk_tkof_pos_slop_pr 
    FORMAT "%7.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_smk_tkof_pos_slop_rij
		"Minimum gradient to decrease richness offset for takeoff in RIJ mode"
		VALUE
		0x800422de
		RSA_RecordLayout_VALUE_UWORD
		30
		FhAkxid_mcktvDd_ysgmcea_1__000a
		0.
		30.
    DISPLAY_IDENTIFIER Cxx_smk_tkof_pos_slop_rij 
    FORMAT "%7.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_snd_edge_dly
		"Calibration used for EGR bypass desactivation delay"
		VALUE
		0x80043abc
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_snd_edge_dly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sp_vs_dif_brk_det
		"Difference between requested speed and vehicle speed to detect braking"
		VALUE
		0x80059158
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_sp_vs_dif_brk_det 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_cool_fil
		"Time constant for last filter"
		VALUE
		0x800578da
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_spg_cool_fil 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_fail_max_slop
		"Maximal slope for switching between sens_spg and default value"
		VALUE
		0x800577f4
		RSA_RecordLayout_VALUE_UWORD
		20000
		AmckCEa_rzqllkb_aAvivha_hp__a0a
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_spg_fail_max_slop 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_prs_lih_neg_slop
		"Value of the exhaut pressure setpoint negative slope in case of spg pressure sensor limphome"
		VALUE
		0x80043af8
		RSA_RecordLayout_VALUE_UWORD
		3276750
		BzcDpDc_nDAfApa_arzCqqa_BsA005a
		-3276750.
		0.
    DISPLAY_IDENTIFIER Cxx_spg_prs_lih_neg_slop 
    FORMAT "%8.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_prs_lih_pos_slop
		"Value of the exhaut pressure setpoint positive slope in case of spg pressure sensor limphome"
		VALUE
		0x80043af6
		RSA_RecordLayout_VALUE_UWORD
		3276750
		fFxvEyc_Farydib_Bvpdzsa_Bp__o20
		0.
		3276750.
    DISPLAY_IDENTIFIER Cxx_spg_prs_lih_pos_slop 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_reg_apl_down_max
		"Threshold of negative deviation of the turbocharger"
		VALUE
		0x8005d02e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		rblEeyb_zFoAatd_ouFadBc_hk__10a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_spg_reg_apl_down_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_reg_apl_up_max
		"Threshold of positive deviation of the turbocharger"
		VALUE
		0x8005d02c
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		rblEeyb_zFoAatd_ouFadBc_hk__10a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_spg_reg_apl_up_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_sp_dev_max
		"Maximum bap setpoint variation allowed to enable the continuous diagnostic of the turbocharger"
		VALUE
		0x8005d02a
		RSA_RecordLayout_VALUE_UWORD
		32767
		AmckCEa_rzqllkb_aAvivha_hp__a0a
		0.
		32767.
    DISPLAY_IDENTIFIER Cxx_spg_sp_dev_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_sp_ex_df_slop_neg
		"Value of the exhaut pressure setpoint negative slope in case of exhaust pressure sensor limphome."
		VALUE
		0x8005f884
		RSA_RecordLayout_VALUE_UWORD
		3276750
		dFifxkd_wwDjcjb_dhaphib_hs_0e20
		-3276750.
		0.
    DISPLAY_IDENTIFIER Cxx_spg_sp_ex_df_slop_neg 
    FORMAT "%8.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_sp_ex_df_slop_pos
		"Value of the exhaut pressure setpoint negative slope in case of exhaust pressure sensor limphome."
		VALUE
		0x8005f882
		RSA_RecordLayout_VALUE_UWORD
		3276750
		fFxvEyc_Farydib_Bvpdzsa_Bp__o20
		0.
		3276750.
    DISPLAY_IDENTIFIER Cxx_spg_sp_ex_df_slop_pos 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_sp_max
		"Manifold air pressure maximum threshold value"
		VALUE
		0x800437c6
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_spg_sp_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_sp_min
		"Manifold air pressure minimum threshold value"
		VALUE
		0x800437c4
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_spg_sp_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_sp_slop_neg
		"Negative slope for manifold air pressure setpoint transition"
		VALUE
		0x800437c2
		RSA_RecordLayout_VALUE_UWORD
		3276750
		dFifxkd_wwDjcjb_dhaphib_hs_0e20
		-3276750.
		0.
    DISPLAY_IDENTIFIER Cxx_spg_sp_slop_neg 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_sp_slop_pos
		"Positive slope for manifold air pressure setpoint transition"
		VALUE
		0x800437c0
		RSA_RecordLayout_VALUE_UWORD
		3276750
		ErjifAd_avCpgCa_wuzpvkc_hsA0ea0
		0.
		3276750.
    DISPLAY_IDENTIFIER Cxx_spg_sp_slop_pos 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_spg_sp_t_fil
		"Time constant of boost air pressure setpoint first order filter"
		VALUE
		0x8005d028
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_spg_sp_t_fil 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sta_alt_dec
		"Alternator power min slew rate after start"
		VALUE
		0x8005897f
		RSA_RecordLayout_VALUE_UBYTE
		2550
		Bejmpoa_ynzmvdb_ymxlAud_W__000a
		-2550.
		0.
    DISPLAY_IDENTIFIER Cxx_sta_alt_dec 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sta_alt_inc
		"Alternator power max slew rate after start"
		VALUE
		0x8005897e
		RSA_RecordLayout_VALUE_UBYTE
		2550
		igyxFvd_CwEnvea_dcprdrc_W___o0a
		0.
		2550.
    DISPLAY_IDENTIFIER Cxx_sta_alt_inc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sta_dspl_arw_down_dly
		"Cxx_sta_dspl_arw_down_dly"
		VALUE
		0x800592f2
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sta_stt_is_in_dly
		"Delay to enter in activate state  after condition state (coming engine start)"
		VALUE
		0x8005aa6e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_sta_stt_is_in_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sta_stt_vld_dly
		"Duration of the starter status validity status before starter status reading"
		VALUE
		0x8005ceee
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_sta_stt_vld_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sta_tco_dly_dft
		"time value depending on starting coolant temperature (default value)"
		VALUE
		0x8005af3e
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_sta_tco_dly_dft 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_statqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sta_tq_inc
		"Starting torque ramp value for difficult start"
		VALUE
		0x8004188c
		RSA_RecordLayout_VALUE_UBYTE
		255
		xmoyqad_zuxgeuc_aAwwvka_NsA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_sta_tq_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_statqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sta_tq_inc_dly
		"Delay before starting torque ramp activation"
		VALUE
		0x8004188a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_sta_tq_inc_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stal_ac_max_tq_d
		"Air conditioning maximum torque derivative factor in anti-stall strategy"
		VALUE
		0x8005cd88
		RSA_RecordLayout_VALUE_UWORD
		3.99993896484375
		zqyfxbd_bjFzFBd_nzzBAub_smA_3a0
		0.
		3.99993896484375
    DISPLAY_IDENTIFIER Cxx_stal_ac_max_tq_d 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stal_ac_max_tq_dft_val
		"Air conditioning maximum torque default value in anti-stall strategy"
		VALUE
		0x8005cd86
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_stal_ac_max_tq_dft_val 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stal_ac_max_tq_p
		"Air conditioning maximum torque proportional factor in anti-stall strategy"
		VALUE
		0x8005cd84
		RSA_RecordLayout_VALUE_UWORD
		7.9998779296875
		DjimBpc_DyzDjma_Dkpqeyb_1mA_1a0
		0.
		7.9998779296875
    DISPLAY_IDENTIFIER Cxx_stal_ac_max_tq_p 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stal_ac_max_tq_ref
		"Air conditioning reference torque in anti-stall strategy"
		VALUE
		0x8005cd82
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_stal_ac_max_tq_ref 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stal_ac_max_tq_slop
		"Air conditioning maximum torque slew rate in anti-stall strategy"
		VALUE
		0x8005cd80
		RSA_RecordLayout_VALUE_UBYTE
		127.5
		wCxComb_nadiaac_aAowvka_NsA_20a
		0.
		127.5
    DISPLAY_IDENTIFIER Cxx_stal_ac_max_tq_slop 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stal_ac_max_tq_thd
		"Air conditioning maximum torque threshold in anti-stall strategy"
		VALUE
		0x8005cd7e
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_stal_ac_max_tq_thd 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stal_acs_dsb_dly
		"Minimum duration before leaving stalling states in anti-stall strategy"
		VALUE
		0x8005cd7c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_stal_acs_dsb_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stal_alt_ac_amp_h_thd
		"Atmospheric pressure threshold to inhibit anti-stall strategy for alternator and air conditioning"
		VALUE
		0x8005cd7a
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_stal_alt_ac_amp_h_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stal_alt_ac_amp_l_thd
		"Atmospheric pressure threshold to activate anti-stall strategy for alternator and air conditioning"
		VALUE
		0x8005cd78
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_stal_alt_ac_amp_l_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbstain_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_star_mod_nok
		"Value to selected the default value of starting mode"
		VALUE
		0x80055bb9
		RSA_RecordLayout_VALUE_UBYTE
		3
		FgevDdd_qBlgAwd_zDfgqra_n_R0aoa
		1.
		4.
    DISPLAY_IDENTIFIER Cxx_star_mod_nok 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_stop_toil_fil
		"Filtering coefficient for oil temperature computing in engine stop running conditions"
		VALUE
		0x80058532
		RSA_RecordLayout_VALUE_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_stop_toil_fil 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sudn_brk_det_dly
		"Minimum time to detect a sudden braking"
		VALUE
		0x80059156
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_sudn_brk_det_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sudn_brk_min_decl_thd
		"Minimum deceleration value to detect sudden braking"
		VALUE
		0x80059154
		RSA_RecordLayout_VALUE_SWORD
		25.5
		egzsxdd_khlsmxa_bqjovCc_msA_10a
		-12.
		13.5
    DISPLAY_IDENTIFIER Cxx_sudn_brk_min_decl_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_supl_nr1
		"Supplier number (byte 0)"
		VALUE
		0x80056f71
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_supl_nr1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_supl_nr2
		"Supplier number (byte 1)"
		VALUE
		0x80056f70
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_supl_nr2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_supl_nr3
		"Supplier number (byte 2)"
		VALUE
		0x80056f6f
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_supl_nr3 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_swa_abst_frm_dly
		"Steering Wheel Angle Control Unit absence detection time-out"
		VALUE
		0x80055bc1
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_swa_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_swa_ecu_conf
		"Steering Wheel Angle Control Unit feature for Mux configuration detection (always present or opt.)"
		VALUE
		0x80055bc0
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swa_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_swa_vld_abst_frm_dec
		"Steering Wheel Angle Control Unit : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bbf
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swa_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_swa_vld_abst_frm_inc
		"Steering Wheel Angle Control Unit : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bbe
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swa_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swi_drv_is_ofs
		"engine offset after cut when engine derivate is low"
		VALUE
		0x80043304
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_swi_drv_is_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swi_drv_n_thd
		"switch derivate engine threshold"
		VALUE
		0x80043302
		RSA_RecordLayout_VALUE_SWORD
		16383
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		-8192.
		8191.
    DISPLAY_IDENTIFIER Cxx_swi_drv_n_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_chlg_dly
		"max delay for waiting the response to the challenge"
		VALUE
		0x80043368
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_swlk_chlg_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_diag_dly
		"Minimum delay for availability of Immobilizer diagnosis"
		VALUE
		0x80043367
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_swlk_diag_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_id_forb_dly
		"max delay during which both engine running and exchanges with BCM are forbidden"
		VALUE
		0x80043366
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_swlk_id_forb_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_id_nok_ctr_dec
		"max number of authentications allowed after the end of antiscanning timer"
		VALUE
		0x80043365
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swlk_id_nok_ctr_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_id_nr_ena
		"max number of false authentications allowed"
		VALUE
		0x80043364
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swlk_id_nr_ena 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_key_dlt_dly
		"max time where clearing the secret key is allowed"
		VALUE
		0x80043363
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_swlk_key_dlt_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_key_dly
		"max waiting time for receiving secret key"
		VALUE
		0x80043362
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_swlk_key_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_noi[0]
		"Value used to calculate the first noise byte of the ECM_VERLOG frame"
		VALUE
		0x8004335c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swlk_noi_1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_noi[1]
		"Value used to calculate the first noise byte of the ECM_VERLOG frame"
		VALUE
		0x8004335d
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swlk_noi_2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_noi[2]
		"Value used to calculate the first noise byte of the ECM_VERLOG frame"
		VALUE
		0x8004335e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swlk_noi_3 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_noi[3]
		"Value used to calculate the first noise byte of the ECM_VERLOG frame"
		VALUE
		0x8004335f
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swlk_noi_4 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_noi[4]
		"Value used to calculate the first noise byte of the ECM_VERLOG frame"
		VALUE
		0x80043360
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swlk_noi_5 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_noi[5]
		"Value used to calculate the first noise byte of the ECM_VERLOG frame"
		VALUE
		0x80043361
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_swlk_noi_6 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_swlk_pwl_dly
		"duration of the power lacth phase concerning the anti-theft strategy."
		VALUE
		0x8004335b
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_swlk_pwl_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_sys_c_nr
		"Other system features"
		VALUE
		0x80056f6e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_sys_c_nr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_t_acq_tenv
		"Time treshold calibration for the acquisition of tenv"
		VALUE
		0x800578c6
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_t_acq_tenv 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_t_egr_byp_dist_cmd
		"Anti-jamming function duration"
		VALUE
		0x80060088
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_t_egr_byp_dist_cmd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_t_emtv_act_1
		"Time period of the active Power latch."
		VALUE
		0x80058b72
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_t_emtv_act_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_t_emtv_act_dly
		"Time period after the key on to activate the Power Latch strategy."
		VALUE
		0x80058b70
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_t_emtv_act_dly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_t_ovn_pp
		"Time delay to avoid the ear to be saturated in case of overrun conditions in pp mode"
		VALUE
		0x800614a0
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_t_ovn_pp 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_t_ovn_pr
		"Time delay to avoid the ear to be saturated in case of overrun conditions in pr mode"
		VALUE
		0x8006149e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_t_ovn_pr 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_t_ovn_rij
		"Time delay to avoid the ear to be saturated in case of overrun conditions in ri mode"
		VALUE
		0x8006149c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_t_ovn_rij 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tac_tout_timer_io
		"Delay to declare timeout when a supplier I/O control is executed"
		VALUE
		0x80056e22
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tout_timer_io 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tac_tout_timer_stac
		"Delay to declare timeout when a static test supplier control is executed"
		VALUE
		0x80056e20
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tout_timer_stac 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tac_vb_max
		"Maximum battery voltage to allow heat glow control"
		VALUE
		0x80056e1e
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_tac_vb_max 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tac_vb_min
		"Calibration value of the minimum battery voltage for static test"
		VALUE
		0x80056e1c
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_tac_vb_min 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_act_err_thd
		"Loop deviation thresold : The regulation is reactived if the loop deviation is greater than thresold"
		VALUE
		0x800497fa
		RSA_RecordLayout_VALUE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_act_err_thd 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_act_reg_dly
		"Max duration of the regulation deactivation during a change of combustion mode"
		VALUE
		0x800497f8
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tbt_act_reg_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_act_thd_pr
		"Value for regulation activation in PR mode"
		VALUE
		0x8004715c
		RSA_RecordLayout_VALUE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_act_thd_pr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_act_thd_rij
		"Value for regulation activation during regular combustion mode"
		VALUE
		0x80048bf0
		RSA_RecordLayout_VALUE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_act_thd_rij 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_adv_fac
		"Factor for the advance correction of the main injection"
		VALUE
		0x800497f6
		RSA_RecordLayout_VALUE_SWORD
		720
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_tbt_adv_fac 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_cut_thd_pr
		"Value for regulation deactivation in PR mode"
		VALUE
		0x8004715a
		RSA_RecordLayout_VALUE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_cut_thd_pr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_cut_thd_rij
		"Value for regulation deactivation during regular combustion mode"
		VALUE
		0x80048bee
		RSA_RecordLayout_VALUE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_cut_thd_rij 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_dg_t_fil
		"Low pass filter factor of the D part"
		VALUE
		0x800497f4
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tbt_dg_t_fil 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_dev_min
		"minimum temperature before turbine deviation"
		VALUE
		0x8005836c
		RSA_RecordLayout_VALUE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_diag_dev_min 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_h
		"maximum temperature before turbine for SRC max diagnosis"
		VALUE
		0x8005836a
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_diag_h 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_n_min
		"minimum engine speed for diagnosis condition"
		VALUE
		0x80058368
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_tbt_diag_n_min 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_n_min_pup
		"minimum engine speed for diagnosis condition in case of pull up commutation"
		VALUE
		0x80058366
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_tbt_diag_n_min_pup 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_no_dev_cdn
		"maximum difference between first and current filtered temperature"
		VALUE
		0x80058364
		RSA_RecordLayout_VALUE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_diag_no_dev_cdn 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_tco_min
		"minimum coolant temperature for non deviation diagnosis condition"
		VALUE
		0x80058362
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tbt_diag_tco_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_tco_min_pup
		"minimum engine coolant temperature for diagnosis condition in case of pull up commutation"
		VALUE
		0x80058360
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tbt_diag_tco_min_pup 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_temp_min
		"first break point of temperature before turbine minimum possible value"
		VALUE
		0x8005835e
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_diag_temp_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_tqi_min
		"minimum torque indicated for diagnosis condition"
		VALUE
		0x8005835c
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tbt_diag_tqi_min 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_diag_tqi_min_pup
		"minimum torque indicated for diagnosis condition in case of pull up commutation"
		VALUE
		0x8005835a
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tbt_diag_tqi_min_pup 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_err_max
		"Maximum temperature loop deviation of the regulator"
		VALUE
		0x800497f2
		RSA_RecordLayout_VALUE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_err_max 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_err_min
		"Minimum temperature loop deviation of the regulator"
		VALUE
		0x800497f0
		RSA_RecordLayout_VALUE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_err_min 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_err_min_pr
		"Minimum temperature loop deviation in PR mode"
		VALUE
		0x80047158
		RSA_RecordLayout_VALUE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_err_min_pr 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_err_min_rij
		"Minimum temperature loop deviation in regular combustion mode"
		VALUE
		0x80048bec
		RSA_RecordLayout_VALUE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_err_min_rij 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_fim_main_fac
		"Factor for correction of fuel mass quantity of the main injection"
		VALUE
		0x800497ee
		RSA_RecordLayout_VALUE_SWORD
		200
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_fim_main_fac 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_fpo_fac
		"Factor for the fuel mass quantity correction of the post injection"
		VALUE
		0x800497ec
		RSA_RecordLayout_VALUE_SWORD
		200
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_fpo_fac 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_fpo_max_cor_pft_asd_rgn
		"Maximal fuel mass quantity correction for the post injection in AD RGN mode"
		VALUE
		0x80047156
		RSA_RecordLayout_VALUE_SWORD
		200
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_fpo_max_cor_pft_asd_rgn 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_fpo_min_cor_pft_asd_rgn
		"Minimal fuel mass quantity correction for the post injection in ASD RGN mode"
		VALUE
		0x80047154
		RSA_RecordLayout_VALUE_SWORD
		200
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_fpo_min_cor_pft_asd_rgn 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtcsxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_ftc
		"filtering time for temperature before turbine"
		VALUE
		0x80058356
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_tbt_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_ig_reg_ini
		"Value of the initialization of the I part of the TBT PI regulator"
		VALUE
		0x800497ea
		RSA_RecordLayout_VALUE_SWORD
		200
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_ig_reg_ini 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_pid_reg_max_pr
		"Maximal value of the final output regulator in pr mode"
		VALUE
		0x800497e8
		RSA_RecordLayout_VALUE_SWORD
		200
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_pid_reg_max_pr 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_pid_reg_max_rij
		"Maximum value of the final output regulator in regular combustion mode"
		VALUE
		0x800497e6
		RSA_RecordLayout_VALUE_SWORD
		200
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_pid_reg_max_rij 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_pid_reg_min_pr
		"Minimal value of the final output regulator in pr mode"
		VALUE
		0x800497e4
		RSA_RecordLayout_VALUE_SWORD
		200
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_pid_reg_min_pr 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_pid_reg_min_rij
		"Minimum value of the final output regulator in regular combustion mode"
		VALUE
		0x800497e2
		RSA_RecordLayout_VALUE_SWORD
		200
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_pid_reg_min_rij 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_pid_slop_neg
		"Negative slope of the output regulator"
		VALUE
		0x800497e0
		RSA_RecordLayout_VALUE_UWORD
		100
		aFiroeb_qrguaya_rFDnrda_1__000a
		-100.
		0.
    DISPLAY_IDENTIFIER Cxx_tbt_pid_slop_neg 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_pid_slop_pos
		"Positive slope of the output regulator"
		VALUE
		0x800497de
		RSA_RecordLayout_VALUE_UWORD
		100
		rbbElwb_afouokc_ysgmcia_1__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tbt_pid_slop_pos 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_reg_apl_up
		"Threshold for the maximum temperature before turbine"
		VALUE
		0x800497dc
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_reg_apl_up 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_sp_max
		"Maximal temperature before turbine setpoint"
		VALUE
		0x800497da
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_sp_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_sp_min
		"Minimal temperature before turbine setpoint"
		VALUE
		0x800497d8
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_sp_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_sp_pft_asd_rgn
		"Unfiltered value of the tbt setpoint in ASD RGN mode"
		VALUE
		0x80047152
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_tbt_sp_pft_asd_rgn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_sp_t_fil_down
		"Falling factor for target temperature before turbine low pass filter"
		VALUE
		0x800497d6
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tbt_sp_t_fil_down 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tbt_sp_t_fil_up
		"Rising factor for target temperature before turbine low pass filter"
		VALUE
		0x800497d4
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tbt_sp_t_fil_up 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_atissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_agb_df_min_is_n
		"Nominal idle speed setpoint calibration in case of a validity status default under drive or drag reduction mode"
		VALUE
		0x8005ada0
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_tco_agb_df_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_cata_hot_dft
		"Default value for engine coolant temperature in case of failure in catalyst heating state"
		VALUE
		0x80067ef6
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tco_cata_hot_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_fail_cmd_mdf_dly
		"Maximum duration of mdf1 activation (compromised between engine compartment cooling and electric balance)."
		VALUE
		0x8006b090
		RSA_RecordLayout_VALUE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_tco_fail_cmd_mdf_dly 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_h_thd_mon
		"High temperature threhold for monitoring"
		VALUE
		0x80043b48
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tco_h_thd_mon 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_inc
		"Max gradient of tco"
		VALUE
		0x800583e6
		RSA_RecordLayout_VALUE_UWORD
		30
		jFzaled_fvrodod_dCEcchc_qsA_10a
		0.
		30.
    DISPLAY_IDENTIFIER Cxx_tco_inc 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_inf
		"Min value of coolant temperature during air mass flow sensor drift diagnosis"
		VALUE
		0x800573dc
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tco_inf 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_l_thd_mon
		"Low temperature threhold for monitoring"
		VALUE
		0x80043b46
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tco_l_thd_mon 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_mdf_dly
		"Maximum duration of water temperature monitoring to activate mdf1 (compromised between engine compartment cooling and electric"
		VALUE
		0x8006b08e
		RSA_RecordLayout_VALUE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_tco_mdf_dly 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_ms_ofs_clc_dft
		"Default value of engine coolant temperature for activation of soot mass computation"
		VALUE
		0x80046622
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tco_ms_ofs_clc_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_rgn_temp_chk_dft
		"Default value for engine coolant temperature in check temperature state"
		VALUE
		0x80067f5e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tco_rgn_temp_chk_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcomcsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_sig_mcut_max_slop
		"Slop of engine cooling temperature for micro cut detection"
		VALUE
		0x800583e0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tco_sig_mcut_max_slop 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_sup
		"Max value of coolant temperature during air mass flow sensor drift diagnosis"
		VALUE
		0x800573da
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tco_sup 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_thd
		"Cxx_tco_thd"
		VALUE
		0x8005975e
		RSA_RecordLayout_VALUE_UWORD
		240
		VA_F_0v1_m40_21
		-40
		200
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_toil_fil
		"Filtering coefficient for water temperature."
		VALUE
		0x80058530
		RSA_RecordLayout_VALUE_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tco_toil_fil 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tco_toil_thd
		"Reference water temperature in usual running conditions for oil temperature computing"
		VALUE
		0x8005852e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tco_toil_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tdc_mdl_fail_tdc_cnt
		"Top Dead Center counter when Vsx_mdl_tco_vld == Nok."
		VALUE
		0x80058432
		RSA_RecordLayout_VALUE_UWORD
		65535
		FrDdxAd_gBlBhnd_wuyyxkd_T_A_1oa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_tdc_mdl_fail_tdc_cnt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tdc_mdl_tdc_cnt
		"Top Dead Center counter."
		VALUE
		0x80058430
		RSA_RecordLayout_VALUE_UWORD
		65535
		FrDdxAd_gBlBhnd_wuyyxkd_T_A_1oa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_tdc_mdl_tdc_cnt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tdc_rev_nr
		"ratio of one complete revolution on one tdc duration"
		VALUE
		0x80058920
		RSA_RecordLayout_VALUE_UBYTE
		4
		muDnEvb_EDdacoc_Fqvzxwb_n_R0ooa
		0.
		4.
    DISPLAY_IDENTIFIER Cxx_tdc_rev_nr 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_temp_dif_mv_max
		"Value of the maximum threshold for OBD service 06 purposey"
		VALUE
		0x80043aba
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_temp_dif_mv_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_temp_dif_mv_min
		"Criteria threshold used to detect an EGR bypass failure"
		VALUE
		0x80043ab8
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_temp_dif_mv_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thd_n_diag_vb_h
		"Engine speed threshold for high level battery voltage fault detection"
		VALUE
		0x80058a9a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_thd_n_diag_vb_h 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thd_n_diag_vb_l
		"Engine speed threshold for low level battery voltage fault detection"
		VALUE
		0x80058a98
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_thd_n_diag_vb_l 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thd_vb_h
		"Max threshold for battery voltage fault detection"
		VALUE
		0x80058a96
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_thd_vb_h 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thd_vb_l
		"Min threshold for battery voltage fault detection"
		VALUE
		0x80058a94
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_thd_vb_l 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_alt_pwm_sp
		"Alternator pwm setpoint for THP regulation"
		VALUE
		0x8005cf41
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_thpl_alt_pwm_sp 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_alt_pwm_sp_ptc
		"Alternator pwm setpoint for THP regulation with ptc actives"
		VALUE
		0x8005cf40
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_thpl_alt_pwm_sp_ptc 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_alt_pwm_dif_mv
		"Mean value of Alt PWM difference for THP Diagnostic"
		VALUE
		0x8005907a
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_thpl_diag_alt_pwm_dif_mv 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_alt_pwm_fil_fac
		"Filtered factor of Alt PWM for THP diagnostic"
		VALUE
		0x80059078
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_thpl_diag_alt_pwm_fil_fac 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_alt_pwm_t
		"Timing of the alternator PWM diagnostic"
		VALUE
		0x80059076
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_thpl_diag_alt_pwm_t 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_alt_pwm_tot_t
		"Time counter of comparaison of Alt PWM Values"
		VALUE
		0x80059074
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_thpl_diag_alt_pwm_tot_t 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_fedg_dec
		"Decrementation gain for the falling edge detection diagnostic"
		VALUE
		0x80059072
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_thpl_diag_fedg_dec 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_fedg_inc
		"Incrementation of default counter if a falling edge default is detected"
		VALUE
		0x80059070
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_thpl_diag_fedg_inc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_max_thd
		"Max Threshold of THP default counter"
		VALUE
		0x8005906e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_thpl_diag_max_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_redg_dec
		"Decrementation of default counter if a rising edge default is detected"
		VALUE
		0x8005906c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_thpl_diag_redg_dec 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_redg_inc
		"Incrementation of default counter if a rising edge default is detected"
		VALUE
		0x8005906a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_thpl_diag_redg_inc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_redg_tot_dec
		"Decrementation of default counter for all THP diagnostic"
		VALUE
		0x80059068
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_thpl_diag_redg_tot_dec 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_redg_tot_inc
		"Incrementation of default counter for all THP diagnostic"
		VALUE
		0x80059066
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_thpl_diag_redg_tot_inc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_tot_on_t
		"Time during comparaison of Alt PWM Values"
		VALUE
		0x80059064
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_thpl_diag_tot_on_t 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_diag_vb_t
		"Timing of the voltage battery diagnostic"
		VALUE
		0x80059062
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_thpl_diag_vb_t 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_heat_tco_h
		"high coolant hysteresis temperature for heating request of THP activation"
		VALUE
		0x80055268
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_heat_tco_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_heat_tco_l
		"low coolant hysteresis temperature for heating request of THP activation"
		VALUE
		0x80055266
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_heat_tco_l 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_heat_tco_ofs_h
		"high coolant temperature delta for heating request of THP activation"
		VALUE
		0x80055264
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_heat_tco_ofs_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_heat_tco_ofs_l
		"low coolant temperature delta for heating request of THP activation"
		VALUE
		0x80055262
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_heat_tco_ofs_l 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_heat_tia_h
		"high air hysteresis temperature for heating request of THP activation"
		VALUE
		0x80055260
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_heat_tia_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_heat_tia_l
		"low intake air hysteresis temperature for heating request of THP activation"
		VALUE
		0x8005525e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_heat_tia_l 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_heat_tia_ofs_h
		"high air temperature delta for heating request of THP activation"
		VALUE
		0x8005525c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_heat_tia_ofs_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_heat_tia_ofs_l
		"low intake air temperature delta for heating request of THP activation"
		VALUE
		0x8005525a
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_heat_tia_ofs_l 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_meca_pow
		"Coolant heater mechanical power"
		VALUE
		0x8006b33a
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_thpl_meca_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_min_dec_dly
		"Minimum delay before THP power decrement"
		VALUE
		0x8005900a
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_thpl_min_dec_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_min_inc_dly
		"Minimum delay before THP power increment"
		VALUE
		0x80059009
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_thpl_min_inc_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_min_is_n
		"Thermoplunger idle speed setpoint calibration"
		VALUE
		0x8005ae36
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_thpl_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_nr
		"cl_coo_ctl_chctlxx/ Number of coolant heater elements"
		VALUE
		0x80055258
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_thpl_nr 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_nr_1
		"Number of THP on pin1"
		VALUE
		0x80059060
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_thpl_nr_1 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_nr_2
		"Number of THP on pin2"
		VALUE
		0x8005905f
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_thpl_nr_2 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_nr_3
		"Number of THP on pin3"
		VALUE
		0x8005905e
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_thpl_nr_3 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_pft_tco_h
		"high coolant hysteresis temperature for particulate filter regeneration request of THP activation"
		VALUE
		0x800432b8
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_pft_tco_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_pft_tco_l
		"low coolant hysteresis temperature for particulate filter regeneration request of THP activation"
		VALUE
		0x800432b6
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_pft_tco_l 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_pft_tco_ofs_h
		"high coolant temperature delta for particulate filter regeneration request of THP activation"
		VALUE
		0x800432b4
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_pft_tco_ofs_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_pft_tco_ofs_l
		"low coolant temperature delta for particulate filter regeneration request of THP activation"
		VALUE
		0x800432b2
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_thpl_pft_tco_ofs_l 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_ptc_dly
		"Delay of the use of Cxx_alt_pwm_thpl_sp_ptc (PTC actives)"
		VALUE
		0x8005cf3e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_thpl_ptc_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_samp
		"Sampling time for PID governor"
		VALUE
		0x80059008
		RSA_RecordLayout_VALUE_UBYTE
		0.255
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		0.255
    DISPLAY_IDENTIFIER Cxx_thpl_samp 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_h_conf1
		"high threshold of THP actuator 1"
		VALUE
		0x8005cf3c
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_h_conf1 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_h_conf2
		"high threshold of THP actuator 2"
		VALUE
		0x8005cf3a
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_h_conf2 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_h_conf3
		"high threshold of THP actuator 3"
		VALUE
		0x8005cf38
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_h_conf3 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_h_conf4
		"high threshold of THP actuator 4"
		VALUE
		0x8005cf36
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_h_conf4 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_h_conf5
		"high threshold of THP actuator 5"
		VALUE
		0x8005cf34
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_h_conf5 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_h_conf6
		"high threshold of THP actuator 6"
		VALUE
		0x8005cf32
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_h_conf6 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_h_conf7
		"high threshold of THP actuator 7"
		VALUE
		0x8005cf30
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_h_conf7 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_l_conf1
		"low threshold of THP actuator 1"
		VALUE
		0x8005cf2e
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_l_conf1 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_l_conf2
		"low threshold of THP actuator 2"
		VALUE
		0x8005cf2c
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_l_conf2 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_l_conf3
		"low threshold of THP actuator 3"
		VALUE
		0x8005cf2a
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_l_conf3 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_l_conf4
		"low threshold of THP actuator 4"
		VALUE
		0x8005cf28
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_l_conf4 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_l_conf5
		"low threshold of THP actuator 5"
		VALUE
		0x8005cf26
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_l_conf5 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_l_conf6
		"low threshold of THP actuator 6"
		VALUE
		0x8005cf24
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_l_conf6 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_thd_l_conf7
		"low threshold of THP actuator 7"
		VALUE
		0x8005cf22
		RSA_RecordLayout_VALUE_UWORD
		50
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		50.
    DISPLAY_IDENTIFIER Cxx_thpl_thd_l_conf7 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_tqi_err_max
		"Maximum tqi error threshold for thpl activation"
		VALUE
		0x800432b0
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_thpl_tqi_err_max 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_tqi_err_min
		"Minimum tqi error threshold for thpl activation"
		VALUE
		0x800432ae
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_thpl_tqi_err_min 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_vb_dif_thd
		"Battery Voltage Threshold not to detec a default"
		VALUE
		0x8005905c
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_thpl_vb_dif_thd 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_vb_err_neg
		"Negative balance voltage error threshold"
		VALUE
		0x8005cf20
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_thpl_vb_err_neg 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_vb_err_pos
		"Positive balance voltage error threshold"
		VALUE
		0x8005cf1e
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_thpl_vb_err_pos 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_vb_sp
		"Voltage setpoint for THP regulation"
		VALUE
		0x8005cf1c
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_thpl_vb_sp 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_thpl_vb_sp_ptc
		"Voltage setpoint for THP regulation with ptc actives"
		VALUE
		0x8005cf1a
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_thpl_vb_sp_ptc 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_cata_hot_dft
		"Default value for intake air temperature in case of failure in catalyst heating state"
		VALUE
		0x80067ef4
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_cata_hot_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_df_ex_prs_sp
		""
		VALUE
		0x80060bb0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_df_ex_prs_sp 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_df_ol_spg
		"Intake air temperature default value in case of failure Nok0 (for supercharger open loop)"
		VALUE
		0x8005e044
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_df_ol_spg 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_df_spg_sp
		"Intake air temperature default value in case of Nok_0 status for supercharger setpoint"
		VALUE
		0x8005f880
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_df_spg_sp 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_efi_ar_temp_dft
		"Inlet air temperature default value"
		VALUE
		0x8005824e
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_tia_efi_ar_temp_dft 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_fail_val
		"Default value for Intake air temperature"
		VALUE
		0x800578c4
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_fail_val 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_grd_inf
		"Min slope value for gradient on air temperature variable"
		VALUE
		0x800573d8
		RSA_RecordLayout_VALUE_UWORD
		25
		xuCdrCc_xlEAFsd_fCEjphd_q__0o0a
		-25.
		0.
    DISPLAY_IDENTIFIER Cxx_tia_grd_inf 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_grd_sup
		"Max slope value for gradient on air temperature variable"
		VALUE
		0x800573d6
		RSA_RecordLayout_VALUE_UWORD
		25
		jFzaled_fvrodod_dCEcchc_qsA_10a
		0.
		25.
    DISPLAY_IDENTIFIER Cxx_tia_grd_sup 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_lih_val
		"Intake air temperature limp home value"
		VALUE
		0x80045868
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_lih_val 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_max_h_thd_mon
		"Maximum intake air temperature high threshold"
		VALUE
		0x80043b44
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_max_h_thd_mon 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_max_l_thd_mon
		"Maximum intake air temperature low threshold"
		VALUE
		0x80043b42
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_max_l_thd_mon 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_min_h_thd_mon
		"Minimum intake air temperature high threshold"
		VALUE
		0x80043b40
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_min_h_thd_mon 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_min_l_thd_mon
		"Minimum intake air temperature low threshold"
		VALUE
		0x80043b3e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_min_l_thd_mon 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_ms_ofs_clc_dft
		"Default value of intake air temperature for activation of soot mass computation"
		VALUE
		0x80046620
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_ms_ofs_clc_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tia_rgn_temp_chk_dft
		"Default value for intake air temperature in check temperature state"
		VALUE
		0x80067f5c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tia_rgn_temp_chk_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_dsb_coup_dly
		"Turnoff delay on coupler state in takeoff strategy"
		VALUE
		0x8005cd76
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_acs_dsb_coup_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_dsb_dly
		"Maximum duration of accessories deactivation in takeoff strategy"
		VALUE
		0x8005cd74
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_acs_dsb_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_dsb_n
		"Minimum engine speed to request accessories deactivation in takeoff strategy"
		VALUE
		0x8005cd72
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_tkof_acs_dsb_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_dsb_pwt_sp
		"Minimum driver powertrain setpoint to request accessories deactivation in takeoff strategy"
		VALUE
		0x8005cd70
		RSA_RecordLayout_VALUE_UWORD
		1
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_tkof_acs_dsb_pwt_sp 
    FORMAT "%8.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_dsb_rwhs_t
		"Time constant of vehicle speed filter in rear wheel speed configuration"
		VALUE
		0x8005cd6e
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_tkof_acs_dsb_rwhs_t 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_dsb_tqe_sp_rat
		"Minimum driver torque/maximum torque ratio to request accessories deactivation in takeoff strategy"
		VALUE
		0x8005cd6c
		RSA_RecordLayout_VALUE_UWORD
		255.99609375
		fsjmcda_jujcsFa_ycbccca_n_Ra6oa
		0.
		255.99609375
    DISPLAY_IDENTIFIER Cxx_tkof_acs_dsb_tqe_sp_rat 
    FORMAT "%10.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_dsb_vs
		"Maximum vehicle speed to request accessories deactivation in takeoff strategy"
		VALUE
		0x8005cd6a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_acs_dsb_vs 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_dsb_vs_pos_slop
		"Maximum vehicle acceleration on takeoff"
		VALUE
		0x8005cd68
		RSA_RecordLayout_VALUE_UBYTE
		255
		jBfcoed_dgfcpFd_nsxxcxb_khCRa0a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tkof_acs_dsb_vs_pos_slop 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_ena_pwt_sp
		"Maximum driver powertrain setpoint to request accessories reactivation in takeoff strategy"
		VALUE
		0x8005cd66
		RSA_RecordLayout_VALUE_UWORD
		1
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_tkof_acs_ena_pwt_sp 
    FORMAT "%8.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_ena_vs
		"Minimum vehicle speed to request accessories reactivation in takeoff strategy"
		VALUE
		0x8005cd64
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_acs_ena_vs 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_acs_ena_zero_vs
		"Vehicle speed (0 km/h) to prevent accessories deactivation on no-load accelerations in takeoff strategy"
		VALUE
		0x8005cd62
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_acs_ena_zero_vs 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_alt_ac_amp_h_thd
		"Atmospheric pressure threshold to inhibit takeoff strategy for alternator and air conditioning"
		VALUE
		0x8005cd60
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_tkof_alt_ac_amp_h_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_alt_ac_amp_l_thd
		"Atmospheric pressure threshold to activate takeoff strategy for alternator and air conditioning"
		VALUE
		0x8005cd5e
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_tkof_alt_ac_amp_l_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_ass_h_vs_mv_min
		"Minimum vehicule speed to freeze the calculation of the high vehicle speed average"
		VALUE
		0x800401ee
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_ass_h_vs_mv_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_ass_h_vs_mv_t
		"Filter time for calculation of high vehicle speed average"
		VALUE
		0x800401ec
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tkof_ass_h_vs_mv_t 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_ass_l_vs_mv_max
		"Maximum vehicule speed used in the calculation of the low vehicle speed average"
		VALUE
		0x800401ea
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_ass_l_vs_mv_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_ass_l_vs_mv_min
		"Minimum vehicule speed to freeze the calculation of the low vehicle speed average"
		VALUE
		0x800401e8
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_ass_l_vs_mv_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_ass_l_vs_mv_t_down
		"Filter time for calculation of low vehicle speed average, when decreasing"
		VALUE
		0x800401e6
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tkof_ass_l_vs_mv_t_down 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_ass_l_vs_mv_t_up
		"Filter time for calculation of low vehicle speed average, when increasing"
		VALUE
		0x800401e5
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tkof_ass_l_vs_mv_t_up 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_ass_slop_swi
		"Slope constant used during inibition/desinibition of the strategie."
		VALUE
		0x800401e4
		RSA_RecordLayout_VALUE_UBYTE
		1
		lnarxkb_nEFqnga_vinBdFa_roCR2a0
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_tkof_ass_slop_swi 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_cdn_vs_max
		"Maximum vehicule speed to detect that the vehicules is in take off conditions"
		VALUE
		0x80059c26
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_cdn_vs_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_tkodlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_ena_vs_thd
		"Threshold of vehicle speed to enter in take off state"
		VALUE
		0x800413f4
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_ena_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_tkodlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_end_vs_thd
		"Threshold of vehicle speed to exit of take off state"
		VALUE
		0x800413f2
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_end_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_tkodlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_n_grd_end_thd
		"derivate of engine speed threshold for take off"
		VALUE
		0x800413f0
		RSA_RecordLayout_VALUE_SWORD
		16383
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		-8192.
		8191.
    DISPLAY_IDENTIFIER Cxx_tkof_n_grd_end_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_spt_inc
		"Constant value added to sportivity take off factor when a sportivity take off is detected"
		VALUE
		0x800401e3
		RSA_RecordLayout_VALUE_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_tkof_spt_inc 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_spt_pdl_grd_cdn
		"Pedal gradient condition to detect a sportive take off"
		VALUE
		0x800401e2
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		sDwtuec_riAActa_vnpvdDd_ri__50a
		0.
		5.1
    DISPLAY_IDENTIFIER Cxx_tkof_spt_pdl_grd_cdn 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_spt_pdl_rat_cdn
		"Powertrain setpoint (%) condition to detect a sportivity take off"
		VALUE
		0x800401e0
		RSA_RecordLayout_VALUE_UWORD
		1.25
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.25
    DISPLAY_IDENTIFIER Cxx_tkof_spt_pdl_rat_cdn 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_spt_pdl_rat_grd_cdn
		"Powertrain setpoint (%) condition associated with pedal gradient condition to detect a sportivity take off"
		VALUE
		0x800401de
		RSA_RecordLayout_VALUE_UWORD
		1.25
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.25
    DISPLAY_IDENTIFIER Cxx_tkof_spt_pdl_rat_grd_cdn 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_spt_slop_dec
		"Time factor to decrease the sportivity take off criteria."
		VALUE
		0x800401dc
		RSA_RecordLayout_VALUE_UBYTE
		1
		FgyAFgc_tigarid_FoAniEa_ro__ao0
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_tkof_spt_slop_dec 
    FORMAT "%8.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_spt_vs_max
		"Maximum vehicle speed to detect a sportivity take off"
		VALUE
		0x800401da
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_spt_vs_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_spt_vs_min
		"Minimum vehicle speed to detect a sportivity take off"
		VALUE
		0x800401d8
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_spt_vs_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_stop_vs
		"Limit vehicule speed that determines the end of a take off"
		VALUE
		0x80059c24
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_tkof_stop_vs 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_tkodlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tkof_vs_n_rat_stop_thd
		"Threshold of vehicle and engine speed ratio to exit of take off state"
		VALUE
		0x800413ee
		RSA_RecordLayout_VALUE_UWORD
		210
		zkbcymc_ixcjqia_ikunepd_ijp_a1a
		-10.
		200.
    DISPLAY_IDENTIFIER Cxx_tkof_vs_n_rat_stop_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_togl_dly
		"Delay to consider toggling phenomena"
		VALUE
		0x8005916d
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_togl_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_togl_thr
		"Maximum number of activation/deactivation before a calibrated delay to consider toggling"
		VALUE
		0x8005916c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_togl_thr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_toil_is_n_ofs
		"Minimum after-sale idle speed setpoint"
		VALUE
		0x8005ade6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_toil_is_n_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_toil_pws_max_dly
		"Maximum duration after engine stall of maintain of the calculation of the oil temperature."
		VALUE
		0x8005852c
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_toil_pws_max_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_toil_tco_cnt
		"Water temp minus Oil temperature value for 'power-latch' maintenance"
		VALUE
		0x8005852a
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_toil_tco_cnt 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ton_dly_is_val
		"Turn on delay delay value in idle speed condition for EMTV failure mode"
		VALUE
		0x80043b6b
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ton_dly_is_val 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ton_dly_ovr_val
		"Turn on delay value in overun condition for EMTV failure mode"
		VALUE
		0x80043b6a
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ton_dly_ovr_val 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tq_dif_acel_dec_fil
		"Cxx_tq_dif_acel_dec_fil"
		VALUE
		0x800597c5
		RSA_RecordLayout_VALUE_UBYTE
		10.2
		VA_F_0v04_p0_7
		0
		10.2
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tq_dif_acel_inc_fil
		"Cxx_tq_dif_acel_inc_fil"
		VALUE
		0x800597c4
		RSA_RecordLayout_VALUE_UBYTE
		10.2
		VA_F_0v04_p0_7
		0
		10.2
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tq_dif_degr_fac
		"Cxx_tq_dif_degr_fac"
		VALUE
		0x800597c1
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_F_0v004_p0_4
		0
		1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tq_dif_esti_tqe_fil
		"Cxx_tq_dif_esti_tqe_fil"
		VALUE
		0x800597c3
		RSA_RecordLayout_VALUE_UBYTE
		10.2
		VA_F_0v04_p0_7
		0
		10.2
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tq_dif_fil
		"Cxx_tq_dif_fil"
		VALUE
		0x800597c2
		RSA_RecordLayout_VALUE_UBYTE
		10.2
		VA_F_0v04_p0_7
		0
		10.2
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tq_lim_tbt_reg_cfm
		"Activation of torque limitation by temperature before turbine regulation validity status (0: no limitation, 1: low limitation, 2: mean"
		VALUE
		0x8005b1fc
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_tq_lim_tbt_reg_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqe_max_gear_slop_neg
		"Negative slope during the transmission sift"
		VALUE
		0x80041932
		RSA_RecordLayout_VALUE_UBYTE
		255
		zlhAlxa_lflywEd_dCwmhyc_NsA_n0a
		-255.
		0.
    DISPLAY_IDENTIFIER Cxx_tqe_max_gear_slop_neg 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqe_max_gear_slop_pos
		"Positive slope during the transmission sift"
		VALUE
		0x80041931
		RSA_RecordLayout_VALUE_UBYTE
		255
		xmoyqad_zuxgeuc_aAwwvka_NsA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tqe_max_gear_slop_pos 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tqe_max_ovn
		"torque saturation for the controller PI"
		VALUE
		0x8005aef8
		RSA_RecordLayout_VALUE_SWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_tqe_max_ovn 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_cor_maf_dif_t_fil_ocd
		"Low pass filter time constant for air mass flow loop deviation in ocd mode"
		VALUE
		0x8005bb0a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tqi_cor_maf_dif_t_fil_ocd 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_cor_maf_dif_t_fil_pr
		"Low pass filter time constant for air mass flow loop deviation in pr mode"
		VALUE
		0x8005bc2a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tqi_cor_maf_dif_t_fil_pr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_cor_maf_dif_t_fil_rij
		"Low pass filter time constant for air mass flow loop deviation in rij mode"
		VALUE
		0x8005c39c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tqi_cor_maf_dif_t_fil_rij 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_egr_off_fac
		"Specific air mass correction factor in case of EGR shut off in ocd mode"
		VALUE
		0x8005bb08
		RSA_RecordLayout_VALUE_SWORD
		10
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		-5.
		5.
    DISPLAY_IDENTIFIER Cxx_tqi_egr_off_fac 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_fim_tot_cor_max_pr
		"Maximum fuel quantity correction for torque model corrections in pr mode"
		VALUE
		0x8005bc29
		RSA_RecordLayout_VALUE_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_tqi_fim_tot_cor_max_pr 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_fim_tot_cor_max_rij
		"Maximum fuel quantity correction for torque model corrections in rij mode"
		VALUE
		0x8005c39b
		RSA_RecordLayout_VALUE_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_tqi_fim_tot_cor_max_rij 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_fim_tot_cor_min_pr
		"Minimum fuel quantity correction for torque model corrections in pr mode"
		VALUE
		0x8005bc28
		RSA_RecordLayout_VALUE_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_tqi_fim_tot_cor_min_pr 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_fim_tot_cor_min_rij
		"Minimum fuel quantity correction for torque model corrections in rij mode"
		VALUE
		0x8005c39a
		RSA_RecordLayout_VALUE_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_tqi_fim_tot_cor_min_rij 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ftc_mon
		"Filtering time calibration for the operating torque"
		VALUE
		0x80043b3c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tqi_ftc_mon 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_h_thd_mon
		"high operating torque threshold for monitoring"
		VALUE
		0x80043b3a
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_h_thd_mon 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_l_thd_decl_pp
		"Torque threshold for the definition of the overrun in pp mode"
		VALUE
		0x8006149a
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_l_thd_decl_pp 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_l_thd_decl_pr
		"Torque threshold for the definition of the overrun in pr mode"
		VALUE
		0x80061498
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_l_thd_decl_pr 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_l_thd_decl_rij
		"Lower torque threshold used in the definition of the overrun in rij mode"
		VALUE
		0x80061496
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_l_thd_decl_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_l_thd_mon
		"low operating torque threshold for monitoring"
		VALUE
		0x80043b38
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_l_thd_mon 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_max_comb_slop
		"value of positive and negative value used for inner torque transition."
		VALUE
		0x80041930
		RSA_RecordLayout_VALUE_UBYTE
		254
		xmoyqad_zuxgeuc_aAwwvka_NsA_10a
		0.
		254.
    DISPLAY_IDENTIFIER Cxx_tqi_max_comb_slop 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_max_mon
		"Maximal torque value for monitoring"
		VALUE
		0x80043b36
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_max_mon 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_min_mon
		"Minimum torque value for monitoring"
		VALUE
		0x80043b34
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_min_mon 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_amp_h_thd
		"Atmospheric pressure high threshold for torque compensation activation in ocd mode"
		VALUE
		0x8005bb06
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_amp_h_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_amp_l_thd
		"Atmospheric pressure low threshold for torque compensation activation in ocd mode"
		VALUE
		0x8005bb04
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_amp_l_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_n_h_thd_h
		"Engine speed high limit upper hysterisis for torque compensation activation in ocd mode"
		VALUE
		0x8005bb02
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_n_h_thd_h 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_n_h_thd_l
		"Engine speed high limit lower hysterisis for torque compensation activation in ocd mode"
		VALUE
		0x8005bb00
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_n_h_thd_l 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_n_l_thd_h
		"Engine speed low limit upper hysterisis for torque compensation activation in ocd mode"
		VALUE
		0x8005bafe
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_n_l_thd_h 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_n_l_thd_l
		"Engine speed low limit lower hysterisis for torque compensation activation in ocd mode"
		VALUE
		0x8005bafc
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_n_l_thd_l 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_tco_h_thd
		"Hysterisis upper threshold for coolant temperature conditions for torque compensation activation in ocd mode"
		VALUE
		0x8005bafa
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_tco_h_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_tco_l_thd
		"Hysterisis lower threshold for coolant temperature conditions for torque compensation activation in ocd mode"
		VALUE
		0x8005baf8
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_tco_l_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_tia_h_thd
		"Hysterisis upper threshold for intake air temperature conditions for torque compensation activation in ocd mode"
		VALUE
		0x8005baf6
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_tia_h_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_tia_l_thd
		"Hysterisis lower threshold for intake air temperature conditions for torque compensation activation in ocd mode"
		VALUE
		0x8005baf4
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_tia_l_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_tqi_h_thd_h
		"Final indicated torque high limit upper hysterisis for torque compensation activation in ocd mode"
		VALUE
		0x8005baf2
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_tqi_h_thd_h 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_tqi_h_thd_l
		"Final indicated torque high limit lower hysterisis for torque compensation activation in ocd mode"
		VALUE
		0x8005baf0
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_tqi_h_thd_l 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_tqi_l_thd_h
		"Final indicated torque low limit upper hysterisis for torque compensation activation in ocd mode"
		VALUE
		0x8005baee
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_tqi_l_thd_h 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_ena_tqi_l_thd_l
		"Final indicated torque low limit lower hysterisis for torque compensation activation in ocd mode"
		VALUE
		0x8005baec
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_ena_tqi_l_thd_l 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_ocd_fim_lim_max
		"Maximum offset for fuel flow correction in ocd mode"
		VALUE
		0x8005baea
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tqi_ocd_fim_lim_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_rat_cut_thd
		"Threshold of indicated torque ratio used for the filtering of the oil temperature model"
		VALUE
		0x80058528
		RSA_RecordLayout_VALUE_UWORD
		1
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_tqi_rat_cut_thd 
    FORMAT "%11.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_raw_bch
		"Raw indicated torque bench value"
		VALUE
		0x800432fa
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_raw_bch 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_sp_bch
		"Setpoint indicated torque bench value"
		VALUE
		0x800432f8
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_sp_bch 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_tgt_bch
		"Target indicated torque bench value"
		VALUE
		0x800432f6
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_tqi_tgt_bch 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_thpl_ig_neg
		"Negative integral gain for torque governor (for coolant heater max number)"
		VALUE
		0x800432ac
		RSA_RecordLayout_VALUE_UWORD
		10
		ffmgnAd_dDtexfb_dlatjta_1mCR1o0
		0.
		10.
    DISPLAY_IDENTIFIER Cxx_tqi_thpl_ig_neg 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tqi_thpl_ig_pos
		"Positive integral gain for torque governor (for coolant heater max number)"
		VALUE
		0x800432aa
		RSA_RecordLayout_VALUE_UWORD
		10
		ffmgnAd_dDtexfb_dlatjta_1mCR1o0
		0.
		10.
    DISPLAY_IDENTIFIER Cxx_tqi_thpl_ig_pos 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tra_acel_cur_fil
		"Cxx_tra_acel_cur_fil"
		VALUE
		0x800592e2
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tra_acel_mv_fil
		"Time constant of the first order filter on the average of the transverse acceleration"
		VALUE
		0x80058ab3
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tra_acel_mv_fil 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tsta_dft_lght_off_tco_thd
		"offset for switching off the alert temperature lamp, in HIGH temperature mode."
		VALUE
		0x8005904c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tsta_dft_lght_off_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_tsta_dft_lght_on_tco_thd
		"offset for switching ON the alert temperature lamp, in HIGH temperature mode."
		VALUE
		0x8005904a
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_tsta_dft_lght_on_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_tt_cor
		"Measured temperature before turbine correction"
		VALUE
		0x80058f26
		RSA_RecordLayout_VALUE_UWORD
		1200
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		0.
		1200.
    DISPLAY_IDENTIFIER Cxx_tt_cor 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_uhil_flat_thd
		"Cxx_uhil_flat_thd"
		VALUE
		0x80059762
		RSA_RecordLayout_VALUE_SWORD
		65535
		VA_F_1_p0_13
		-32768
		32767
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_up_it_temp_fail_val
		"Upstream throttle temperature fail value"
		VALUE
		0x800578d2
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_up_it_temp_fail_val 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_up_shf_dly
		"Cxx_up_shf_dly"
		VALUE
		0x80059308
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_up_shf_pow_rat
		"Cxx_up_shf_pow_rat"
		VALUE
		0x80059214
		RSA_RecordLayout_VALUE_UWORD
		100
		VA_F_0v125_p0_14
		0
		100
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ups_rich_fail_val
		"Default value for upstream proportional sensor richness and calculated richness"
		VALUE
		0x8005837e
		RSA_RecordLayout_VALUE_UWORD
		2
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_ups_rich_fail_val 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_usm_abst_frm_dly
		"USM Control Unit absence detection time-out"
		VALUE
		0x80055bbd
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_usm_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_usm_ecu_conf
		"USM Control Unit feature for Mux Network configuration detection (always present or optional)"
		VALUE
		0x80055bbc
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_usm_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_usm_vld_abst_frm_dec
		"USM Control Unit : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bbb
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_usm_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_usm_vld_abst_frm_inc
		"USM Control Unit : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bba
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_usm_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vb_fil_fac
		"cl_coo_ctl_chctlxx/ Filtering factor for battery voltage"
		VALUE
		0x80055256
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_vb_fil_fac 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vb_fil_fac_neg
		"Filtered Factor for battery voltage, if variation if negative"
		VALUE
		0x8005905a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_vb_fil_fac_neg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vb_fil_fac_pos
		"Filtered Factor for battery voltage, if variation if positive"
		VALUE
		0x80059058
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_vb_fil_fac_pos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_floatcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vb_flot_ena_dly
		"Delay for enabling battery floating (when all conditions are OK)"
		VALUE
		0x8005d006
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_vb_flot_ena_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vb_thd_h
		"cl_coo_ctl_chctlxx/ High voltage threshold to enable cut state"
		VALUE
		0x80055254
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_vb_thd_h 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vb_thd_l
		"cl_coo_ctl_chctlxx/ Low voltage threshold to enable cut state"
		VALUE
		0x80055252
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_vb_thd_l 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vb_vnt_pwm_max
		"Maximum vnt pwm value after battery voltage correction"
		VALUE
		0x800400e2
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vb_vnt_pwm_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vb_vnt_pwm_min
		"Minimum vnt pwm value after battery voltage correction"
		VALUE
		0x800400e0
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vb_vnt_pwm_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vb_vnt_ref
		"Battery voltage reference for vnt pwm corection"
		VALUE
		0x800400de
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_vb_vnt_ref 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vers_nr1
		"Edition number (byte 0)"
		VALUE
		0x80056f6d
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_vers_nr1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vers_nr2
		"Edition number (byte 1)"
		VALUE
		0x80056f6c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_vers_nr2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_dgtdvcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vh_dist_max_dif
		"Maximum allowed differential value of vehicle distance (for incrementing model)"
		VALUE
		0x80058aae
		RSA_RecordLayout_VALUE_UBYTE
		255
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_vh_dist_max_dif 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vh_run_max_is_i_ofs
		"Offset on the maximum saturation if the vehicle is running"
		VALUE
		0x8005ab28
		RSA_RecordLayout_VALUE_SWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_vh_run_max_is_i_ofs 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vh_run_min_is_i_fac
		"Factor of the losses to estimate the maximum saturation if the vehicle is running"
		VALUE
		0x8005ab26
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_vh_run_min_is_i_fac 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vh_stop_min_is_i_fac
		"Factor of the losses to estimate the minimum saturation if the vehicle is stopped"
		VALUE
		0x8005ab24
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_vh_stop_min_is_i_fac 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vh_wht
		"Vehicle mass"
		VALUE
		0x80040150
		RSA_RecordLayout_VALUE_UWORD
		2550
		nBjwgbd_shAlvca_ldEgbrc_kC_0ooa
		450.
		3000.
    DISPLAY_IDENTIFIER Cxx_vh_wht 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_cgv_dfz_neg
		"Gravity centre of the negative output membership function"
		VALUE
		0x8005ece4
		RSA_RecordLayout_VALUE_SWORD
		2
		lasreaa_cardnzb_hCDtpsa_n__a00a
		-1.
		1.
    DISPLAY_IDENTIFIER Cxx_vnt_cgv_dfz_neg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_cold_sta_n_thd
		"Engine speed threshold for vnt coldstart"
		VALUE
		0x80043384
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_vnt_cold_sta_n_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ctl_max
		"Maximum vnt control value"
		VALUE
		0x8005d7ec
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_ctl_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ctl_min
		"Minimum vnt control value"
		VALUE
		0x8005d7ea
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_ctl_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ctl_ofs_gear_nok
		"Offset vnt control value in case of invalid gear status"
		VALUE
		0x8005d7e8
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_ctl_ofs_gear_nok 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ctl_slop_neg
		"Maximum negative slope for the vnt control value pwm"
		VALUE
		0x8005d7e6
		RSA_RecordLayout_VALUE_UWORD
		32767
		ffvohed_uoEmjkd_dCoeDrc_f___20a
		-32767.
		0.
    DISPLAY_IDENTIFIER Cxx_vnt_ctl_slop_neg 
    FORMAT "%8.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ctl_slop_pos
		"Maximum positive slope for the vnt control value pwm"
		VALUE
		0x8005d7e4
		RSA_RecordLayout_VALUE_UWORD
		32767
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		0.
		32767.
    DISPLAY_IDENTIFIER Cxx_vnt_ctl_slop_pos 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_diag_pwm_max
		"Maximum pwm value for vnt in diagnostic module"
		VALUE
		0x80043382
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_diag_pwm_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_diag_pwm_min
		"Minimal pwm value for vnt in diagnostic module"
		VALUE
		0x80043380
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_diag_pwm_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_emtv_clos_psn
		"EMTV position threshold to detect closed position to force i init of vnt reg"
		VALUE
		0x8005ece2
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_vnt_emtv_clos_psn 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_emtv_open_t
		"Delay of EMTV closing to initialize i part of vnt regulation"
		VALUE
		0x8005ece0
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vnt_emtv_open_t 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ena_ol
		"Calibration to enable pit controller open loop (slow loop - CRAFT)."
		VALUE
		0x8005ecde
		RSA_RecordLayout_VALUE_UWORD
		256
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		256.
    DISPLAY_IDENTIFIER Cxx_vnt_ena_ol 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_err_drv_max
		"Maximum reduced derivative  error"
		VALUE
		0x8005ecdc
		RSA_RecordLayout_VALUE_SWORD
		2
		lasreaa_cardnzb_hCDtpsa_n__a00a
		-1.
		1.
    DISPLAY_IDENTIFIER Cxx_vnt_err_drv_max 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ex_i_ini
		"Initial value of the I part  in the exhaut pressure limitation mode"
		VALUE
		0x8005d084
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_ex_i_ini 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ex_i_win_neg
		"Value of definition of the negative window for I part in the exhaust pressure limitation mode"
		VALUE
		0x8005d082
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_vnt_ex_i_win_neg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ex_i_win_pos
		"Value of definition of the positive window for I part in the exhaust pressure limitation mode"
		VALUE
		0x8005d080
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_vnt_ex_i_win_pos 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ex_lim_tia_cold_cut_dly
		"Delay calibration of turn off delay bloc used for Tia cold shut-off"
		VALUE
		0x8004337e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_vnt_ex_lim_tia_cold_cut_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ex_reg_dfz_fmt
		"Formatting factor for the output of the fuzzy governor in exhaust limitation mode"
		VALUE
		0x8005d07e
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_ex_reg_dfz_fmt 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ex_reg_dfz_max
		"Maximum output of fuzzy governor in exhaust limitation mode"
		VALUE
		0x8005d07c
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_ex_reg_dfz_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ex_reg_dfz_min
		"Minimum output of fuzzy governor  in exhaust limitation mode"
		VALUE
		0x8005d07a
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_ex_reg_dfz_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ex_reg_err_drv_red
		"Reduction factor for the derivative error in exhaust limitation mode"
		VALUE
		0x8005d078
		RSA_RecordLayout_VALUE_UWORD
		99998
		uxdoaqa_BznFwjc_okphcBc_hp__00a
		2.
		100000.
    DISPLAY_IDENTIFIER Cxx_vnt_ex_reg_err_drv_red 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_ex_reg_err_red
		"Reduction factor for the governor error in exhaust limitation mode"
		VALUE
		0x8005d076
		RSA_RecordLayout_VALUE_UWORD
		99998
		bCyeoab_zijwjxc_htqocrc_h___o0a
		2.
		100000.
    DISPLAY_IDENTIFIER Cxx_vnt_ex_reg_err_red 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_lih_slop_neg
		"Maximum negative slope for pwm"
		VALUE
		0x8004337c
		RSA_RecordLayout_VALUE_UWORD
		32767
		ffvohed_uoEmjkd_dCoeDrc_f___20a
		-32767.
		0.
    DISPLAY_IDENTIFIER Cxx_vnt_lih_slop_neg 
    FORMAT "%8.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_lih_slop_pos
		"Maximum positive slope for pwm"
		VALUE
		0x8004337a
		RSA_RecordLayout_VALUE_UWORD
		32767
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		0.
		32767.
    DISPLAY_IDENTIFIER Cxx_vnt_lih_slop_pos 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_mnl_pwm
		"Manual pwm VNT"
		VALUE
		0x80043378
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_mnl_pwm 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_moni_neg_dif_set_dly
		"Time delay for negative deviation set during monitool activation"
		VALUE
		0x80043376
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vnt_moni_neg_dif_set_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_moni_spg_neg_dif_thd
		"Negative VNT governor deviation threshold during monitool activation"
		VALUE
		0x80043374
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_vnt_moni_spg_neg_dif_thd 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_moni_spg_neg_lim_dly
		"Time threshold of turn on delay for boost pressure monitoring during monitool mode"
		VALUE
		0x80043372
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vnt_moni_spg_neg_lim_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_moni_spg_sp_neg_lim
		"Max limitation of boost pressure value during monitool mode"
		VALUE
		0x80043370
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_vnt_moni_spg_sp_neg_lim 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_pwm_i_rst_hys_h
		"High pwm hysteresis threshold to reset the I term of governor (relative to Cmp_vnt_pwm_i_rst)"
		VALUE
		0x8005ecda
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_pwm_i_rst_hys_h 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_dfz_fmt
		"Formatting factor for the output of the fuzzy governor"
		VALUE
		0x8005d074
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_dfz_fmt 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_dfz_max
		"Maximum output of fuzzy governor"
		VALUE
		0x8005d072
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_dfz_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_dfz_min
		"Minimum output of fuzzy governor"
		VALUE
		0x8005d070
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_dfz_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_err_drv_red
		"Reduction factor for the derivative error"
		VALUE
		0x8005d06e
		RSA_RecordLayout_VALUE_UWORD
		99998
		uxdoaqa_BznFwjc_okphcBc_hp__00a
		2.
		100000.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_err_drv_red 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_err_red
		"Reduction factor for the governor error"
		VALUE
		0x8005d06c
		RSA_RecordLayout_VALUE_UWORD
		99998
		bCyeoab_zijwjxc_htqocrc_h___o0a
		2.
		100000.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_err_red 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_ex_err_min
		"Minimum echaust pressure governor error to take into account in the diagnostic criteria"
		VALUE
		0x8005d026
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_ex_err_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_ex_prs_err_dt1
		"Memory factor of the D part for exhaust pressure error used by fuzzy governor"
		VALUE
		0x8004347a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_vnt_reg_ex_prs_err_dt1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_i_ini
		"Initial value of the I part"
		VALUE
		0x8005d06a
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_i_ini 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_i_ini_egr_cut
		"Specific initilal value of the vnt regulator i part in case of emtv closure"
		VALUE
		0x8005ecd8
		RSA_RecordLayout_VALUE_SWORD
		400
		iCuEfea_DmeBtvd_oAbwmgc_f_99300
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_i_ini_egr_cut 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_i_rst_emtv_thd
		"VNT regulation integral part threshold to force initialisation in case of EGR closing"
		VALUE
		0x8005ecd6
		RSA_RecordLayout_VALUE_SWORD
		400
		iCuEfea_DmeBtvd_oAbwmgc_f_99300
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_i_rst_emtv_thd 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_spg_err_dt1
		"Memory factor of the D part for boost pressure error used by fuzzy governor"
		VALUE
		0x80043478
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_vnt_reg_spg_err_dt1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_reg_spg_err_min
		"Minimum boost air pressure governor error to take into account in the diagnostic criteria"
		VALUE
		0x8005d024
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_vnt_reg_spg_err_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_sge_pwm_pr
		"Anti_surge vnt pwm command during pr mode"
		VALUE
		0x8005d268
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_sge_pwm_pr 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_sge_pwm_rij
		"Anti_surge vnt pwm command during rij mode"
		VALUE
		0x8005d526
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_sge_pwm_rij 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_tia_cold_h_ex_lim_ena
		"Tia high threshold to activate Tia cold shut-off"
		VALUE
		0x8004336e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_tia_cold_h_ex_lim_ena 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_tia_cold_l_ex_lim_ena
		"Tia low threshold to activate Tia cold shut-off"
		VALUE
		0x8004336c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_tia_cold_l_ex_lim_ena 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_tran_pwm_max
		"Maximum pwm value for transient module"
		VALUE
		0x800434c0
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_tran_pwm_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_tran_pwm_min
		"Minimum value for transient module"
		VALUE
		0x800434be
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_vnt_tran_pwm_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_tran_pwm_slop_neg
		"Negative slop of transient pwm command slope switch"
		VALUE
		0x8005d05c
		RSA_RecordLayout_VALUE_UWORD
		32767
		ffvohed_uoEmjkd_dCoeDrc_f___20a
		-32767.
		0.
    DISPLAY_IDENTIFIER Cxx_vnt_tran_pwm_slop_neg 
    FORMAT "%8.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_tran_pwm_slop_pos
		"Positive slop of transient pwm command slope switch"
		VALUE
		0x8005d05a
		RSA_RecordLayout_VALUE_UWORD
		32767
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		0.
		32767.
    DISPLAY_IDENTIFIER Cxx_vnt_tran_pwm_slop_pos 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_n_thd_1_pr
		"Engine speed threshold 1 in pft regeneration mode."
		VALUE
		0x8005ea3a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_vnt_zon_n_thd_1_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_n_thd_1_rij
		"Engine speed threshold 1 in regular injection mode"
		VALUE
		0x8005eb8c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_vnt_zon_n_thd_1_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_n_thd_2_pr
		"Engine speed threshold 2 in pft regeneration mode."
		VALUE
		0x8005ea38
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_vnt_zon_n_thd_2_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_n_thd_2_rij
		"Engine speed threshold 2 in regular injection mode"
		VALUE
		0x8005eb8a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_vnt_zon_n_thd_2_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_n_thd_3_pr
		"Engine speed threshold 3 in pft regeneration mode."
		VALUE
		0x8005ea36
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_vnt_zon_n_thd_3_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_n_thd_3_rij
		"Engine speed threshold 3  in regular injection mode"
		VALUE
		0x8005eb88
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_vnt_zon_n_thd_3_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_tqi_thd_2_pr
		"Torque threshold 2 in pft regeneration mode."
		VALUE
		0x8005ea34
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_vnt_zon_tqi_thd_2_pr 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_tqi_thd_2_rij
		"Torque threshold 2 in regular injection mode"
		VALUE
		0x8005eb86
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_vnt_zon_tqi_thd_2_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_tqi_thd_3_pr
		"Torque threshold 3 in pft regeneration mode."
		VALUE
		0x8005ea32
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_vnt_zon_tqi_thd_3_pr 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vnt_zon_tqi_thd_3_rij
		"Torque threshold 3  in regular injection mode"
		VALUE
		0x8005eb84
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_vnt_zon_tqi_thd_3_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_ac_clu_dsb_thd
		"Minimum vehicule speed to authorize AC compressor clutching"
		VALUE
		0x8005ced2
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_vs_ac_clu_dsb_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_clos_spt_lamp_off_thd
		"Difference between vehicle speed and requested speed to turn OFF the lamp indicating that vehicle speed is reaching the setpoint."
		VALUE
		0x800401b5
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		bAngAbd_ajxybma_vfjmdrc_m___00a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_vs_clos_spt_lamp_off_thd 
    FORMAT "%3.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_clos_spt_lamp_off_thd_mph
		"Difference between vehicle speed and requested speed to turn OFF the lamp indicating that vehicle speed is reaching the setpoint  in mph."
		VALUE
		0x800401b4
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		bAngAbd_ajxybma_vfjmdrc_m___00a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_vs_clos_spt_lamp_off_thd_mph 
    FORMAT "%3.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_clos_spt_lamp_on_thd
		"Difference between vehicle speed and requested speed to turn ON the lamp indicating that vehicle speed is reaching the setpoint."
		VALUE
		0x800401b3
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		bAngAbd_ajxybma_vfjmdrc_m___00a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_vs_clos_spt_lamp_on_thd 
    FORMAT "%3.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_clos_spt_lamp_on_thd_mph
		"Difference between vehicle speed and requested speed to turn ON the lamp indicating that vehicle speed is reaching the setpoint  in mph."
		VALUE
		0x800401b2
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		bAngAbd_ajxybma_vfjmdrc_m___00a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_vs_clos_spt_lamp_on_thd_mph 
    FORMAT "%3.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_eco_xurb_thd
		"Cxx_vs_eco_xurb_thd"
		VALUE
		0x8005975c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_max
		"Calibration value for maximum vehicle speed allowed"
		VALUE
		0x800578d8
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vs_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_min
		"Calibration value for minimum vehicle speed allowed"
		VALUE
		0x800578d6
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vs_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_n_rat_ant_gear_ftc1
		"First time constant of second order numeric filter of ratio V/N for Ant Gear detection"
		VALUE
		0x8006b243
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_vs_n_rat_ant_gear_ftc1 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_n_rat_ant_gear_ftc2
		"Second time constant of second order numeric filter of ratio V/N for Ant Gear detection"
		VALUE
		0x8006b242
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_vs_n_rat_ant_gear_ftc2 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_n_rat_dft_max
		"Max value of V/Neng ratio."
		VALUE
		0x80058848
		RSA_RecordLayout_VALUE_SWORD
		210
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		-10.
		200.
    DISPLAY_IDENTIFIER Cxx_vs_n_rat_dft_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_n_rat_dft_min
		"Default value of V/Neng ratio if calculation of real value can't be done."
		VALUE
		0x80058846
		RSA_RecordLayout_VALUE_SWORD
		210
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		-10.
		200.
    DISPLAY_IDENTIFIER Cxx_vs_n_rat_dft_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_n_rat_fil_fac1
		"First time constant of second order numeric filter of ratio V/N"
		VALUE
		0x80058845
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_vs_n_rat_fil_fac1 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_n_rat_fil_fac2
		"Second time constant of second order numeric filter of ratio V/N"
		VALUE
		0x80058844
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_vs_n_rat_fil_fac2 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_n_rat_min_n_bkp
		"Minimal engine speed that enables Vehicle_speed/Engine_speed ratio calculation"
		VALUE
		0x80058842
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_vs_n_rat_min_n_bkp 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_thd_h
		"Higher threshold calibration for air cor temp correction"
		VALUE
		0x800578c2
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vs_thd_h 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_thd_l
		"Lower threshold calibration for air cor temp correction"
		VALUE
		0x800578c0
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vs_thd_l 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_thd_med
		"Medium threshold calibration for air cor temp correction"
		VALUE
		0x800578be
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vs_thd_med 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_thd_t
		"Time threshold calibration for air temperature correction"
		VALUE
		0x800578bc
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vs_thd_t 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_lacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_tkof_thd
		"a_in_vfi_vsi_lacelmd_xxxx_xx_x_a/Take off vehicle speed value"
		VALUE
		0x8006b34e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_vs_tkof_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_vh_max
		"Maximum vehicle speed to enable the detection of a foot on clutch pedal"
		VALUE
		0x8005885e
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_vs_vh_max 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_vh_min
		"Minimum vehicle speed to enable the detection of a foot on clutch pedal"
		VALUE
		0x8005885d
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_vs_vh_min 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_vs_xurb_eco_thd
		"Cxx_vs_xurb_eco_thd"
		VALUE
		0x8005975a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		VA_F_0v01_p0_10
		0
		655.35
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wait_sta_fail_dly
		"Duration in stopped engine state before making a starter stop request"
		VALUE
		0x8005ceec
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_wait_sta_fail_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wait_tra_acel_vld
		"Temporization before to calculate the validity of the transverse acceleration"
		VALUE
		0x80058ab2
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_wait_tra_acel_vld 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_mngtxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wf_ac_req_dly
		"Delay to filter a wire AC clutching request"
		VALUE
		0x80058a88
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_wf_ac_req_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_mngtxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wf_ac_req_dsb_dly
		"Delay to filter a wire AC clutching request inhibition"
		VALUE
		0x80058a86
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_wf_ac_req_dsb_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wf_bgin_clu_rams_dly
		"Delay to confirm activated clutch for safety needs"
		VALUE
		0x80059132
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_wf_bgin_clu_rams_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wf_brk_rams_dly
		"Delay to confirm activated brake for safety needs"
		VALUE
		0x80059130
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_wf_brk_rams_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_whl_rad
		"Cxx_whl_rad"
		VALUE
		0x800597c0
		RSA_RecordLayout_VALUE_UBYTE
		0.25
		VA_F_0v001_p0v2_8
		0.2
		0.45
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wpmp_tcr_max_t
		"Max duration of pump command"
		VALUE
		0x800590de
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_wpmp_tcr_max_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wpmp_tcr_max_tco_t
		"Max duration of water cooling monitoring"
		VALUE
		0x800590dc
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_wpmp_tcr_max_tco_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wpmp_tcr_tco_hys
		"hysteresis for water temperarute monitoring"
		VALUE
		0x800590da
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_wpmp_tcr_tco_hys 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wpmp_tcr_tco_thd
		"Water temperarute threshold monitoring"
		VALUE
		0x800590d8
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_wpmp_tcr_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wup_cata_dly
		"Cxx_wup_cata_dly"
		VALUE
		0x80059758
		RSA_RecordLayout_VALUE_UWORD
		65535
		VA_F_1_p0_18
		0
		65535
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wup_dif_thd_tco
		"Minimum engine coolant temperature rising required to validate a warm-up cycle"
		VALUE
		0x80055c22
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_wup_dif_thd_tco 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_wup_pft_utp_thd
		"CSF up temp threshold for DOC warmup ending"
		VALUE
		0x80045866
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_wup_pft_utp_thd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_wup_thd_tco
		"Minimum engine coolant temperature required to validate a warm up cycle"
		VALUE
		0x80055c20
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_wup_thd_tco 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ntx_data_avl_list[0]
		"List of supported extended data number"
		VALUE
		0x8006b206
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		128.
		135.
    DISPLAY_IDENTIFIER Ntx_data_avl_list[0] 
    FORMAT "%3.0" 
    READ_ONLY 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ntx_data_avl_list[1]
		"List of supported extended data number"
		VALUE
		0x8006b207
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		128.
		135.
    DISPLAY_IDENTIFIER Ntx_data_avl_list[1] 
    FORMAT "%3.0" 
    READ_ONLY 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ntx_data_avl_list[2]
		"List of supported extended data number"
		VALUE
		0x8006b208
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		128.
		135.
    DISPLAY_IDENTIFIER Ntx_data_avl_list[2] 
    FORMAT "%3.0" 
    READ_ONLY 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ntx_data_avl_list[3]
		"List of supported extended data number"
		VALUE
		0x8006b209
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		128.
		135.
    DISPLAY_IDENTIFIER Ntx_data_avl_list[3] 
    FORMAT "%3.0" 
    READ_ONLY 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ntx_data_avl_list[4]
		"List of supported extended data number"
		VALUE
		0x8006b20a
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		128.
		135.
    DISPLAY_IDENTIFIER Ntx_data_avl_list[4] 
    FORMAT "%3.0" 
    READ_ONLY 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ntx_frm_avl_list[0]
		"List of supported snapshot number"
		VALUE
		0x8006b202
		RSA_RecordLayout_VALUE_UBYTE
		3
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		4.
    DISPLAY_IDENTIFIER Ntx_frm_avl_list[0] 
    FORMAT "%3.0" 
    READ_ONLY 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ntx_frm_avl_list[1]
		"List of supported snapshot number"
		VALUE
		0x8006b203
		RSA_RecordLayout_VALUE_UBYTE
		3
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		4.
    DISPLAY_IDENTIFIER Ntx_frm_avl_list[1] 
    FORMAT "%3.0" 
    READ_ONLY 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ntx_frm_avl_list[2]
		"List of supported snapshot number"
		VALUE
		0x8006b204
		RSA_RecordLayout_VALUE_UBYTE
		3
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		4.
    DISPLAY_IDENTIFIER Ntx_frm_avl_list[2] 
    FORMAT "%3.0" 
    READ_ONLY 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ntx_frm_avl_list[3]
		"List of supported snapshot number"
		VALUE
		0x8006b205
		RSA_RecordLayout_VALUE_UBYTE
		3
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		4.
    DISPLAY_IDENTIFIER Ntx_frm_avl_list[3] 
    FORMAT "%3.0" 
    READ_ONLY 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c9c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ac_prs[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c9e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ac_prs[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056ca0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ac_prs[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056ca2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ac_prs[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056ca4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ac_prs[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ac_prs.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056ca6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ac_prs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c90
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c92
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c94
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c96
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c98
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c9a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_acel_pdl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c84
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v1[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c86
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v1[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c88
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v1[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c8a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v1[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c8c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v1[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v1.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c8e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_acel_pdl_v1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c78
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v2[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c7a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v2[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c7c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v2[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c7e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v2[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c80
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_acel_pdl_v2[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_acel_pdl_v2.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c82
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_acel_pdl_v2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c6c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_actr_rly[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c6e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_actr_rly[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c70
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_actr_rly[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c72
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_actr_rly[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c74
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_actr_rly[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_actr_rly.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c76
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_actr_rly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c54
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c56
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c58
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c5a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c5c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c5e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_agb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c60
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb_data[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c62
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb_data[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c64
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb_data[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c66
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb_data[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c68
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_agb_data[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_agb_data.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c6a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_agb_data 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056888
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_amp_reg[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005688a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_amp_reg[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x8005688c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_amp_reg[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005688e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_amp_reg[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056890
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_amp_reg[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_amp_reg.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056892
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_amp_reg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a08
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_bgin_clu[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a0a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_bgin_clu[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a0c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_bgin_clu[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a0e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_bgin_clu[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a10
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_bgin_clu[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_bgin_clu.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a12
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_bgin_clu 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800569fc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_brk_pdl[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800569fe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_brk_pdl[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a00
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_brk_pdl[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a02
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_brk_pdl[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a04
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_brk_pdl[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_brk_pdl.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a06
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_brk_pdl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c48
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cata[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c4a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cata[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c4c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cata[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c4e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cata[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c50
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cata[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cata.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c52
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_cata 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c3c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_clu_cnt[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c3e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_clu_cnt[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c40
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_clu_cnt[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c42
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_clu_cnt[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c44
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_clu_cnt[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_clu_cnt.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c46
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_clu_cnt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x8005690c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_crk[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005690e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_crk[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056910
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_crk[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056912
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_crk[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056914
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_crk[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_crk.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056916
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_crk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800569f0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800569f2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800569f4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800569f6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800569f8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800569fa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_cru 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800569d8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800569da
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800569dc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800569de
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800569e0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800569e2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_cru_sl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800569e4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl_swi[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800569e6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl_swi[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800569e8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl_swi[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800569ea
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl_swi[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800569ec
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_sl_swi[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_sl_swi.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800569ee
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_cru_sl_swi 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800569cc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_vs[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800569ce
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_vs[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800569d0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_vs[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800569d2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_vs[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800569d4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_vs[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_vs.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800569d6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_cru_vs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800569c0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_whl_cmd[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800569c2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_whl_cmd[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800569c4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_whl_cmd[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800569c6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_whl_cmd[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800569c8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_cru_whl_cmd[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_cru_whl_cmd.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800569ca
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_cru_whl_cmd 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c30
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_doc1_utp[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c32
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_doc1_utp[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c34
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_doc1_utp[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c36
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_doc1_utp[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c38
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_doc1_utp[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_doc1_utp.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c3a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_doc1_utp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800568d0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_err[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800568d2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_err[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800568d4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_err[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800568d6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_err[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800568d8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_err[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_err.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800568da
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ecm_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056894
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_inj[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056896
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_inj[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056898
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_inj[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005689a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_inj[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x8005689c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_inj[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_inj.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005689e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ecm_inj 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800568c4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_mon[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800568c6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_mon[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800568c8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_mon[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800568ca
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_mon[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800568cc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ecm_mon[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ecm_mon.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800568ce
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ecm_mon 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c24
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_inj[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c26
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_inj[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c28
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_inj[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c2a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_inj[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c2c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_inj[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_inj.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c2e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_efi_inj 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800569b4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_sldv[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800569b6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_sldv[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800569b8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_sldv[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800569ba
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_sldv[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800569bc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_efi_sldv[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_efi_sldv.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800569be
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_efi_sldv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c18
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_egr_byp[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c1a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_egr_byp[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c1c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_egr_byp[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c1e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_egr_byp[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c20
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_egr_byp[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_egr_byp.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c22
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_egr_byp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c0c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_flow[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c0e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_flow[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c10
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_flow[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c12
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_flow[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c14
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_flow[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_flow.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c16
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_emtv_flow 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056c00
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_hbdg[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056c02
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_hbdg[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056c04
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_hbdg[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056c06
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_hbdg[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056c08
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_hbdg[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_hbdg.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056c0a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_emtv_hbdg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056bf4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_ofs[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056bf6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_ofs[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056bf8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_ofs[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056bfa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_ofs[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056bfc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_ofs[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_ofs.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056bfe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_emtv_ofs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056be8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_reg[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056bea
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_reg[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056bec
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_reg[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056bee
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_reg[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056bf0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_emtv_reg[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_emtv_reg.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056bf2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_emtv_reg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056bd0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056bd2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056bd4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056bd6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056bd8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056bda
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_esp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056bdc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp_data[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056bde
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp_data[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056be0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp_data[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056be2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp_data[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056be4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_esp_data[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_esp_data.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056be6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_esp_data 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056bc4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ex_prs[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056bc6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ex_prs[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056bc8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ex_prs[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056bca
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ex_prs[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056bcc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ex_prs[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ex_prs.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056bce
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ex_prs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800569a8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_actr[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800569aa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_actr[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800569ac
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_actr[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800569ae
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_actr[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800569b0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_actr[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_actr.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800569b2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ff_actr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x8005699c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_fct[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005699e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_fct[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800569a0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_fct[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800569a2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_fct[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800569a4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ff_fct[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ff_fct.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800569a6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ff_fct 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056990
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_actr[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056992
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_actr[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056994
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_actr[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056996
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_actr[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056998
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_actr[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_actr.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005699a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_fprs_actr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056984
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_fct[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056986
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_fct[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056988
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_fct[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005698a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_fct[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x8005698c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fprs_fct[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fprs_fct.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005698e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_fprs_fct 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056978
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fsys[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005697a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fsys[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x8005697c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fsys[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005697e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fsys[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056980
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fsys[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fsys.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056982
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_fsys 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a20
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fuel_temp[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a22
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fuel_temp[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a24
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fuel_temp[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a26
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fuel_temp[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a28
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_fuel_temp[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_fuel_temp.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a2a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_fuel_temp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056bb8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_glow_cmd[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056bba
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_glow_cmd[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056bbc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_glow_cmd[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056bbe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_glow_cmd[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056bc0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_glow_cmd[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_glow_cmd.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056bc2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_glow_cmd 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056900
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056902
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056904
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056906
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056908
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005690a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_in_cam 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056804
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam_crk[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056806
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam_crk[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056808
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam_crk[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005680a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam_crk[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x8005680c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_in_cam_crk[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_in_cam_crk.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005680e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_in_cam_crk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800568a0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800568a2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800568a4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800568a6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800568a8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800568aa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_inj 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056bac
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj1[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056bae
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj1[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056bb0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj1[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056bb2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj1[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056bb4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj1[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj1.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056bb6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_inj1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056ba0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj2[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056ba2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj2[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056ba4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj2[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056ba6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj2[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056ba8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj2[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj2.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056baa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_inj2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b94
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj3[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b96
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj3[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b98
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj3[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b9a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj3[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b9c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj3[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj3.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b9e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_inj3 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b88
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj4[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b8a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj4[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b8c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj4[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b8e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj4[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b90
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_inj4[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
