		"Manual interpolation factor between pedal progressivity maps (for tuning purposes)"
		VALUE
		0x80059c2b
		RSA_RecordLayout_VALUE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_fmt_mnl_fac 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_fmt_rvr_fac
		"Pedal progressivity correction factor for reverse gear"
		VALUE
		0x80059c2a
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_acel_pdl_fmt_rvr_fac 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_grd_abs_fil_fac
		"Pedal gradient absolute value first order filter time constant (signal processing filtering)"
		VALUE
		0x80059192
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_acel_pdl_grd_abs_fil_fac 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_kd_hys
		"Uref ratio hysteresis linked with kick-down flag"
		VALUE
		0x8005878c
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_kd_hys 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_kd_in_thd_nok
		"Uref ratio entry threshold to activate kick-down flag if failure on track 1 and no failure on track 2"
		VALUE
		0x8005878a
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_kd_in_thd_nok 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_kd_in_thd_ok
		"Uref ratio entry threshold to activate kick-down flag when pedal sensor is in nominal operation (track 1)"
		VALUE
		0x80058788
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_kd_in_thd_ok 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_hys_n_l
		"Difference of engine speed for the hysteresis on max admissible engine speed in pedal limp home"
		VALUE
		0x80059d26
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_hys_n_l 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_hys_vs_h
		"High vehicle speed threshold for the hysteresis on the regulators switch in pedal limp home"
		VALUE
		0x80059d25
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_hys_vs_h 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_hys_vs_l
		"Low vehicle speed threshold for the hysteresis on the regulators switch in pedal limp home"
		VALUE
		0x80059d24
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_hys_vs_l 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_max_vs
		"Maximum vehicle speed allowed in pedal limp home"
		VALUE
		0x80059d23
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_max_vs 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_min_l
		"Decreasing slope during the application of the foot-up accelerator pedal"
		VALUE
		0x80059d22
		RSA_RecordLayout_VALUE_UBYTE
		1
		pEmaegc_clacCDa_mtFteua_roCRa0a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_min_l 
    FORMAT "%12.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_n_ig
		"Integrate factor of pedal limp home engine speed regulator"
		VALUE
		0x80059d21
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_n_ig 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_n_pg
		"Proportional factor of pedal limp home engine speed regulator"
		VALUE
		0x80059d20
		RSA_RecordLayout_VALUE_UBYTE
		1
		saAcdba_dmCvrqc_nuuwjCd_Np__2a0
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_n_pg 
    FORMAT "%8.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_n_sp_bpk_on
		"Pedal limp home engine speed setpoint if brake parking is applied"
		VALUE
		0x80059d1e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_n_sp_bpk_on 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_n_sp_srs
		"Pedal limp home engine speed setpoint if vehicle speed failure (safety setpoint)"
		VALUE
		0x80059d1c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_n_sp_srs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_n_tqe_h
		"Maximum torque setpoint allowed for the pedal limp home engine speed regulator"
		VALUE
		0x80059d1a
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_n_tqe_h 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_slop_h1
		"Slope for the low vehicle speed and for the increasing vehicle speed setpoint in pedal limp home"
		VALUE
		0x80059d18
		RSA_RecordLayout_VALUE_UBYTE
		255
		jBfcoed_dgfcpFd_nsxxcxb_khCRa0a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_slop_h1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_slop_h2
		"Slope for the high vehicle speed and for the increasing vehicle speed setpoint in pedal limp home"
		VALUE
		0x80059d17
		RSA_RecordLayout_VALUE_UBYTE
		255
		jBfcoed_dgfcpFd_nsxxcxb_khCRa0a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_slop_h2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_slop_n_h
		"Slope for the increasing engine speed setpoint in pedal limp home"
		VALUE
		0x80059d16
		RSA_RecordLayout_VALUE_UBYTE
		25500
		bCvqxab_BrEwowc_wubjDqc_rsA0ea0
		0.
		25500.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_slop_n_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_slop_vs
		"Vehicle speed threshold for the change of the vehicle speed setpoint slope"
		VALUE
		0x80059d15
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_slop_vs 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_sub_v
		"Accelerator pedal voltage (safety replacement value) if accelerator pedal limp home actived"
		VALUE
		0x800587b6
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_sub_v 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_vs_ig
		"Integrate factor of pedal limp home vehicle speed regulator"
		VALUE
		0x80059d14
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_vs_ig 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_vs_pg
		"Proportional factor of pedal limp home vehicle speed regulator"
		VALUE
		0x80059d12
		RSA_RecordLayout_VALUE_UWORD
		24.902343
		hlmzaia_FvatkBa_FEDjhpa_NhR055o
		0.
		24.902343
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_vs_pg 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_vs_rvr
		"Pedal limp home vehicle speed setpoint in reverse gear"
		VALUE
		0x80059d11
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_vs_rvr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_vs_sp
		"Pedal limp home vehicle speed setpoint"
		VALUE
		0x80059d10
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_vs_sp 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lih_vs_tqe_h
		"Maximum torque setpoint allowed for the pedal limp home vehicle speed regulator"
		VALUE
		0x80059d0e
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lih_vs_tqe_h 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_lvl_tqe_thd
		"Imposed torque setpoint to help to the calibration of the accelerator pedal limp home regulators"
		VALUE
		0x80059d0c
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_acel_pdl_lvl_tqe_thd 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcaplou_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_rat_secu_1_val
		"Value sent on CAN during detected failure of accelerator pedal safety case N°1 (reversible)"
		VALUE
		0x8006b1fc
		RSA_RecordLayout_VALUE_UWORD
		1.25
		omqfgpc_fbAwBcc_yctdhkb_f_Ra0oa
		0.
		1.25
    DISPLAY_IDENTIFIER Cxx_acel_pdl_rat_secu_1_val 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_2_inc_1
		"Accelerator pedal safety case N°2 counter increment (when diagnosis is not confirmed)"
		VALUE
		0x800587f2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_2_inc_1 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_2_inc_2
		"Accelerator pedal safety case N°2 counter increment (when diagnosis is confirmed)"
		VALUE
		0x800587f0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_2_inc_2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_2_thd
		"Pedal threshold to allow the healing of accelerator pedal safety case N°2"
		VALUE
		0x800587ee
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_2_thd 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_2_vs_thd
		"Vehicle speed threshold to allow the healing of accelerator pedal safety case N°2"
		VALUE
		0x800587ec
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_2_vs_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_dly1
		"Tempo 1 (before breaking) to validate the conditions of accelerator pedal safety case"
		VALUE
		0x800587ea
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_dly1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_dly2
		"Tempo 2 (after breaking) to detect the failure of accelerator pedal safety case N°1"
		VALUE
		0x800587e8
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_dly2 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_flu_thd
		"Pedal variation threshold to allowthe detection of accelerator pedal safety case"
		VALUE
		0x800587e6
		RSA_RecordLayout_VALUE_UWORD
		1
		kDBlDjc_fldogca_dCfnthc_f__020a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_flu_thd 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_n_thd
		"Engine speed threshold to allow the detection of accelerator pedal safety case"
		VALUE
		0x800587e4
		RSA_RecordLayout_VALUE_UBYTE
		8160
		BFEumua_fgyxxpd_AuvxBuc_rC_3e20
		0.
		8160.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_n_thd 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_thd
		"Pedal threshold to allow the detection of accelerator pedal safety case"
		VALUE
		0x800587e2
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_thd 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_secu_vs_thd
		"Pedal threshold to allow the detection of accelerator pedal safety case"
		VALUE
		0x800587e0
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_secu_vs_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_sens_pws
		"Accelerator pedal sensor power supply"
		VALUE
		0x8006b22e
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_sens_pws 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_stab_thd
		"Accelerator pedal signal stabilization threshold"
		VALUE
		0x8006b22c
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_stab_thd 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_trs_slop_neg
		"Pedal slope during the decreasing transitions : normal mode <=> accelerator pedal limp home"
		VALUE
		0x80059d0a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pEmaegc_clacCDa_mtFteua_roCRa0a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_trs_slop_neg 
    FORMAT "%12.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_trs_slop_pos
		"Pedal slope during the increasing transitions : normal mode <=> accelerator pedal limp home"
		VALUE
		0x80059d09
		RSA_RecordLayout_VALUE_UBYTE
		1
		pEmaegc_clacCDa_mtFteua_roCRa0a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_trs_slop_pos 
    FORMAT "%12.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_v1_max_thd
		"Maximum threshold to detect high signal failure on accelerator pedal track 1"
		VALUE
		0x800587b4
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_v1_max_thd 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_v1_min_thd
		"Minimum threshold to detect high signal failure on accelerator pedal track 1"
		VALUE
		0x800587b2
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_v1_min_thd 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_v1_v2_fac
		"Accelerator pedal voltage (safety replacement value) if accelerator pedal limp home actived"
		VALUE
		0x800587b0
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_v1_v2_fac 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_v2_max_thd
		"Maximum threshold to detect high signal failure on accelerator pedal track 2"
		VALUE
		0x800587ae
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_v2_max_thd 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_v2_min_thd
		"Minimum threshold to detect high signal failure on accelerator pedal track 2"
		VALUE
		0x800587ac
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_v2_min_thd 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acr_eng_fac
		"Compressor driving ratio (on engine)"
		VALUE
		0x80058972
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_acr_eng_fac 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acs_amp_dft_val
		"Atmospheric pressure replacement value in case of invalid atmospheric pressure"
		VALUE
		0x8005cdac
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_acs_amp_dft_val 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acs_ena_dly
		"Minimum duration between accessories reactivations"
		VALUE
		0x8005cdaa
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_acs_ena_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_aftr_eng_sta_dly
		"After start delay for diagnosis enabled"
		VALUE
		0x80043c12
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_AtCatDgn_Time_1s
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_aftr_eng_sta_dly 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_aftr_long_idle_dly
		"Delay after long idle detection for offset learning"
		VALUE
		0x80043c10
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_AtCatDgn_Time_1s
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_aftr_long_idle_dly 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_aftr_long_idle_dly_ena
		"Delay after long idle detection for diagnosis enabled"
		VALUE
		0x80043c0e
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_AtCatDgn_Time_1s
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_aftr_long_idle_dly_ena 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_aftr_ofs_ad_dly
		"Delay after offset learning for diagnosis enabled"
		VALUE
		0x80043c0c
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_AtCatDgn_Time_1s
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_aftr_ofs_ad_dly 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_aftr_rgn_req_dly
		"delay after regeneration request to begin diagnosis"
		VALUE
		0x8004011e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_aftr_rgn_req_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_abst_dly
		"Maximum permitted time without frame, before fault detection"
		VALUE
		0x80058784
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_agb_abst_dly 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_abst_frm_dly
		"Automatic Gear Box Control Unit absence detection time-out"
		VALUE
		0x80055bdb
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_agb_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_clck_max_step
		"Maximum AGB clock step"
		VALUE
		0x80058782
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_agb_clck_max_step 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_ofs_slop_neg
		"Negative slope on torque offset to estimate the gearbox losses"
		VALUE
		0x80058618
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		baCmrya_mltpssd_Aavnptc_N__0o0a
		-12799.8046875
		0.
    DISPLAY_IDENTIFIER Cxx_agb_csm_ofs_slop_neg 
    FORMAT "%14.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_ofs_slop_neg_dft
		"Negative slope on torque offset to estimate the gearbox losses in degraded mode"
		VALUE
		0x80058616
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		baCmrya_mltpssd_Aavnptc_N__0o0a
		-12799.8046875
		0.
    DISPLAY_IDENTIFIER Cxx_agb_csm_ofs_slop_neg_dft 
    FORMAT "%14.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_ofs_slop_pos
		"Positive slope on torque offset to estimate the gearbox losses"
		VALUE
		0x80058614
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		0.
		12799.8046875
    DISPLAY_IDENTIFIER Cxx_agb_csm_ofs_slop_pos 
    FORMAT "%13.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_ofs_slop_pos_dft
		"Positive slope on torque offset to estimate the gearbox losses in degraded mode"
		VALUE
		0x80058612
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		0.
		12799.8046875
    DISPLAY_IDENTIFIER Cxx_agb_csm_ofs_slop_pos_dft 
    FORMAT "%13.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_ftc_fast
		"Fast filter factor to coupler torque losses in the neutral position or the drag reduction mode"
		VALUE
		0x80058611
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_ftc_fast 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_ftc_slow
		"Slow filter factor to coupler torque losses in the neutral position or the drag reduction mode"
		VALUE
		0x80058610
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_ftc_slow 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_ftc_vs_thd
		"Vehicle speed threshold to switch between a simple filter time or a depending on engine coolant temperature one"
		VALUE
		0x8005860e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_ftc_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_is_n_hys
		"Engine speed hysteresis on the threshold of the idle speed regulation zone"
		VALUE
		0x8005860c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_is_n_hys 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_is_n_thd
		"Engine speed threshold to bound the low zone and the high zone of idle speed regulation"
		VALUE
		0x8005860a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_is_n_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_neg
		"Negative slope on torque converter losses in the low zone of idle speed"
		VALUE
		0x80058608
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		baCmrya_mltpssd_Aavnptc_N__0o0a
		-12799.8046875
		0.
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_neg 
    FORMAT "%14.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_neg_1
		"Negative slope on torque converter losses in the high zone of idle speed"
		VALUE
		0x80058606
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		baCmrya_mltpssd_Aavnptc_N__0o0a
		-12799.8046875
		0.
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_neg_1 
    FORMAT "%14.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_neg_1_rvr
		"Negative slope on torque converter losses in the high zone of idle speed, (reserve gear)"
		VALUE
		0x80058604
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		baCmrya_mltpssd_Aavnptc_N__0o0a
		-12799.8046875
		0.
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_neg_1_rvr 
    FORMAT "%14.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_neg_2
		"Negative slope on torque converter losses in the zone out of idle speed"
		VALUE
		0x80058602
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		baCmrya_mltpssd_Aavnptc_N__0o0a
		-12799.8046875
		0.
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_neg_2 
    FORMAT "%14.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_neg_rvr
		"Negative slope on torque converter losses in the low zone of idle speed, (reserve gear)"
		VALUE
		0x80058600
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		baCmrya_mltpssd_Aavnptc_N__0o0a
		-12799.8046875
		0.
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_neg_rvr 
    FORMAT "%14.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_pos
		"Positive slope on torque converter losses in the low zone of idle speed"
		VALUE
		0x800585fe
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		0.
		12799.8046875
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_pos 
    FORMAT "%13.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_pos_1
		"Positive slope on torque converter losses in the high zone of idle speed"
		VALUE
		0x800585fc
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		0.
		12799.8046875
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_pos_1 
    FORMAT "%13.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_pos_1_rvr
		"Positive slope on torque converter losses in the high zone of idle speed, (reserve gear)"
		VALUE
		0x800585fa
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		0.
		12799.8046875
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_pos_1_rvr 
    FORMAT "%13.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_pos_2
		"Positive slope on torque converter losses in the zone out of idle speed"
		VALUE
		0x800585f8
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		0.
		12799.8046875
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_pos_2 
    FORMAT "%13.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_slop_pos_rvr
		"Positive slope on torque converter losses in the low zone of idle speed, (reserve gear)"
		VALUE
		0x800585f6
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		0.
		12799.8046875
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_slop_pos_rvr 
    FORMAT "%13.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_csm_tq_vs_thd
		"Vehicle speed threshold to authorize the egb torque correction"
		VALUE
		0x800585f4
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_agb_csm_tq_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_ctr_max_thd
		"Failure counter threshold. It authorize N successive failures before downgraded mode activation"
		VALUE
		0x80058781
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_agb_ctr_max_thd 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_ecu_conf
		"Automatic Gear Box Control Unit feature for Mux configuration detection (always present or optional)"
		VALUE
		0x80055bda
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_agb_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_int_rst_t
		"Time after we reset the integrator after a shift"
		VALUE
		0x80058780
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_agb_int_rst_t 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_max_tqe
		"Max value which can be set in CAN message list for torque"
		VALUE
		0x8005877e
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_agb_max_tqe 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_max_tqe_cor
		"Value of maximum torque allowed for AT torque converter"
		VALUE
		0x8005afec
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_agb_max_tqe_cor 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_atissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_min_is_n
		"Idle speed setpoint under request of the AT"
		VALUE
		0x8005ada4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_agb_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_min_tqe_fac
		"Factor which allows adapting the final level of AT converter torque, according to the engine speed."
		VALUE
		0x8005afea
		RSA_RecordLayout_VALUE_UBYTE
		3.984375
		ftmodod_Ffszhha_Fbvahrc_n_R0ooa
		0.
		3.984375
    DISPLAY_IDENTIFIER Cxx_agb_min_tqe_fac 
    FORMAT "%8.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_pwst_min_is_n
		"Power steering accelerated idle speed (EGB in drive mode)"
		VALUE
		0x8005ae6e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_agb_pwst_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_slwr_neg
		"Negative torque slew rate calibration in case of protocol error"
		VALUE
		0x8005877c
		RSA_RecordLayout_VALUE_UWORD
		10235
		BsxxCDd_fyuafxb_rkxlsta_NsA_00a
		-10235.
		0.
    DISPLAY_IDENTIFIER Cxx_agb_slwr_neg 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_slwr_pos
		"Positive torque slew rate calibration in case of protocol error"
		VALUE
		0x8005877a
		RSA_RecordLayout_VALUE_UWORD
		10235
		aainjEc_jgzdbtd_deplAyc_NsA_00a
		0.
		10235.
    DISPLAY_IDENTIFIER Cxx_agb_slwr_pos 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_tq_slop_drag_red_neg
		"Negative slope on torque converter losses in the drag reduction mode"
		VALUE
		0x800585f2
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		baCmrya_mltpssd_Aavnptc_N__0o0a
		-12799.8046875
		0.
    DISPLAY_IDENTIFIER Cxx_agb_tq_slop_drag_red_neg 
    FORMAT "%14.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_tq_slop_drag_red_pos
		"Positive slope on torque converter losses in the drag reduction mode"
		VALUE
		0x800585f0
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		0.
		12799.8046875
    DISPLAY_IDENTIFIER Cxx_agb_tq_slop_drag_red_pos 
    FORMAT "%13.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_tq_slop_dsb_neg
		"Negative slope to disable the Slew Rate on the AT_torque"
		VALUE
		0x800585ee
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		baCmrya_mltpssd_Aavnptc_N__0o0a
		-12799.8046875
		0.
    DISPLAY_IDENTIFIER Cxx_agb_tq_slop_dsb_neg 
    FORMAT "%14.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_tq_slop_dsb_pos
		"Positive slope to disable the Slew Rate on the AT_torque"
		VALUE
		0x800585ec
		RSA_RecordLayout_VALUE_UWORD
		12799.8046875
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		0.
		12799.8046875
    DISPLAY_IDENTIFIER Cxx_agb_tq_slop_dsb_pos 
    FORMAT "%13.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_vld_abst_frm_dec
		"Automatic Gear Box Control Unit : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bd9
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_agb_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_vld_abst_frm_inc
		"Automatic Gear Box Control Unit : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bd8
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_agb_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_agb_wind_min_is_n
		"Electric windshield idle speed setpoint calibration under drive mode of the AT"
		VALUE
		0x8005ae46
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_agb_wind_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_air_fil_fac
		"Value for pressure loss in the air filter"
		VALUE
		0x800578e6
		RSA_RecordLayout_VALUE_UWORD
		6000
		hmkxuhd_cvwcsja_vaFmhaa_PKEA_o0
		0.
		6000.
    DISPLAY_IDENTIFIER Cxx_air_fil_fac 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_air_temp_inf
		"Min value of air temperature during air mass flow sensor drift diagnosis"
		VALUE
		0x80057404
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_air_temp_inf 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_air_temp_sup
		"Max value of air temperature during air mass flow sensor drift diagnosis"
		VALUE
		0x80057402
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_air_temp_sup 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_acel_tq_thd
		"Torque variation threshold to consider the engine in acceleration state"
		VALUE
		0x8005a718
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_ajs_acel_tq_thd 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_dz_dly
		"Time delay of AJCOR dead zone"
		VALUE
		0x80040a18
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ajs_cor_dz_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_dz_dly_spc
		"Specific time delay of AJCOR dead zone"
		VALUE
		0x800410d0
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ajs_cor_dz_dly_spc 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_lim_tq_ofs
		"Torque offset added to the maximum dynamic torque autorized for AJCOR"
		VALUE
		0x800432fc
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ajs_cor_lim_tq_ofs 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_max_cor_dyn_dt_open
		"Maximum dynamic torque correction autorized for AJCOR when driveline is open"
		VALUE
		0x80040a16
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_ajs_cor_max_cor_dyn_dt_open 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_max_dyn_open_spc
		"Specific maximum dynamic torque correction autorized for AJCOR when driveline is open"
		VALUE
		0x800410ce
		RSA_RecordLayout_VALUE_SWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_ajs_cor_max_dyn_open_spc 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_min_cor_dyn_dt_open
		"Minimum dynamic torque correction autorized for AJCOR when driveline is opened"
		VALUE
		0x80040a14
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_ajs_cor_min_cor_dyn_dt_open 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_min_dyn_open_spc
		"Specific minimum dynamic torque correction autorized for AJCOR when driveline is open"
		VALUE
		0x800410cc
		RSA_RecordLayout_VALUE_SWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_ajs_cor_min_dyn_open_spc 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_t1_acel_dt_modu
		"AJCOR time constant value when driveline is in modulation mode for vehicle acceleration"
		VALUE
		0x80040a12
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_cor_t1_acel_dt_modu 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_t1_acel_dt_open
		"AJCOR time constant value when driveline is open for vehicle acceleration"
		VALUE
		0x80040a10
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_cor_t1_acel_dt_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_t1_decl_dt_modu
		"AJCOR time constant value when driveline is in modulation mode for vehicle deceleration"
		VALUE
		0x80040a0e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_cor_t1_decl_dt_modu 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_t1_decl_dt_open
		"AJCOR time constant value when driveline is open for vehicle deceleration"
		VALUE
		0x80040a0c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_cor_t1_decl_dt_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_t1_dt_ini
		"AJCOR time constant value during initialisation"
		VALUE
		0x80040a0a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_cor_t1_dt_ini 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_td_acel_dt_modu
		"AJCOR gain value when driveline is in modulation mode for vehicle acceleration (unit=(N.m/rpm)^(1/2)"
		VALUE
		0x80040a08
		RSA_RecordLayout_VALUE_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_cor_td_acel_dt_modu 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_td_acel_dt_open
		"AJCOR gain value when driveline is open for vehicle acceleration (unit=(N.m/rpm)^(1/2))"
		VALUE
		0x80040a06
		RSA_RecordLayout_VALUE_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_cor_td_acel_dt_open 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_td_decl_dt_modu
		"AJCOR gain value when driveline is in modulation for vehicle deceleration (unit=(N.m/rpm)^(1/2))"
		VALUE
		0x80040a04
		RSA_RecordLayout_VALUE_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_cor_td_decl_dt_modu 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_td_decl_dt_open
		"AJCOR gain value when driveline is open for vehicle deceleration (unit=(N.m/rpm)^(1/2))"
		VALUE
		0x80040a02
		RSA_RecordLayout_VALUE_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_cor_td_decl_dt_open 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_td_dt_ini
		"AJCOR gain value during initialisation (unit=(N.m/rpm)^(1/2))"
		VALUE
		0x80040a00
		RSA_RecordLayout_VALUE_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_cor_td_dt_ini 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_cor_tkof_vs_thd
		"Threshold of vehicle speed to activate the anti-jerk correction during take off"
		VALUE
		0x800409fe
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ajs_cor_tkof_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_decl_tq_thd
		"Torque variation threshold to consider the engine in deceleration state"
		VALUE
		0x8005a716
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_ajs_decl_tq_thd 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_drag_pwt_sp_thd
		"Threshold for powertrain setpoint to enable the drag error correction."
		VALUE
		0x8005a714
		RSA_RecordLayout_VALUE_UWORD
		1
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_drag_pwt_sp_thd 
    FORMAT "%8.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_drag_tq_drv_hys
		"Hysteresis for driver torque derivative threshold to disable the drag error correction."
		VALUE
		0x8005a713
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_drag_tq_drv_hys 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_drag_tq_drv_thd
		"Threshold for driver torque derivative to disable the drag error correction."
		VALUE
		0x8005a712
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_drag_tq_drv_thd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_driv_pwt_sp_fil
		"Filter time constant for filtering of the driver powertrain setpoint derivate"
		VALUE
		0x8005a710
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_driv_pwt_sp_fil 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_driv_pwt_sp_grd_hys
		"Driver powertrain setpoint derivative hysteresis used in antijerk strategy"
		VALUE
		0x8005a70e
		RSA_RecordLayout_VALUE_UWORD
		100
		pEmaegc_clacCDa_mtFteua_roCRa0a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_ajs_driv_pwt_sp_grd_hys 
    FORMAT "%8.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_driv_pwt_sp_grd_thd
		"Threshold for powertrain setpoint derivative to enable the boost of the curative anti-jerk function."
		VALUE
		0x8005a70c
		RSA_RecordLayout_VALUE_UWORD
		100
		pEmaegc_clacCDa_mtFteua_roCRa0a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_ajs_driv_pwt_sp_grd_thd 
    FORMAT "%8.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_driv_pwt_sp_thd
		"Threshold for powertrain setpoint to enable the boost of the curative anti-jerk function."
		VALUE
		0x8005a70a
		RSA_RecordLayout_VALUE_UWORD
		1
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_driv_pwt_sp_thd 
    FORMAT "%8.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_dt_grip_rat_clos
		"Value of coupler torque grip ratio to consider the driveline closed"
		VALUE
		0x8005a709
		RSA_RecordLayout_VALUE_UBYTE
		1
		yuEqExb_buwnyAb_Fbvbdrc_n_R0ooa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_dt_grip_rat_clos 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_dt_grip_rat_open
		"Value of coupler torque grip ratio to consider the driveline open"
		VALUE
		0x8005a708
		RSA_RecordLayout_VALUE_UBYTE
		1
		yuEqExb_buwnyAb_Fbvbdrc_n_R0ooa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_dt_grip_rat_open 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_loss_fil_cut_thd
		"Torque threshold for AJMOD engine torque losses filtering management"
		VALUE
		0x80059d6c
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ajs_modu_loss_fil_cut_thd 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_slk_fil_t1_acel
		"Time constant for filtering the slack effect correction for vehicle acceleration"
		VALUE
		0x80059d6a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_modu_slk_fil_t1_acel 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_slk_fil_t1_decl
		"Time constant for filtering the slack effect correction for vehicle deceleration"
		VALUE
		0x80059d68
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_modu_slk_fil_t1_decl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_t1_decl_dt_modu
		"AJMOD time constant value when driveline is in modulation mode for vehicle deceleration"
		VALUE
		0x80059d66
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_modu_t1_decl_dt_modu 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_t1_decl_dt_open
		"AJMOD time constant value when driveline is open for vehicle deceleration"
		VALUE
		0x80059d64
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_modu_t1_decl_dt_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_t1_dt_clos_max
		"Maximum AJMOD time constant value when driveline is close"
		VALUE
		0x80059d62
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_modu_t1_dt_clos_max 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_t1_dt_ini
		"AJMOD time constant value during initialisation"
		VALUE
		0x80059d60
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_modu_t1_dt_ini 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_t1_fast_cor
		"AJMOD time constant value during a fast anti-jerk correction"
		VALUE
		0x80059d5e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_modu_t1_fast_cor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_td_decl_dt_modu
		"AJMOD gain value when driveline is in modulation mode for vehicle deceleration"
		VALUE
		0x80059d5c
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_modu_td_decl_dt_modu 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_td_decl_dt_open
		"AJMOD gain value when driveline is open for vehicle deceleration"
		VALUE
		0x80059d5a
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_modu_td_decl_dt_open 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_td_dt_ini
		"AJMOD gain value during initialisation"
		VALUE
		0x80059d58
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_modu_td_dt_ini 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_td_fast_cor
		"AJMOD gain value during a fast anti-jerk correction"
		VALUE
		0x80059d56
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_modu_td_fast_cor 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_tkof_vs_thd
		"Vehicule speed threshold to deactivate parameters modulation during takeoff phase"
		VALUE
		0x80059d54
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ajs_modu_tkof_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_vs_thd_off
		"Vehicule speed high threshold to deactivate AJMOD function"
		VALUE
		0x80059d52
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ajs_modu_vs_thd_off 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_modu_vs_thd_on
		"Vehicule speed low threshold to deactivate AJMOD function"
		VALUE
		0x80059d50
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ajs_modu_vs_thd_on 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_n_mv_dft
		"Engine speed replacement value for invalid engine speed measure"
		VALUE
		0x80059d4e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ajs_n_mv_dft 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_slk_act_ctr
		"Number of permitted activations of slack effect"
		VALUE
		0x80059d4c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ajs_slk_act_ctr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_slk_drv_tq_thd_off
		"Normalized driver torque factor high threshold to deactivate the slack effect"
		VALUE
		0x8005a707
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_slk_drv_tq_thd_off 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_slk_drv_tq_thd_on
		"Normalized driver torque factor low threshold to deactivate the slack effect"
		VALUE
		0x8005a706
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_slk_drv_tq_thd_on 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_slk_td_ini_fac
		"Corrective factor of Td added by the slack effect"
		VALUE
		0x80059d4a
		RSA_RecordLayout_VALUE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_ajs_slk_td_ini_fac 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spccdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spc_comb_mod_cho_1
		"Combustion mode chosen for activation of Anti-jerk specific parameters"
		VALUE
		0x80040284
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_ajs_spc_comb_mod_cho_1 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spccdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spc_comb_mod_cho_2
		"Combustion mode chosen for activation of Anti-jerk specific parameters"
		VALUE
		0x80040283
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_ajs_spc_comb_mod_cho_2 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spccdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spc_comb_mod_cho_3
		"Combustion mode chosen for activation of Anti-jerk specific parameters"
		VALUE
		0x80040282
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_ajs_spc_comb_mod_cho_3 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spd_diff_thd_off_acel
		"Speed difference high threshold to deactivate the slack effect for vehicle acceleration"
		VALUE
		0x8005a704
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_ajs_spd_diff_thd_off_acel 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spd_diff_thd_off_decl
		"Speed difference high threshold to deactivate the slack effect for vehicle deceleration"
		VALUE
		0x8005a702
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_ajs_spd_diff_thd_off_decl 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spv_driv_tq_t1_fil
		"Filter time constant for calculation of the driver torque factor"
		VALUE
		0x8005a700
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_spv_driv_tq_t1_fil 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spv_n_mv_thd
		"Engine speed threshold to enable the boost of the curative anti-jerk function."
		VALUE
		0x8005a6fe
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ajs_spv_n_mv_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spv_slk_decl_dly
		"Time delay to detect the end of the slack effect correction during vehicle deceleration"
		VALUE
		0x8005a6fc
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ajs_spv_slk_decl_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spv_tco_thd
		"Engine temperature threshold to enable the boost of the curative anti-jerk function."
		VALUE
		0x8005a6fa
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ajs_spv_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spv_tq_drv_hys
		"hysteresis for Driver torque derivative threshold to enable the boost of the curative anti-jerk function."
		VALUE
		0x8005a6f9
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_spv_tq_drv_hys 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spv_tq_drv_thd
		"Driver torque derivative threshold to enable the boost of the curative anti-jerk function."
		VALUE
		0x8005a6f8
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ajs_spv_tq_drv_thd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spv_tq_rat_t1_fil
		"Filter time constant for filtering of the driver torque ratio"
		VALUE
		0x8005a6f6
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ajs_spv_tq_rat_t1_fil 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spv_tqe_tgt_thd
		"Driver torque threshold to enable the boost of the curative anti-jerk function."
		VALUE
		0x8005a6f4
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_ajs_spv_tqe_tgt_thd 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ajs_spv_wait_dly
		"Maximum time for the observation of driver pedal or torque conditions to enable the boost of the curative the anti-jerk function."
		VALUE
		0x8005a6f2
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ajs_spv_wait_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_is_meca_pow
		"Alternator idle speed mechanical power"
		VALUE
		0x8006b34a
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_alt_is_meca_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_min_pow_ena
		"Alternator maximum power minimum value"
		VALUE
		0x8005cda8
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_alt_min_pow_ena 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_pow_dsb_fil_fac
		"Value when the 1st filter is disabled"
		VALUE
		0x80058988
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_alt_pow_dsb_fil_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_pow_trs_dif_thd
		"Alternator power transitional detection threshold"
		VALUE
		0x80058986
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_alt_pow_trs_dif_thd 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_pow_trs_fil_dec
		"Filtering factor used to detect a decreasing alternator power value"
		VALUE
		0x80058984
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_alt_pow_trs_fil_dec 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_pow_trs_fil_inc
		"Filtering factor used to detect an increasing alternator power value"
		VALUE
		0x80058982
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_alt_pow_trs_fil_inc 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_pwm_fil_fac
		"cl_coo_ctl_chctlxx/ Filtering factor for alternator PWM"
		VALUE
		0x8005cf44
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_alt_pwm_fil_fac 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_altdfcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_pwm_l
		"Alternator load setting when engine is not autonomous"
		VALUE
		0x80058a91
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_alt_pwm_l 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_pwm_nok
		"Invalid value of Alternator PWM (load signal)"
		VALUE
		0x80059090
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_alt_pwm_nok 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_altdfcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_pwm_sub
		"Alternator load by default"
		VALUE
		0x80058a90
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_alt_pwm_sub 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_alt_slop_dly
		"Alternator power ramp on initialisation"
		VALUE
		0x80058980
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_alt_slop_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_chr_amp_max
		"Maximum amp to authorize the chr diagnosis"
		VALUE
		0x800576ba
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_amp_chr_amp_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_chr_amp_min
		"Minimum amp to authorize the chr diagnosis"
		VALUE
		0x800576b8
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_amp_chr_amp_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_chr_map_spg_dif
		"Maximum spg-map difference to enable amp_chr diag"
		VALUE
		0x800576b6
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_amp_chr_map_spg_dif 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_chr_n_max
		"Maximum  engine speed to authorize the chr diag"
		VALUE
		0x800576b4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_amp_chr_n_max 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_chr_tco_max
		"Maximum Engine coolant temperature to authorize the chr diag"
		VALUE
		0x800576b2
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_amp_chr_tco_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_chr_tco_min
		"Minimum Engine coolant temperature to authorize the chr diag"
		VALUE
		0x800576b0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_amp_chr_tco_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_chr_tia_max
		"Maximum Intake air temperature to authorize the chr diag"
		VALUE
		0x800576ae
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_amp_chr_tia_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_chr_tia_min
		"Minimum Intake air temperature to authorize the chr diag"
		VALUE
		0x800576ac
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_amp_chr_tia_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_chr_tqi_max
		"Maximum torque setpoint to authorize the chr diag"
		VALUE
		0x800576aa
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_amp_chr_tqi_max 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_h_thd_mon
		"Max value of amp for monitoring"
		VALUE
		0x80043b66
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_amp_h_thd_mon 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_l_thd_mon
		"Minimal value for amp for monitoring of error loop"
		VALUE
		0x80043b64
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_amp_l_thd_mon 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_lih_val
		"Atmospheric pressure limp home value"
		VALUE
		0x80045888
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_amp_lih_val 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_map_spg_dif
		"Maximum difference between Map+Spg and 2*Amp to detect an amp_chr failure"
		VALUE
		0x800576a8
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_amp_map_spg_dif 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_amp_sup
		"Min value of atmospheric pressure during air mass flow sensor drift diagnosis"
		VALUE
		0x80057400
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_amp_sup 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ant_gear_dif_thd
		"Threshold for the rising shift detection"
		VALUE
		0x8006b23a
		RSA_RecordLayout_VALUE_SWORD
		14
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		-7.
		7.
    DISPLAY_IDENTIFIER Cxx_ant_gear_dif_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ant_gear_fil
		"Time constant value for the the gear shift filter"
		VALUE
		0x8006b238
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ant_gear_fil 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_asr_msr_abst_dly
		"Calibration time to detect a lost frame"
		VALUE
		0x80058888
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_asr_msr_abst_dly 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_asr_msr_ctr_thd
		"This is a failure counter threshold. It authorize N successive failure before downgraded mode"
		VALUE
		0x80058886
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_asr_msr_ctr_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_asr_msr_max_tqe
		"Maximum allowable ASR/MSR torque request"
		VALUE
		0x80058884
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_asr_msr_max_tqe 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_asr_msr_raw_sum
		"Sum of raw ASR target and raw MSR setpoint"
		VALUE
		0x80058882
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_asr_msr_raw_sum 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_asr_slwr_neg
		"ASR slew rate negative curve in case of protocol error"
		VALUE
		0x80058880
		RSA_RecordLayout_VALUE_UWORD
		10235
		BsxxCDd_fyuafxb_rkxlsta_NsA_00a
		-10235.
		0.
    DISPLAY_IDENTIFIER Cxx_asr_slwr_neg 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_asr_slwr_pos
		"ASR slew rate positive curve in case of protocol error"
		VALUE
		0x8005887e
		RSA_RecordLayout_VALUE_UWORD
		10235
		aainjEc_jgzdbtd_deplAyc_NsA_00a
		0.
		10235.
    DISPLAY_IDENTIFIER Cxx_asr_slwr_pos 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_asr_tqe_sp_msr_raw
		"Unscaled (raw) value of ASR torque setpoint sent during MSR requests"
		VALUE
		0x8005887c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_asr_tqe_sp_msr_raw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_engstxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_aut_eng_n_thd_h
		"Engine speed threshold used to declare the autonomous engine state"
		VALUE
		0x80041502
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_aut_eng_n_thd_h 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_aut_swi1_is_ofs
		"engine offset after cut, threshold is added of idle speed set point, if the first gear ratio is detected"
		VALUE
		0x8004331a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_aut_swi1_is_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_aut_swi_is_ofs
		"engine offset after cut, threshold is added of idle speed set point, if gear ratio is different of first ratio"
		VALUE
		0x80043318
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_aut_swi_is_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_bgin_clu_dg_act_vs_min
		"Minimal vehicle speed of the activation of the diagnosis"
		VALUE
		0x8006b236
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_bgin_clu_dg_act_vs_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_bgin_clu_fail_ccp_dly
		"Admissible delay of incoherence between clutch information due to CAN communication"
		VALUE
		0x8005914c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_bgin_clu_fail_ccp_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_bgin_clu_fail_co_dly
		"Admissible delay of incoherence between clutch information due to CAN communication"
		VALUE
		0x8005914a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_bgin_clu_fail_co_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_bgin_clu_off_no_chr_ctr
		"Number of incoherencies when the begin clutch contactor is OFF before activating the failure manager"
		VALUE
		0x8006b235
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_bgin_clu_off_no_chr_ctr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_bgin_clu_on_no_chr_ctr
		"Number of incoherencies when the begin clutch contactor is ON before activating the failure manager"
		VALUE
		0x8006b234
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_bgin_clu_on_no_chr_ctr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_blk_n_i_fac_cor
		"Factor on integral torque correction in case of blocked engine speed"
		VALUE
		0x8005ab44
		RSA_RecordLayout_VALUE_UWORD
		6.99
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		6.99
    DISPLAY_IDENTIFIER Cxx_blk_n_i_fac_cor 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_blk_n_min_is_i
		"Offset on minimum integral torque correction in case of blocked engine speed"
		VALUE
		0x8005ab42
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_blk_n_min_is_i 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_brk_det_dly
		"Minimum time to detect à brake pedal press"
		VALUE
		0x8005916a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_brk_det_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_brk_fail_ccp_dly
		"Admissible delay of incoherence between brake information due to CAN communication"
		VALUE
		0x80059148
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_brk_fail_ccp_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_brk_fail_co_dly
		"Admissible delay of incoherence between brake information due to CAN communication"
		VALUE
		0x80059146
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_brk_fail_co_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_brk_min_decl_thd
		"Minimum deceleration value to detect braking"
		VALUE
		0x80059168
		RSA_RecordLayout_VALUE_SWORD
		25.5
		egzsxdd_khlsmxa_bqjovCc_msA_10a
		-12.
		13.5
    DISPLAY_IDENTIFIER Cxx_brk_min_decl_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id1
		"ASCII value of the first character of the CALID#2"
		VALUE
		0x80056d8f
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id10
		"ASCII value of the tenth character of the CALID#2"
		VALUE
		0x80056d8e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id10 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id11
		"ASCII value of the eleventh character of the CALID#2"
		VALUE
		0x80056d8d
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id11 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id12
		"ASCII value of the twelfth character of the CALID#2"
		VALUE
		0x80056d8c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id12 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id13
		"ASCII value of the thirteenth character of the CALID#2"
		VALUE
		0x80056d8b
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id13 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id14
		"ASCII value of the fourteenth character of the CALID#2"
		VALUE
		0x80056d8a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id14 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id15
		"ASCII value of the fifteenth character of the CALID#2"
		VALUE
		0x80056d89
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id15 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id16
		"ASCII value of the sixteenth character of the CALID#2"
		VALUE
		0x80056d88
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id16 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id2
		"ASCII value of the second character of the CALID#2"
		VALUE
		0x80056d87
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id3
		"ASCII value of the third character of the CALID#2"
		VALUE
		0x80056d86
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id3 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id4
		"ASCII value of the fourth character of the CALID#2"
		VALUE
		0x80056d85
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id4 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id5
		"ASCII value of the fifth character of the CALID#2"
		VALUE
		0x80056d84
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id5 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id6
		"ASCII value of the sixth character of the CALID#2"
		VALUE
		0x80056d83
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id6 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id7
		"ASCII value of the seventh character of the CALID#2"
		VALUE
		0x80056d82
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id7 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id8
		"ASCII value of the eighth character of the CALID#2"
		VALUE
		0x80056d81
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id8 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_id9
		"ASCII value of the ninth character of the CALID#2"
		VALUE
		0x80056d80
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_id9 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_nr1
		"Calibration number (byte 0)"
		VALUE
		0x80056f7e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_nr1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_c_nr2
		"Calibration number (byte 1)"
		VALUE
		0x80056f7d
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_c_nr2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ccu_abst_frm_dly
		"BCM Control Unit absence detection time-out"
		VALUE
		0x80055bd7
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ccu_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ccu_ecu_conf
		"BCM Control Unit feature for Mux Network configuration detection (always present or optional)"
		VALUE
		0x80055bd6
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ccu_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ccu_vld_abst_frm_dec
		"BCM Control Unit : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bd5
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ccu_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ccu_vld_abst_frm_inc
		"BCM Control Unit : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bd4
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ccu_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cert_id
		"Approval Number basic part list"
		VALUE
		0x80056f7c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cert_id 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cmd_mdf_dly
		"Maximum duration of mdf1 activation (compromised between engine compartment cooling and electric balance)."
		VALUE
		0x8006b0b2
		RSA_RecordLayout_VALUE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_cmd_mdf_dly 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_comb_efy_sta
		"Combustion efficiency during Starting Combustion Mode"
		VALUE
		0x8004324c
		RSA_RecordLayout_VALUE_UWORD
		9.999
		uobbrza_onEavnc_ryxBhwb_Ngj_ao0
		0.001
		10.
    DISPLAY_IDENTIFIER Cxx_comb_efy_sta 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_ptissxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_comb_mod_is_1
		"First possible combustion mode"
		VALUE
		0x8005aef7
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_comb_mod_is_1 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_ptissxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_comb_mod_is_2
		"Second possible combustion mode"
		VALUE
		0x8005aef6
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_comb_mod_is_2 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_ctlfacx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_comb_mod_is_3
		"Third possible combustion mode"
		VALUE
		0x8005a9db
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_comb_mod_is_3 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_ctlfacx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_comb_mod_is_4
		"Fourth possible combustion mode"
		VALUE
		0x8005a9da
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_comb_mod_is_4 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_comb_mod_mafs_plau_diag_1
		"First possible combustion mode which allows learning"
		VALUE
		0x800573fe
		RSA_RecordLayout_VALUE_UBYTE
		5
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_comb_mod_mafs_plau_diag_1 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_comb_mod_mafs_plau_diag_2
		"Second possible combustion mode which allows learning"
		VALUE
		0x800573fd
		RSA_RecordLayout_VALUE_UBYTE
		5
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_comb_mod_mafs_plau_diag_2 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_comb_mod_mafs_plau_diag_3
		"Third possible combustion mode which allows learning"
		VALUE
		0x800573fc
		RSA_RecordLayout_VALUE_UBYTE
		5
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_comb_mod_mafs_plau_diag_3 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_comb_mod_slop_on_tout
		"Maximum time during combustion transition"
		VALUE
		0x8004ea6e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_comb_mod_slop_on_tout 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafdymd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_cool_vol
		"Volume between the maf sensor and the inlet throttle"
		VALUE
		0x800573d2
		RSA_RecordLayout_VALUE_UWORD
		0.007
		qmxjsqc_pfyberd_Fwnmela_mCRa0a0
		0.
		0.007
    DISPLAY_IDENTIFIER Cxx_cool_vol 
    FORMAT "%9.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_abst_dspl_vs_dly
		"Frame absence duration to declare unavailable displayed vehicle speed"
		VALUE
		0x800401d3
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_cru_abst_dspl_vs_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_abst_vs_dly
		"Frame absence duration to declare unavailable vehicle speed"
		VALUE
		0x800401d2
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_cru_abst_vs_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_brk_fail_dly
		"Minimum time to detect a brake information absence."
		VALUE
		0x80059166
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_cru_brk_fail_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_brk_nok_dly
		"Minimum time to detect a non available brake information."
		VALUE
		0x80059164
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_cru_brk_nok_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_clu_navl_dly
		"Minimum time to detect a clutch information absence"
		VALUE
		0x80059162
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_cru_clu_navl_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_clu_nok_dly
		"Minimum time to detect a non available clutch information"
		VALUE
		0x80059160
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_cru_clu_nok_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_cmf_cut_forc_dec
		"Force decrement/s for comfortable cut-off of cruise control."
		VALUE
		0x80040180
		RSA_RecordLayout_VALUE_UWORD
		131070
		fdzoyza_nfCiiDb_dkpidrc_N___o0a
		0.
		131070.
    DISPLAY_IDENTIFIER Cxx_cru_cmf_cut_forc_dec 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_dgn_eprm_imd_writ_thr
		"Threshold to stop root cause and mileage EEPROM write-on-the-flight"
		VALUE
		0x80059170
		RSA_RecordLayout_VALUE_ULONG
		16777215
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		16777215.
    DISPLAY_IDENTIFIER Cxx_cru_dgn_eprm_imd_writ_thr 
    FORMAT "%8.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_forc_sp_dly
		"Delay for cruise control comfortable deactivation before safety failure detection"
		VALUE
		0x80059144
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_cru_forc_sp_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_forc_sp_thd
		"Threshold for the maximum force request out of cruise control conditions"
		VALUE
		0x80059140
		RSA_RecordLayout_VALUE_SLONG
		131068
		akxoDid_fubczib_zregbrc_N_R05oa
		-20000.
		111068.
    DISPLAY_IDENTIFIER Cxx_cru_forc_sp_thd 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_long_step
		"Value of requested speed step in cruise control mode when accel or decel switch pressed continuously"
		VALUE
		0x800401d1
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_long_step 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_long_step_mph
		"Value of requested speed step in Cruise control mode when accel or decel switch pressed continuously in mph"
		VALUE
		0x800401d0
		RSA_RecordLayout_VALUE_UBYTE
		255
		fbhwiwa_ocsanpd_EFwyxCb_m_A_1oa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_long_step_mph 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_min_forc
		"Minimum saturation value of the force request (lesser than the minimum force feasible by the engine)"
		VALUE
		0x8004017c
		RSA_RecordLayout_VALUE_SLONG
		131068
		akxoDid_fubczib_zregbrc_N_R05oa
		-20000.
		111068.
    DISPLAY_IDENTIFIER Cxx_cru_min_forc 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_nok_vs_dly
		"Invalid value duration to  declare invalid vehicle speed"
		VALUE
		0x800401cf
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_cru_nok_vs_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_ovs_warn_thd
		"Speed theshold to activate the warning in case of volontary cruise control overspeed"
		VALUE
		0x800401b0
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		lthgvjd_avbcmnd_vDEmpCc_khA_10a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_cru_ovs_warn_thd 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_ovs_warn_thd_mph
		"Speed theshold in mph to activate the warning in case of volontary cruise control overspeed"
		VALUE
		0x800401af
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		bAngAbd_ajxybma_vfjmdrc_m___00a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_cru_ovs_warn_thd_mph 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_ref_vs_acel_grd
		"Acceleration gradient coefficient to calculatethe speed reference"
		VALUE
		0x80040179
		RSA_RecordLayout_VALUE_SBYTE
		0.255
		ezvttmd_fgeufqb_bCDnrha_1__000a
		-0.128
		0.127
    DISPLAY_IDENTIFIER Cxx_cru_ref_vs_acel_grd 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_ref_vs_acel_ofs
		"Acceleration gradient offset to calculate the speed reference for cruise control"
		VALUE
		0x80040178
		RSA_RecordLayout_VALUE_UBYTE
		6.375
		bFjCisa_ylspjfb_EjFjAea_kp__40a
		0.
		6.375
    DISPLAY_IDENTIFIER Cxx_cru_ref_vs_acel_ofs 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_ref_vs_decl_grd
		"Deceleration gradient coefficient to calculate the speed reference"
		VALUE
		0x80040177
		RSA_RecordLayout_VALUE_SBYTE
		0.255
		ezvttmd_fgeufqb_bCDnrha_1__000a
		-0.128
		0.127
    DISPLAY_IDENTIFIER Cxx_cru_ref_vs_decl_grd 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_ref_vs_decl_ofs
		"Declaration gradient offset to calculate the speed reference for cruise control"
		VALUE
		0x80040176
		RSA_RecordLayout_VALUE_UBYTE
		6.375
		bFjCisa_ylspjfb_EjFjAea_kp__40a
		0.
		6.375
    DISPLAY_IDENTIFIER Cxx_cru_ref_vs_decl_ofs 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_acel_blk_dly
		"Maxixmum duration of the SET+ press before blocked switch detection"
		VALUE
		0x8005882a
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_acel_blk_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_acel_max_thd
		"Maximum dec threshold to detect an accel switch press"
		VALUE
		0x80058828
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_acel_max_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_acel_min_thd
		"Minimum dec threshold to detect an accel switch press"
		VALUE
		0x80058826
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_acel_min_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_decl_blk_dly
		"Maxixmum duration of the SET- press before blocked switch detection"
		VALUE
		0x80058824
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_decl_blk_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_decl_max_thd
		"Maximum dec threshold to detect a decel switch press"
		VALUE
		0x80058822
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_decl_max_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_decl_min_thd
		"Minimum dec threshold to detect a decel switch press"
		VALUE
		0x80058820
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_decl_min_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_fil_acel_fac
		"Acceleration digital filtering parameter"
		VALUE
		0x800401ce
		RSA_RecordLayout_VALUE_UBYTE
		0.99609375
		fsjmcda_jujcsFa_ycbccca_n_Ra6oa
		0.
		0.99609375
    DISPLAY_IDENTIFIER Cxx_cru_sl_fil_acel_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_fil_vs_fac
		"Speed digital filtering parameter"
		VALUE
		0x800401cd
		RSA_RecordLayout_VALUE_UBYTE
		0.99609375
		fsjmcda_jujcsFa_ycbccca_n_Ra6oa
		0.
		0.99609375
    DISPLAY_IDENTIFIER Cxx_cru_sl_fil_vs_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_lk_ena_dly
		"Filter time to enable the cruise control and speed limiter option detection"
		VALUE
		0x8005881e
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_cru_sl_lk_ena_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_lk_vb_thd
		"Minimum battery voltage to enable the cruise control and speed limiter option detection"
		VALUE
		0x8005881c
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_lk_vb_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_long_sp_dec_t
		"pc_cru_spt_setptxx/Minimum duration of a push button press for continuous decrease of requested speed"
		VALUE
		0x800401ae
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_cru_sl_long_sp_dec_t 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_long_sp_inc_t
		"pc_cru_spt_setptxx/Minimum duration of a push button press for continuous increase of requested speed"
		VALUE
		0x800401ad
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_cru_sl_long_sp_inc_t 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_max_vs
		"CC/SL maximal speed setpoint"
		VALUE
		0x800401cc
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_sl_max_vs 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_max_vs_mph
		"CC/SL maximal speed setpoint in mph"
		VALUE
		0x800401cb
		RSA_RecordLayout_VALUE_UBYTE
		255
		fbhwiwa_ocsanpd_EFwyxCb_m_A_1oa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_sl_max_vs_mph 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_min_vs
		"CC/SL minimal speed setpoint"
		VALUE
		0x800401ca
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_sl_min_vs 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_min_vs_mph
		"CC/SL minimal speed setpoint in mph"
		VALUE
		0x800401c9
		RSA_RecordLayout_VALUE_UBYTE
		255
		fbhwiwa_ocsanpd_EFwyxCb_m_A_1oa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_sl_min_vs_mph 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_no_efv_vs_thd
		"Difference between vehicle speed and requested speed to declare CC/SL ineffective"
		VALUE
		0x800401c8
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		lthgvjd_avbcmnd_vDEmpCc_khA_10a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_no_efv_vs_thd 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_no_efv_vs_thd_mph
		"Difference between vehicle speed and requested speed to declare CC/SL ineffective in mph"
		VALUE
		0x800401c7
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		bAngAbd_ajxybma_vfjmdrc_m___00a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_no_efv_vs_thd_mph 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_open_min_thd
		"Minimum dec threshold to detect not-connected steering wheel switch"
		VALUE
		0x8005881a
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_open_min_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_resu_blk_dly
		"Maxixmum duration of the RESUME press before blocked switch detection"
		VALUE
		0x80058818
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_resu_blk_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_resu_max_thd
		"Maximum dec threshold to detect a resume switch press"
		VALUE
		0x80058816
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_resu_max_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_resu_min_thd
		"Minimum dec threshold to detect a resume switch press"
		VALUE
		0x80058814
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_resu_min_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_rls_max_thd
		"Maximum dec threshold to detect non-pressed steering wheel switch"
		VALUE
		0x80058812
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_rls_max_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_rls_min_thd
		"Minimum dec threshold to detect non-pressed steering wheel switch"
		VALUE
		0x80058810
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_rls_min_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_smal_step
		"Value of requested speed step when accel or decel switch pressed during a short time"
		VALUE
		0x800401c6
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_sl_smal_step 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_smal_step_mph
		"Value of requested speed step when accel or decel switch pressed during a short time in mph"
		VALUE
		0x800401c5
		RSA_RecordLayout_VALUE_UBYTE
		255
		fbhwiwa_ocsanpd_EFwyxCb_m_A_1oa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_sl_smal_step_mph 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_sp_inc_t
		"Time between two requested speed increments or decrements when button is pressed continuously"
		VALUE
		0x800401ac
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_sp_inc_t 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_susp_blk_dly
		"Maxixmum duration of the SUSPEND press before blocked switch detection"
		VALUE
		0x8005880e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_susp_blk_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_susp_max_thd
		"Maximum dec threshold to detect a suspend switch press"
		VALUE
		0x8005880c
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_cru_sl_susp_max_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_swi_dly
		"Main switch press validation time"
		VALUE
		0x8005880b
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_swi_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_swi_igk_dly
		"Delay to take into account a APC line cut-off"
		VALUE
		0x8005880a
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_swi_igk_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_warn_dly
		"Filtering delay before transmission of a CRU/SL warning"
		VALUE
		0x800401ab
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_cru_sl_warn_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_whl_cmd_blk_ctr_max
		"CC/SL: maximum number of unexpected switch changes before blocked switch detection"
		VALUE
		0x80058809
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_sl_whl_cmd_blk_ctr_max 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sl_whl_swi_dly
		"Steering wheel switch press validation time"
		VALUE
		0x80058808
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_cru_sl_whl_swi_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sp_acel_grd
		"Acceleration gradient coefficient to calculate the speed reference from the objective speed."
		VALUE
		0x80040175
		RSA_RecordLayout_VALUE_SBYTE
		0.255
		ezvttmd_fgeufqb_bCDnrha_1__000a
		-0.128
		0.127
    DISPLAY_IDENTIFIER Cxx_cru_sp_acel_grd 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sp_decl_grd
		"Deceleration gradient coefficient to calculate the speed reference from the objective speed"
		VALUE
		0x80040174
		RSA_RecordLayout_VALUE_SBYTE
		0.255
		ezvttmd_fgeufqb_bCDnrha_1__000a
		-0.128
		0.127
    DISPLAY_IDENTIFIER Cxx_cru_sp_decl_grd 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_sp_max_forc_inc
		"Force gradient for comfortable cruise control activation"
		VALUE
		0x80040170
		RSA_RecordLayout_VALUE_ULONG
		131070
		fdzoyza_nfCiiDb_dkpidrc_N___o0a
		0.
		131070.
    DISPLAY_IDENTIFIER Cxx_cru_sp_max_forc_inc 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_svkl_ig
		"Cruise control integral gain"
		VALUE
		0x8004016e
		RSA_RecordLayout_VALUE_UWORD
		1953.09519763205
		xhkomjb_oEsFhsa_hslCgmd_1C_522a
		0.
		1953.09519763205
    DISPLAY_IDENTIFIER Cxx_cru_svkl_ig 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_svkl_max_i_cor
		"Maximum value of the integral correction for Cruise control"
		VALUE
		0x8004016c
		RSA_RecordLayout_VALUE_SWORD
		124.998092651367
		Cnqgazb_fqFBleb_mEzjcxc_kA49o40
		-62.5
		62.4980926513672
    DISPLAY_IDENTIFIER Cxx_cru_svkl_max_i_cor 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_svkl_min_i_cor
		"Minimum value of the integral correction for Cruise control"
		VALUE
		0x8004016a
		RSA_RecordLayout_VALUE_SWORD
		124.998092651367
		Cnqgazb_fqFBleb_mEzjcxc_kA49o40
		-62.5
		62.4980926513672
    DISPLAY_IDENTIFIER Cxx_cru_svkl_min_i_cor 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_svkl_pg
		"Cruise control proportinal gain"
		VALUE
		0x80040168
		RSA_RecordLayout_VALUE_UWORD
		124.998092651367
		BAEcsta_ghvaACd_foyhjAa_1_0o00a
		0.
		124.998092651367
    DISPLAY_IDENTIFIER Cxx_cru_svkl_pg 
    FORMAT "%10.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_svkl_vs_thd
		"Speed threshold to activate servo-control in case of the objective speed"
		VALUE
		0x80040166
		RSA_RecordLayout_VALUE_SBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		-128.
		127.
    DISPLAY_IDENTIFIER Cxx_cru_svkl_vs_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_vs_secu_min
		"Minimum speed to test the speed coherence"
		VALUE
		0x800401c4
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_cru_vs_secu_min 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cru_vs_sp_rat
		"Minimum vehicle speed/requested speed ratio to disconnect cruise control"
		VALUE
		0x800401c2
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_cru_vs_sp_rat 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_csm_drv_ms_mdl_dft
		"Defaut value of filtered injected fuel quantity for estimation of soot mass in case of sensor failure"
		VALUE
		0x800468c0
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_csm_drv_ms_mdl_dft 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_spdreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_csm_sta_spd_req_dft
		"Default value for injected fuel quantity in speed request state"
		VALUE
		0x80046d04
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_csm_sta_spd_req_dft 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_csm_sum_rest_min
		"Minimum value of fuel consumption to activate start regeneration condition"
		VALUE
		0x80046b8c
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_csm_sum_rest_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_csm_sum_rgn_temp_chk_dft
		"Default value for injected fuel quantity in check temperature state"
		VALUE
		0x80067f66
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_csm_sum_rgn_temp_chk_dft 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_csm_sum_sta_cata_hot_dft
		"Default value for filtered injected fuel quantity in case of failure in catalyst heating state"
		VALUE
		0x80067f04
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_csm_sum_sta_cata_hot_dft 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cur_tra_acel_hys
		"Cxx_cur_tra_acel_hys"
		VALUE
		0x8005926e
		RSA_RecordLayout_VALUE_UWORD
		13.5
		VA_F_0v0004_p0_1
		0
		13.5
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cut_decl_dly_tq_rat
		"delay before injection cut during a gear ratio change"
		VALUE
		0x80043316
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_cut_decl_dly_tq_rat 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cut_decl_tco_thd
		"injection cut deceleration coolant temperature threshold"
		VALUE
		0x80043314
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_cut_decl_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cut_decl_tqi_thd
		"Torque threshold during the transient intersystem torque request , comparaison with the final indicated torque set point"
		VALUE
		0x80043312
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_cut_decl_tqi_thd 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cut_n_ofs
		"injection cut engine offset"
		VALUE
		0x80043310
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_cut_n_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_cut_n_ofs2
		"injection cut engine offset, if a powertrain torque setpoint is requested"
		VALUE
		0x8004330e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_cut_n_ofs2 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_injctxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_cyl_nr
		"Number of cylinder"
		VALUE
		0x800498b8
		RSA_RecordLayout_VALUE_UBYTE
		12
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		12.
    DISPLAY_IDENTIFIER Cxx_cyl_nr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_cyl_vol
		"Engine capacity displacement"
		VALUE
		0x80056fc0
		RSA_RecordLayout_VALUE_UWORD
		0.004
		qmxjsqc_pfyberd_Fwnmela_mCRa0a0
		0.
		0.004
    DISPLAY_IDENTIFIER Cxx_cyl_vol 
    FORMAT "%9.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ddcm_abst_frm_dly
		"DDCM Control Unit absence detection time-out"
		VALUE
		0x80055bd3
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ddcm_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ddcm_ecu_conf
		"DDCM Control Unit feature for Mux configuration detection (always present or optional)"
		VALUE
		0x80055bd2
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ddcm_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ddcm_vld_abst_frm_dec
		"DDCM Control Unit : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bd1
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ddcm_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ddcm_vld_abst_frm_inc
		"DDCM Control Unit : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bd0
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ddcm_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_ac_sp
		"Type of decrease  slope for the air conditionning idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004142a
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_ac_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_acs_sp
		"Type of decrease slope for the accessories idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041429
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_acs_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_agb_sp
		"Type of decrease  slope for the AGB idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041428
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_agb_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_dgi_sp
		"Type of decrease slope for the diagnosis and protection idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041427
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_dgi_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_diag_vvtc_sp
		"Type of decrease slope for the VVTC routine idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041426
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_diag_vvtc_sp 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_el_bk_sp
		"Type of decrease slope for the electrical backlite idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041425
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_el_bk_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_el_wind_sp
		"Type of decrease  slope for the electrical windshield idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041424
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_el_wind_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_inj_sp
		"Type of decrease slope for the injector idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041423
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_inj_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_moni_sp
		"Type of decrease  slope for the monitool idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041422
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_moni_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_pft_sp
		"Type of decrease  slope for the particle filter idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041421
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_pft_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_ptc_sp
		"Type of decrease  slope for the PTC idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041420
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_ptc_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_pwst_sp
		"Type of decrease  slope for the power steering idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004141f
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_pwst_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_run_vh_sp
		"Type of decrease  slope for the running vehicle idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004141e
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_run_vh_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_tco_sp
		"Type of decrease  slope for the coolant temperature idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004141d
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_tco_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dec_slop_thpl_sp
		"Type of decrease  slope for the thermoplunger idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004141c
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_dec_slop_thpl_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_decl_cut_n_ac_ofs
		"Deceleration injection cut engine offset if air conditioning compressor is clutched."
		VALUE
		0x8004330c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_decl_cut_n_ac_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_decl_cut_n_ofs
		"deceleration injection cut engine offset"
		VALUE
		0x8004330a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_decl_cut_n_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfctr_emtv_cutt_thd
		"Maximum cutting failures noticed on successive driving cycles before detection."
		VALUE
		0x80058b28
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dfctr_emtv_cutt_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfctr_emtv_ofs_no_norm_thd
		"Number of first offset learning failures noticed on successive driving cycles before detection."
		VALUE
		0x80058b27
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dfctr_emtv_ofs_no_norm_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfctr_emtv_reg_dirt_thd
		"Maximum dirty closed thrust failures noticed on successive driving cycles before detection."
		VALUE
		0x80058b26
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dfctr_emtv_reg_dirt_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfctr_it_cutt_thd
		"Maximum cutting failures noticed on successive driving cycles before detection."
		VALUE
		0x80058c6d
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dfctr_it_cutt_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfctr_it_dirt_clos_thd
		"Maximum dirty closed thrust failures noticed on successive driving cycles before detection."
		VALUE
		0x80058c6c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dfctr_it_dirt_clos_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfctr_it_ofs_clos_frst_thd
		"Number of first offset learning failures noticed on successive driving cycles (closed thrust)."
		VALUE
		0x80058c6b
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dfctr_it_ofs_clos_frst_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfctr_it_ofs_open_frst_thd
		"Number of first offset learning failures noticed on successive driving cycles (open thrust)."
		VALUE
		0x80058c6a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dfctr_it_ofs_open_frst_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ac_prs
		"Sensor Detected Failure Counter Decrement"
		VALUE
		0x80058a78
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ac_prs 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_acel_pdl_chr
		"Accelerator pedal consistency detected failure counter decrement"
		VALUE
		0x800587aa
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_acel_pdl_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_acel_pdl_secu_2
		"Accelerator pedal safety case N°2 detected failure counter decrement"
		VALUE
		0x800587de
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_acel_pdl_secu_2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_acel_pdl_tot
		"Total loss of accelerator pedal detected failure counter decrement"
		VALUE
		0x800587a8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_acel_pdl_tot 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_acel_pdl_v1
		"Accelerator pedal track 1 detected failure counter decrement"
		VALUE
		0x800587a6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_acel_pdl_v1 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_acel_pdl_v2
		"Accelerator pedal track 2 detected failure counter decrement"
		VALUE
		0x800587a4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_acel_pdl_v2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_agb_data
		"AGB data detected failure counter decrement"
		VALUE
		0x80058778
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_agb_data 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_agb_no_frm
		"AGB Missing Message detected failure counter decrement"
		VALUE
		0x80058776
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_agb_no_frm 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_amp_reg_chr
		""
		VALUE
		0x800576a6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_amp_reg_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_bgin_clu_cmp
		"Incoherence between clutch information detected failure counter decrement."
		VALUE
		0x8005913e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_bgin_clu_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_bgin_clu_nok
		"Wire begin clutch contactor detected failure counter decrement"
		VALUE
		0x8006b232
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_bgin_clu_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_brk_pdl_cmp
		"Incoherence between brake information detected failure counter decrement."
		VALUE
		0x8005913c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_brk_pdl_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_cata_nok_cge
		"Lack efficiency of oxidation catalyst detected failure counter decrement"
		VALUE
		0x80043c0a
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_AtCatDgn_OneToOne
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_cata_nok_cge 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_seclcxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_clu_cnt_nok
		"a_in_pci_dls_seclcxx/Clutch contactors detected failure counter decrement"
		VALUE
		0x80058850
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_clu_cnt_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_crk_chr
		"no cranshaft reference detection detected failure counter decrement"
		VALUE
		0x80058912
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_crk_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_crk_cmp
		"Incorrect number of crankshaft teeth detected failure counter decrement"
		VALUE
		0x80058910
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_crk_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_crk_cyc
		"Interference between two crankshaft teeth detected failure counter decrement"
		VALUE
		0x8005890e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_crk_cyc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_crk_no_sig
		"no crankshaft signal detected failure counter decrement"
		VALUE
		0x8005890c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_crk_no_sig 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_crk_oc
		"Open circuit of one of the leads of crankshaft sensor detected failure counter decrement"
		VALUE
		0x8005890a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_crk_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_crk_shp
		"No detection of crankshaft reference detected failure counter decrement"
		VALUE
		0x80058908
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_crk_shp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_cru_cmp
		"Cruise control safety detected failure counter decrement."
		VALUE
		0x8005913a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_cru_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_cru_sl_swi_chr
		"Cruise Control Main Switch Coherence detected failure counter decrement"
		VALUE
		0x80058806
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_cru_sl_swi_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_cru_sl_tot
		"Cruise control and speed limiter common failures Detected Failure Counter Decrement"
		VALUE
		0x8005915e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_cru_sl_tot 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_cru_vs_cmp
		"CC/SL mux vehicle speed coherence Detected Failure Counter Decrement"
		VALUE
		0x800401c0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_cru_vs_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_cru_whl_cmd
		"Cruise Control Steering Wheel Command Switch Detected Failure Counter Decrement"
		VALUE
		0x80058804
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_cru_whl_cmd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_cru_whl_cmd_nok
		"CCSL steering wheel switches blocked button detected failure counter decrement"
		VALUE
		0x80058802
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_cru_whl_cmd_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_doc1_utp_chr
		"doc1_utp_chr_detected failure counter decrement"
		VALUE
		0x80058126
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_doc1_utp_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_doc1_utp_h
		"doc1_utp_h detected failure counter decrement"
		VALUE
		0x80058124
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_doc1_utp_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_doc1_utp_l
		"doc1_utp_l detected failure counter decrement"
		VALUE
		0x80058122
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_doc1_utp_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_diaginj_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_efi_inj_oc
		"efi_inj_oc detected failure counter decrement"
		VALUE
		0x80058f22
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_efi_inj_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_diaginj_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_efi_inj_scg
		"efi_inj_scg detected failure counter decrement"
		VALUE
		0x80058f20
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_efi_inj_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_diaginj_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_efi_inj_scw
		"efi_inj_scw detected failure counter decrement"
		VALUE
		0x80058f1e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_efi_inj_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_efi_sldv_oc
		"efi_sldv_oc detected failure counter decrement"
		VALUE
		0x80058f16
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_efi_sldv_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_efi_sldv_scg
		"efi_sldv_scg detected failure counter decrement"
		VALUE
		0x80058f14
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_efi_sldv_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_efi_sldv_scw
		"efi_sldv_scw detected failure counter decrement"
		VALUE
		0x80058f12
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_efi_sldv_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_egr_byp_blk
		"EGR bypass blocked detected failure counter decrement"
		VALUE
		0x80043af2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_egr_byp_blk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_bypxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_egr_byp_h
		"EGR bypass high signal detected failure counter decrement"
		VALUE
		0x80058ac6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_egr_byp_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_bypxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_egr_byp_l
		"EGR bypass low signal detected failure counter decrement"
		VALUE
		0x80058ac4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_egr_byp_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_emtv_flow_meca
		"Blocked emtv during full closing request (OBD failure) detected failure counter decrement"
		VALUE
		0x80058b24
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_emtv_flow_meca 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_emtv_hbdg_el
		"EMTV power supply (Hbridge) detected failure counter decrement"
		VALUE
		0x80058b22
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_emtv_hbdg_el 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_emtv_hbdg_ovh
		"EMTV power supply (Hbridge overheat) detected failure counter decrement"
		VALUE
		0x80058b20
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_emtv_hbdg_ovh 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_emtv_ofs_no_norm
		"First offset learning detected failure counter decrement"
		VALUE
		0x80058b1e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_emtv_ofs_no_norm 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_emtv_reg_blk
		"Blocked EMTV during regulation detected failure counter decrement"
		VALUE
		0x80058b1c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_emtv_reg_blk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_emtv_reg_blk_open
		"Blocked emtv during full closing request detected failure counter decrement"
		VALUE
		0x80058b1a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_emtv_reg_blk_open 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_emtv_reg_dirt
		"Dirty EMTV near the closed thrust detected failure counter decrement"
		VALUE
		0x80058b18
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_emtv_reg_dirt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_esp_data_chr
		"ESP data torque request coherency detected failure counter decrement"
		VALUE
		0x8005887a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_esp_data_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_esp_data_seq_ctr
		"ESP data frame sequence counter detected failure counter decrement"
		VALUE
		0x80058878
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_esp_data_seq_ctr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_esp_no_frm
		"ESP Missing Message detected failure counter decrement"
		VALUE
		0x80058876
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_esp_no_frm 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ex_prs_no_lk
		"Ex man pres sens high signal detected failure counter decrement"
		VALUE
		0x80057dc8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ex_prs_no_lk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_in_cam_chr
		"intake camshaft signal incoherency detected failure counter decrement"
		VALUE
		0x800588fa
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_in_cam_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_in_cam_crk_cmp
		"incoherency between intake camshaft signal and crankshaft signal detected failure counter decrement"
		VALUE
		0x800588f8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_in_cam_crk_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_in_cam_cyc
		"Interference close to a intake camshaft edge detected failure counter decrement"
		VALUE
		0x800588f6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_in_cam_cyc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_in_cam_no_sig
		"no intake camshaft signal detected failure counter decrement"
		VALUE
		0x800588f4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_in_cam_no_sig 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_in_cam_nok
		"Camshaft signal invalid for synchronisation detected failure counter decrement"
		VALUE
		0x800588f2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_in_cam_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ip_lght_tco_ovh
		"ou_clo_coo_clatoxx/Warning over heating lamp detected failure counter decrement"
		VALUE
		0x80059054
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ip_lght_tco_ovh 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_it_hbdg_el
		"a_ou_aso_ito_itdiag/IT Power Supply detected failure counter decrement"
		VALUE
		0x80058c68
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_it_hbdg_el 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_it_hbdg_ovh
		"a_ou_aso_ito_itdiag/IT Power Supply detected failure counter decrement"
		VALUE
		0x80058c66
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_it_hbdg_ovh 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_it_ofs_no_norm
		"a_ou_aso_ito_itdiag/IT First Offset detected failure counter decrement"
		VALUE
		0x80058c64
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_it_ofs_no_norm 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_it_reg_blk
		"a_ou_aso_ito_itdiagx/Blocked IT during regulation detected failure counter decrement"
		VALUE
		0x80058c62
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_it_reg_blk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_it_reg_blk_clos
		"a_ou_aso_ito_itdiag/IT regulation detected failure counter decrement"
		VALUE
		0x80058c60
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_it_reg_blk_clos 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_it_reg_blk_open
		"a_ou_aso_ito_itdiag/IT regulation detected failure counter decrement"
		VALUE
		0x80058c5e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_it_reg_blk_open 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_it_reg_dirt
		"a_ou_aso_ito_itdiag/IT regulation detected failure counter decrement"
		VALUE
		0x80058c5c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_it_reg_dirt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_maf_reg_neg_err
		"MAF regulation negative error detected failure counter decrement"
		VALUE
		0x80043b62
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_maf_reg_neg_err 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_mafs_apl_down
		"Mass air flow sensor low drift diagnostic detected failure counter decrement"
		VALUE
		0x800573fa
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_mafs_apl_down 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_mafs_apl_up
		"Mass air flow sensor high drift diagnostic detected failure counter decrement"
		VALUE
		0x800573f8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_mafs_apl_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_map_nok_apc
		"Manifold pressure sensor nok during APC detected failure counter decrement"
		VALUE
		0x800577b6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_map_nok_apc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_map_nok_isr
		"Manifold pressure sensor nok during ISR detected failure counter decrement"
		VALUE
		0x800577b4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_map_nok_isr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_oil_dil_nok
		"Oil dilution overshoot detected failure increment"
		VALUE
		0x8005529a
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OneToOne
		0
		65535
    DISPLAY_IDENTIFIER Cxx_dfdec_oil_dil_nok 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_pft_dirt
		"Overloaded CSF detected failure counter decrement"
		VALUE
		0x80045f76
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_pft_dirt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_pft_dirt_lkg
		"Load CSF detected failure counter decrement"
		VALUE
		0x80046434
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_pft_dirt_lkg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_pft_no_lk
		"Broken CSF detected failure counter decrement"
		VALUE
		0x80045d88
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_pft_no_lk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_pft_rgn_dirt
		"Maximum regenration error reached detected failure counter decrement"
		VALUE
		0x80046b8a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_pft_rgn_dirt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_pft_utp_chr
		"pft_utp_chr detected failure counter decrement"
		VALUE
		0x80058352
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_pft_utp_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_pft_utp_h
		"pft_utp high signal detected failure counter decrement"
		VALUE
		0x80058350
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_pft_utp_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_pft_utp_l
		"pft_utp low signal detected failure counter decrement"
		VALUE
		0x8005834e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_pft_utp_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_pft_utp_neg_err
		"CSF upstream temperature regulation negative error detected failure counter decrement"
		VALUE
		0x80044c4c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_pft_utp_neg_err 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_pft_utp_pos_err
		"CSF upstream temperature regulation positive error detected failure counter decrement"
		VALUE
		0x80044c4a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_pft_utp_pos_err 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_rup_dirt_lkg
		"Pftrelprs sensor dynamic plausibility detected failure counter decrement"
		VALUE
		0x800580c4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_rup_dirt_lkg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_rup_nok
		"Pftrelprs sensor static plausibilty detected failure counter decrement"
		VALUE
		0x800580c2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_rup_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_amp_h
		"Ambient pressure sensor high signal detected failure counter decrement"
		VALUE
		0x800576a4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_amp_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_amp_l
		"Ambient pressure sensor low signal detected failure counter decrement"
		VALUE
		0x800576a2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_amp_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_emtv_nok
		"a_in_asi_egr_evpos/ EMTV Sensor detected failure counter decrement"
		VALUE
		0x80056fa2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_emtv_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ex_prs_h
		"Ex man pres sens high signal detected failure counter decrement"
		VALUE
		0x80057dc6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ex_prs_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ex_prs_l
		"Ex man pres sens low signal detected failure counter decrement"
		VALUE
		0x80057dc4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ex_prs_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_it_nok
		"a_in_asi_iti_itpos/ IT Sensor detected failure counter decrement"
		VALUE
		0x80057cfc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_it_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_maf_h
		"Mass air flow sensor high drift diagnostic detected failure counter decrement"
		VALUE
		0x80057410
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_maf_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_maf_l
		"Mass air flow sensor low drift diagnostic detected failure counter decrement"
		VALUE
		0x8005740e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_maf_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_map_h
		"Manifold pressure sensor high signal detected failure counter decrement"
		VALUE
		0x800577b2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_map_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_map_l
		"Manifold pressure sensor low signal detected failure counter decrement"
		VALUE
		0x800577b0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_map_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_rup_h
		"Pftrelprs sensor SRC high detected failure counter decrement"
		VALUE
		0x800580c0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_rup_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_rup_l
		"Pftrelprs sensor SRC low detected failure counter decrement"
		VALUE
		0x800580be
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_rup_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_tco
		"engine cooling temperature sensor detected failure counter decrement"
		VALUE
		0x8005843c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_tco 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcomcsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_tco_sig_mcut
		"Engine cooling temperature sensor momentarily implausible or discontinuous diagnostic detected failure counter decrement"
		VALUE
		0x800583e4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_tco_sig_mcut 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_tia_h
		"Intake air temperature high signal detected failure counter  decrement"
		VALUE
		0x800578ce
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_tia_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_tia_l
		"Intake air temperature low signal detected failure counter decrement"
		VALUE
		0x800578cc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_tia_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ups_heat_oc
		"Heater powerstage OC detected failure counter decrement"
		VALUE
		0x80040134
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ups_heat_oc 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ups_heat_ovh
		"Transistor heater powerstage overheating detected failure counter decrement"
		VALUE
		0x80040132
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ups_heat_ovh 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ups_heat_scg
		"Heater powerstage SCG detected failure counter decrement"
		VALUE
		0x80040130
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ups_heat_scg 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ups_heat_scw
		"Heater powerstage SCW detected failure counter decrement"
		VALUE
		0x8004012e
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ups_heat_scw 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ups_lamb_oc
		"Nerst cell OC detected failure counter decrement"
		VALUE
		0x800583de
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ups_lamb_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ups_pump_oc
		"Pump current IP OC detected failure counter decrement"
		VALUE
		0x800583dc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ups_pump_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ups_virt_oc
		"Virtual ground OC detected failure counter decrement"
		VALUE
		0x800583da
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ups_virt_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ups_wire_scg
		"Sensor lines SCG detected failure counter decrement"
		VALUE
		0x800583d8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ups_wire_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_sens_ups_wire_scw
		"Sensor lines SCW detected failure counter decrement"
		VALUE
		0x800583d6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_sens_ups_wire_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_spg_cmd_blk_clos
		"Turbine negative deviation detected failure counter decrement"
		VALUE
		0x8005d03e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_spg_cmd_blk_clos 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_spg_reg_apl_down
		"Turbocharger negative deviation detected failure counter decrement"
		VALUE
		0x8005d03c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_spg_reg_apl_down 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_spg_reg_apl_up
		"Turbocharger positive deviation detected failure counter decrement"
		VALUE
		0x8005d03a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_spg_reg_apl_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_tbf_fct_apl_down
		"temperature before particulate filter too low detected failure counter decrement"
		VALUE
		0x8004011c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_tbf_fct_apl_down 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_tbf_fct_apl_up
		"temperature before particulate filter too high detected failure counter decrement"
		VALUE
		0x8004011a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_tbf_fct_apl_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_tbt_chr
		"tbt_chr detected failure counter decrement"
		VALUE
		0x8005837a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_tbt_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_tbt_h
		"tbt high signal diagnostic detected failure counter decrement"
		VALUE
		0x80058378
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_tbt_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_tbt_l
		"tbt low signal diagnostic detected failure counter decrement"
		VALUE
		0x80058376
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_tbt_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_tbt_reg_apl_up
		"TBT too hot detected failure counter decrement"
		VALUE
		0x80049802
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_tbt_reg_apl_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_tbt_reg_neg_err
		"TBT cold detected failure counter decrement"
		VALUE
		0x80049800
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_tbt_reg_neg_err 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_thpl_cmd1_oc
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 1 Control Circuit detected failure counter decrement"
		VALUE
		0x8005902e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_thpl_cmd1_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_thpl_cmd1_scg
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 1 Control Circuit detected failure counter decrement"
		VALUE
		0x8005902c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_thpl_cmd1_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_thpl_cmd1_scw
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 1 Control Circuit detected failure counter decrement"
		VALUE
		0x8005902a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_thpl_cmd1_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_thpl_cmd2_oc
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 2 Control Circuit detected failure counter decrement"
		VALUE
		0x80059028
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_thpl_cmd2_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_thpl_cmd2_scg
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 2 Control Circuit detected failure counter decrement"
		VALUE
		0x80059026
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_thpl_cmd2_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_thpl_cmd2_scw
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 2 Control Circuit detected failure counter decrement"
		VALUE
		0x80059024
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_thpl_cmd2_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_thpl_cmd3_oc
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 3 Control Circuit detected failure counter decrement"
		VALUE
		0x80059022
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_thpl_cmd3_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_thpl_cmd3_scg
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 3 Control Circuit detected failure counter decrement"
		VALUE
		0x80059020
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_thpl_cmd3_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_thpl_cmd3_scw
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 3 Control Circuit detected failure counter decrement"
		VALUE
		0x8005901e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_thpl_cmd3_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_unk_thpl1_chr
		"a_ou_clo_coo_diagthp_xxx_xx_x_a/thpl coherence set of snapshot data identifiers"
		VALUE
		0x8005908e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_unk_thpl1_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_unk_thpl2_chr
		"Thpl 2 coherence detected failure counter decrement"
		VALUE
		0x8005908c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_unk_thpl2_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_unk_thpl3_chr
		"Thpl 3 coherence detected failure counter decrement"
		VALUE
		0x8005908a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_unk_thpl3_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_unk_thpl4_chr
		"Thpl 4 coherence detected failure counter decrement"
		VALUE
		0x80059088
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_unk_thpl4_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_unk_thpl_chr
		"Thpl coherence detected failure counter decrement"
		VALUE
		0x80059086
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_unk_thpl_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ups_ecu_chr
		"Internal resistance of the sensor outside an expected range during the calibration detected failure counter decrement"
		VALUE
		0x800583d4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ups_ecu_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ups_ecu_itl
		"Defect code for SPI-chip monitoring detected failure counter decrement"
		VALUE
		0x800583d2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ups_ecu_itl 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ups_ecu_oor
		"Analog signal for the O2 ratio from the sensor outside an expected range during the calibration detected failure counter decrement"
		VALUE
		0x800583d0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ups_ecu_oor 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upsdgxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ups_ro2_oor
		"Upstream sensor heating control deviation detected failure counter decrement"
		VALUE
		0x800583be
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ups_ro2_oor 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upsdgxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ups_ro2_slow_trs
		"Richness signal rising time detected failure counter decrement"
		VALUE
		0x800583bc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ups_ro2_slow_trs 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ups_tip_oor
		"Sensitive element temperature outside the expected range (overheating ou underheating) detected failure counter decrement"
		VALUE
		0x8004012c
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ups_tip_oor 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upsdgxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_ups_uo2_oor
		"Analog signal for the O2 ratio outside an expected range detected failure counter decrement"
		VALUE
		0x800583ba
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_ups_uo2_oor 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_vb_h
		"Battery voltage above max threshold detected failure counter decrement"
		VALUE
		0x80058aac
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_vb_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_vb_l
		"Battery voltage below min threshold detected failure counter decrement"
		VALUE
		0x80058aaa
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_vb_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_vb_rly_oc_scg
		"Open circuit or short circuit to ground on main relay detected failure counter decrement"
		VALUE
		0x80058aa8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_vb_rly_oc_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_vb_rly_scw
		"Short circuit to battery on main relay detected failure counter decrement"
		VALUE
		0x80058aa6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_vb_rly_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_vnt_h
		"VNT electrovalve high signal detected failurea counter decrement"
		VALUE
		0x800400ea
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_vnt_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_vnt_l
		"VNT electrovalve low signal detected failurea counter decrement"
		VALUE
		0x800400e8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_vnt_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_wpmp_tcr_blk
		"ou_clo_coo_paotxxx/unable to move the component to the commanded position of turbo water pump detected failure counter"
		VALUE
		0x800590ee
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_wpmp_tcr_blk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_wpmp_tcr_oc
		"ou_clo_coo_paotxxx/Circuit Open of turbo water pump detected failure counter decrement"
		VALUE
		0x800590ec
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_wpmp_tcr_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_wpmp_tcr_scg
		"ou_clo_coo_paotxxx/Circuit Short to Ground of turbo water pump detected failure counter decrement"
		VALUE
		0x800590ea
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_wpmp_tcr_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfdec_wpmp_tcr_scw
		"ou_clo_coo_paotxxx/Circuit Short to Battery of turbo water pump detected failure counter decrement"
		VALUE
		0x800590e8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfdec_wpmp_tcr_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ac_prs
		"Sensor Detected Failure Counter Increment"
		VALUE
		0x80058a76
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ac_prs 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_acel_pdl_chr
		"Accelerator pedal consistency detected failure counter increment"
		VALUE
		0x800587a2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_acel_pdl_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_acel_pdl_tot
		"Total loss of accelerator pedal detected failure counter increment"
		VALUE
		0x800587a0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_acel_pdl_tot 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_acel_pdl_v1
		"Accelerator pedal track 1 detected failure counter increment"
		VALUE
		0x8005879e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_acel_pdl_v1 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_acel_pdl_v2
		"Accelerator pedal track 2 detected failure counter increment"
		VALUE
		0x8005879c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_acel_pdl_v2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_agb_data
		"AGB data detected failure counter increment"
		VALUE
		0x80058774
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_agb_data 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_agb_no_frm
		"AGB Missing Message detected failure counter increment"
		VALUE
		0x80058772
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_agb_no_frm 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_amp_reg_chr
		""
		VALUE
		0x800576a0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_amp_reg_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_bgin_clu_cmp
		"Incoherence between clutch information detected failure counter increment."
		VALUE
		0x80059138
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_bgin_clu_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_bgin_clu_nok
		"Wire begin clutch contactor detected failure counter increment"
		VALUE
		0x8006b230
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_bgin_clu_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_brk_pdl_cmp
		"Incoherence between brake information detected failure counter increment."
		VALUE
		0x80059136
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_brk_pdl_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_cata_nok_cge
		"Lack efficiency of oxidation catalyst detected failure counter increment"
		VALUE
		0x80043c08
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_AtCatDgn_OneToOne
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_cata_nok_cge 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_seclcxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_clu_cnt_nok
		"a_in_pci_dls_seclcxx/Clutch contactors detected failure counter increment"
		VALUE
		0x8005884e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_clu_cnt_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_crk_chr
		"no cranshaft reference detection detected failure counter increment"
		VALUE
		0x80058906
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_crk_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_crk_cmp
		"Incorrect number of crankshaft teeth detected failure counter increment"
		VALUE
		0x80058904
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_crk_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_crk_cyc
		"Interference between two crankshaft teeth detected failure counter increment"
		VALUE
		0x80058902
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_crk_cyc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_crk_no_sig
		"no crankshaft signal detected failure counter increment"
		VALUE
		0x80058900
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_crk_no_sig 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_crk_oc
		"Open circuit of one of the leads of crankshaft sensor detected failure counter increment"
		VALUE
		0x800588fe
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_crk_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_crk_shp
		"No detection of crankshaft reference detected failure counter increment"
		VALUE
		0x800588fc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_crk_shp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_cru_cmp
		"Cruise control safety detected failure counter increment."
		VALUE
		0x80059134
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_cru_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_cru_sl_swi_chr
		"Cruise Control Main Switch Coherence detected failure counter increment"
		VALUE
		0x80058800
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_cru_sl_swi_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_cru_sl_tot
		"Cruise control and speed limiter common failures Detected Failure Counter Increment"
		VALUE
		0x8005915c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_cru_sl_tot 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_cru_vs_cmp
		"CC/SL mux vehicle speed coherence Detected Failure Counter Increment"
		VALUE
		0x800401be
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_cru_vs_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_cru_whl_cmd
		"Cruise Control Steering Wheel Command Switch Detected Failure Counter Increment"
		VALUE
		0x800587fe
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_cru_whl_cmd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_cru_whl_cmd_nok
		"CCSL steering wheel switches blocked button detected failure counter increment"
		VALUE
		0x800587fc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_cru_whl_cmd_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_doc1_utp_chr
		"doc1_utp_chr_detected failure counter increment"
		VALUE
		0x80058120
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_doc1_utp_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_doc1_utp_h
		"doc1_utp_h detected failure counter increment"
		VALUE
		0x8005811e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_doc1_utp_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_doc1_utp_pup_l
		"doc1_utp_l detected failure counter increment in pull up case"
		VALUE
		0x8005811c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_doc1_utp_pup_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_doc1_utp_wio_pup_l
		"doc1_utp_l detected failure counter increment without pull up"
		VALUE
		0x8005811a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_doc1_utp_wio_pup_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_diaginj_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_efi_inj_oc
		"efi_inj_oc detected failure counter increment"
		VALUE
		0x80058f1c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_efi_inj_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_diaginj_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_efi_inj_scg
		"efi_inj_scg detected failure counter increment"
		VALUE
		0x80058f1a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_efi_inj_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_diaginj_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_efi_inj_scw
		"efi_inj_scw detected failure counter increment"
		VALUE
		0x80058f18
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_efi_inj_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_efi_sldv_oc
		"efi_sldv_oc detected failure counter increment"
		VALUE
		0x80058f10
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_efi_sldv_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_efi_sldv_scg
		"efi_sldv_scg detected failure counter increment"
		VALUE
		0x80058f0e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_efi_sldv_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_efi_sldv_scw
		"efi_sldv_scw detected failure counter increment"
		VALUE
		0x80058f0c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_efi_sldv_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_egr_byp_blk
		"EGR bypass blocked detected failure counter increment"
		VALUE
		0x80043af0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_egr_byp_blk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_bypxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_egr_byp_h
		"EGR bypass high signal detected failure counter increment"
		VALUE
		0x80058ac2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_egr_byp_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_bypxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_egr_byp_l
		"EGR bypass low signal detected failure counter increment"
		VALUE
		0x80058ac0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_egr_byp_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_emtv_flow_meca
		"Blocked emtv during full closing request (OBD failure) detected failure counter increment"
		VALUE
		0x80058b16
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_emtv_flow_meca 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_emtv_hbdg_el
		"EMTV power supply (Hbridge) detected failure counter increment"
		VALUE
		0x80058b14
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_emtv_hbdg_el 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_emtv_hbdg_ovh
		"EMTV power supply (Hbridge overheat) detected failure counter increment"
		VALUE
		0x80058b12
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_emtv_hbdg_ovh 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_emtv_ofs_no_norm
		"First offset learning detected failure counter increment"
		VALUE
		0x80058b10
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_emtv_ofs_no_norm 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_emtv_reg_blk
		"Blocked EMTV during regulation detected failure counter increment"
		VALUE
		0x80058b0e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_emtv_reg_blk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_emtv_reg_blk_open
		"Blocked emtv during full closing request detected failure counter increment"
		VALUE
		0x80058b0c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_emtv_reg_blk_open 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_emtv_reg_dirt
		"Dirty EMTV near the closed thrust detected failure counter increment"
		VALUE
		0x80058b0a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_emtv_reg_dirt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_esp_data_chr
		"ESP data torque request coherency detected failure counter increment"
		VALUE
		0x80058874
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_esp_data_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_esp_data_seq_ctr
		"ESP data frame sequence counter detected failure counter increment"
		VALUE
		0x80058872
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_esp_data_seq_ctr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_esp_no_frm
		"ESP Missing Message detected failure counter increment"
		VALUE
		0x80058870
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_esp_no_frm 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ex_prs_no_lk
		"Ex man pres sens no link detected failure counter increment"
		VALUE
		0x80057dc2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ex_prs_no_lk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_in_cam_chr
		"intake camshaft signal incoherency detected failure counter increment"
		VALUE
		0x800588f0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_in_cam_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_in_cam_crk_cmp
		"incoherency between intake camshaft signal and crankshaft signal detected failure counter increment"
		VALUE
		0x800588ee
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_in_cam_crk_cmp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_in_cam_cyc
		"Interference close to a intake camshaft edge detected failure counter increment"
		VALUE
		0x800588ec
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_in_cam_cyc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_in_cam_no_sig
		"no intake camshaft signal detected failure counter increment"
		VALUE
		0x800588ea
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_in_cam_no_sig 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_in_cam_nok
		"Camshaft signal invalid for synchronisation detected failure counter increment"
		VALUE
		0x800588e8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_in_cam_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ip_lght_tco_ovh
		"ou_clo_coo_clatoxx/Warning over heating lamp detected failure counter increment"
		VALUE
		0x80059052
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ip_lght_tco_ovh 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_it_hbdg_el
		"a_ou_aso_ito_itdiag/IT Power Supply detected failure counter increment"
		VALUE
		0x80058c5a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_it_hbdg_el 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_it_hbdg_ovh
		"a_ou_aso_ito_itdiag/IT Power Supply detected failure counter increment"
		VALUE
		0x80058c58
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_it_hbdg_ovh 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_it_ofs_no_norm
		"a_ou_aso_ito_itdiag/IT First Offset detected failure counter increment"
		VALUE
		0x80058c56
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_it_ofs_no_norm 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_it_reg_blk
		"a_ou_aso_ito_itdiagx/Blocked IT during regulation detected failure counter increment"
		VALUE
		0x80058c54
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_it_reg_blk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_it_reg_blk_clos
		"a_ou_aso_ito_itdiag/IT regulation detected failure counter increment"
		VALUE
		0x80058c52
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_it_reg_blk_clos 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_it_reg_blk_open
		"a_ou_aso_ito_itdiag/IT regulation detected failure counter increment"
		VALUE
		0x80058c50
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_it_reg_blk_open 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_it_reg_dirt
		"a_ou_aso_ito_itdiag/IT regulation detected failure counter increment"
		VALUE
		0x80058c4e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_it_reg_dirt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_maf_reg_neg_err
		"MAF regulation negative error detected failure counter increment"
		VALUE
		0x80043b60
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_maf_reg_neg_err 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_mafs_apl_down
		"Mass air flow sensor low drift diagnostic detected failure counter increment"
		VALUE
		0x800573f6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_mafs_apl_down 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_mafs_apl_up
		"Mass air flow sensor high drift diagnostic detected failure counter increment"
		VALUE
		0x800573f4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_mafs_apl_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_map_nok_apc
		"Manifold pressure sensor nok during APC detected failure counter increment"
		VALUE
		0x800577ae
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_map_nok_apc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_map_nok_isr
		"Manifold pressure sensor nok during ISR detected failure counter increment"
		VALUE
		0x800577ac
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_map_nok_isr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_oil_dil_nok
		"a_cl_lub_wea_oildilx_xxx_xx_d_a / Oil dilution overshoot diagnostic trouble code (device or function identifier)"
		VALUE
		0x80055298
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OneToOne
		0
		65535
    DISPLAY_IDENTIFIER Cxx_dfinc_oil_dil_nok 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_dirt
		"Overloaded CSF detected failure counter increment"
		VALUE
		0x80045f74
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_dirt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_dirt_lkg
		"Load CSF detected failure counter increment"
		VALUE
		0x80046432
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_dirt_lkg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'stubb.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_dp_chr
		"Engine stopped plausibility of CSF Pdiff detected failure counter increment"
		VALUE
		0x80041538
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_dp_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'stubb.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_dp_dirt_lkg
		""
		VALUE
		0x8004153a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_dp_dirt_lkg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_no_lk
		"Broken CSF detected failure counter increment"
		VALUE
		0x80045d86
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_no_lk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_nok_cge
		"Malfunctioning CSF detected failure counter increment."
		VALUE
		0x80045fde
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_nok_cge 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_nok_cge_zon_1
		"Malfunctioning CSF detected failure counter increment for Zone 1"
		VALUE
		0x80045fdc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_nok_cge_zon_1 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_nok_cge_zon_2
		"Malfunctioning CSF detected failure counter increment for Zone 2"
		VALUE
		0x80045fda
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_nok_cge_zon_2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_nok_cge_zon_3
		"Malfunctioning CSF detected failure counter increment for Zone 3"
		VALUE
		0x80045fd8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_nok_cge_zon_3 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_nok_cge_zon_4
		"Malfunctioning CSF detected failure counter increment for Zone 4"
		VALUE
		0x80045fd6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_nok_cge_zon_4 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_rgn_dirt
		"Maximum regenration error reached detected failure counter increment"
		VALUE
		0x80046b88
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_rgn_dirt 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_utp_chr
		"pft_utp_chr detected failure counter increment"
		VALUE
		0x8005834c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_utp_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_utp_fast_dev_l
		"pft_utp low signal detected failure counter increment in fast deviation"
		VALUE
		0x8005834a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_utp_fast_dev_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_utp_h
		"pft_utp high signal detected failure counter increment"
		VALUE
		0x80058348
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_utp_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_utp_neg_err
		"CSF upstream temperature regulation negative error detected failure counter increment"
		VALUE
		0x80044c48
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_utp_neg_err 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_utp_pos_err
		"CSF upstream temperature regulation positive error detected failure counter increment"
		VALUE
		0x80044c46
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_utp_pos_err 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_utp_pup_l
		"pft_utp low signal detected failure counter increment in pull up case"
		VALUE
		0x80058346
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_utp_pup_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_pft_utp_wio_pup_l
		"pft_utp low signal detected failure counter increment without pull up"
		VALUE
		0x80058344
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_pft_utp_wio_pup_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_rup_dirt_lkg
		"Pftrelprs sensor dynamic plausibility detected failure counter increment"
		VALUE
		0x800580bc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_rup_dirt_lkg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_rup_nok
		"Pftrelprs sensor nok detected failure counter increment"
		VALUE
		0x800580ba
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_rup_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_amp_h
		"Ambient pressure sensor high signal detected failure counter increment"
		VALUE
		0x8005769e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_amp_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_amp_l
		"Ambient pressure sensor low signal detected failure counter increment"
		VALUE
		0x8005769c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_amp_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_emtv_nok
		"a_in_asi_egr_evpos/ EMTV Sensor detected failure counter increment"
		VALUE
		0x80056fa0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_emtv_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ex_prs_h
		"Ex man pres sens high signal detected failure counter increment"
		VALUE
		0x80057dc0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ex_prs_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ex_prs_l
		"Ex man pres sens low signal detected failure counter increment"
		VALUE
		0x80057dbe
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ex_prs_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_it_nok
		"a_in_asi_iti_itpos/ IT Sensor detected failure counter increment"
		VALUE
		0x80057cfa
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_it_nok 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_maf_h
		"Mass air flow sensor high drift diagnostic detected failure counter increment"
		VALUE
		0x8005740c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_maf_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_maf_l
		"Mass air flow sensor low drift diagnostic detected failure counter increment"
		VALUE
		0x8005740a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_maf_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_map_h
		"Manifold pressure sensor high signal detected failure counter increment"
		VALUE
		0x800577aa
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_map_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_map_l
		"Manifold pressure sensor low signal detected failure counter increment"
		VALUE
		0x800577a8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_map_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'stubb.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_pft_dp_oor
		"DP sensor open circuit on the ground wire detected failure counter decrement"
		VALUE
		0x8004153c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_pft_dp_oor 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_rup_h
		"Pftrelprs sensor SRC high detected failure counter increment"
		VALUE
		0x800580b8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_rup_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_rup_l
		"Pftrelprs sensor SRC low detected failure counter increment"
		VALUE
		0x800580b6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_rup_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_tco
		"engine cooling temperature sensor detected failure counter increment"
		VALUE
		0x8005843a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_tco 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcomcsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_tco_sig_mcut
		"Engine cooling temperature sensor momentarily implausible or discontinuous diagnostic detected failure counter increment"
		VALUE
		0x800583e2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_tco_sig_mcut 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_tia_h
		"Intake air temperature high signal detected failure counter increment"
		VALUE
		0x800578ca
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_tia_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_tia_l
		"Intake air temperature low signal detected failure counter increment"
		VALUE
		0x800578c8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_tia_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ups_heat_oc
		"Heater powerstage OC detected failure counter increment"
		VALUE
		0x8004012a
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ups_heat_oc 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ups_heat_ovh
		"Transistor heater powerstage overheating detected failure counter increment"
		VALUE
		0x80040128
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ups_heat_ovh 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ups_heat_scg
		"Heater powerstage SCG detected failure counter increment"
		VALUE
		0x80040126
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ups_heat_scg 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ups_heat_scw
		"Heater powerstage SCW detected failure counter increment"
		VALUE
		0x80040124
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ups_heat_scw 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ups_lamb_oc
		"Nerst cell OC detected failure counter increment"
		VALUE
		0x800583ce
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ups_lamb_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ups_pump_oc
		"Pump current IP OC detected failure counter increment"
		VALUE
		0x800583cc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ups_pump_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ups_virt_oc
		"Virtual ground OC detected failure counter increment"
		VALUE
		0x800583ca
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ups_virt_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ups_wire_scg
		"Sensor lines SCG detected failure counter increment"
		VALUE
		0x800583c8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ups_wire_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_sens_ups_wire_scw
		"Sensor lines SCW detected failure counter increment"
		VALUE
		0x800583c6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_sens_ups_wire_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_spg_cmd_blk_clos
		"Turbine negative deviation detected failure counter increment"
		VALUE
		0x8005d038
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_spg_cmd_blk_clos 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_spg_reg_apl_down
		"Turbocharger negative deviation detected failure counter increment"
		VALUE
		0x8005d036
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_spg_reg_apl_down 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_spg_reg_apl_up
		"Turbocharger positive deviation detected failure counter increment"
		VALUE
		0x8005d034
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_spg_reg_apl_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_tbf_fct_apl_down
		"temperature before particulate filter too low detected failure counter increment"
		VALUE
		0x80040118
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_tbf_fct_apl_down 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_tbf_fct_apl_up
		"temperature before particulate filter high low detected failure counter increment"
		VALUE
		0x80040116
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_tbf_fct_apl_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_tbt_chr
		"tbt_chr detected failure counter increment"
		VALUE
		0x80058374
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_tbt_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_tbt_h
		"tbt high signal diagnostic detected failure counter increment"
		VALUE
		0x80058372
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_tbt_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_tbt_pup_l
		"tbt low signal detected failure counter increment in pull up case"
		VALUE
		0x80058370
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_tbt_pup_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_tbt_reg_apl_up
		"a_cb_cor_tbt_tbtrxxx_xxx_xx_d_a/5_Governor_Diagnosis TBT too hot detected failure counter increment"
		VALUE
		0x800497fe
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_tbt_reg_apl_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_tbt_reg_neg_err
		"a_cb_cor_tbt_tbtrxxx_xxx_xx_d_a/5_Governor_Diagnosis TBT cold detected failure counter increment"
		VALUE
		0x800497fc
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_tbt_reg_neg_err 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_tbt_wio_pup_l
		"tbt low signal detected failure counter increment without pull up"
		VALUE
		0x8005836e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_tbt_wio_pup_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_thpl_cmd1_oc
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 1 Control Circuit detected failure counter increment"
		VALUE
		0x8005901c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_thpl_cmd1_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_thpl_cmd1_scg
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 1 Control Circuit detected failure counter increment"
		VALUE
		0x8005901a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_thpl_cmd1_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_thpl_cmd1_scw
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 1 Control Circuit detected failure counter increment"
		VALUE
		0x80059018
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_thpl_cmd1_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_thpl_cmd2_oc
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 2 Control Circuit detected failure counter increment"
		VALUE
		0x80059016
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_thpl_cmd2_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_thpl_cmd2_scg
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 2 Control Circuit detected failure counter increment"
		VALUE
		0x80059014
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_thpl_cmd2_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_thpl_cmd2_scw
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 2 Control Circuit detected failure counter increment"
		VALUE
		0x80059012
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_thpl_cmd2_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_thpl_cmd3_oc
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 3 Control Circuit detected failure counter increment"
		VALUE
		0x80059010
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_thpl_cmd3_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_thpl_cmd3_scg
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 3 Control Circuit detected failure counter increment"
		VALUE
		0x8005900e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_thpl_cmd3_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_thpl_cmd3_scw
		"a_ou_clo_coo_chvcmdx/Thermoplunger Relay 3 Control Circuit detected failure counter increment"
		VALUE
		0x8005900c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_thpl_cmd3_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_unk_thpl1_chr
		"Thpl 1 coherence detected failure counter increment"
		VALUE
		0x80059084
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_unk_thpl1_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_unk_thpl2_chr
		"Thpl 2 coherence detected failure counter increment"
		VALUE
		0x80059082
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_unk_thpl2_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_unk_thpl3_chr
		"Thpl 3 coherence detected failure counter inc"
		VALUE
		0x80059080
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_unk_thpl3_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_unk_thpl4_chr
		"Thpl 4 coherence detected failure counter increment"
		VALUE
		0x8005907e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_unk_thpl4_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_unk_thpl_chr
		"Thpl coherence detected failure counter increment"
		VALUE
		0x8005907c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_unk_thpl_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ups_ecu_chr
		"Internal resistance of the sensor outside an expected range during the calibration detected failure counter increment"
		VALUE
		0x800583c4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ups_ecu_chr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ups_ecu_itl
		"Defect code for SPI-chip monitoring detected failure counter increment"
		VALUE
		0x800583c2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ups_ecu_itl 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ups_ecu_oor
		"Analog signal for the O2 ratio from the sensor outside an expected range during the calibration detected failure counter increment"
		VALUE
		0x800583c0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ups_ecu_oor 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upsdgxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ups_ro2_oor
		"Upstream sensor heating control deviation detected failure counter increment"
		VALUE
		0x800583b8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ups_ro2_oor 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upsdgxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ups_ro2_slow_trs
		"Richness signal rising time detected failure counter increment"
		VALUE
		0x800583b6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ups_ro2_slow_trs 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ups_tip_oor
		"Sensitive element temperature outside the expected range detected failure counter increment"
		VALUE
		0x80040122
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_OuCboUeg_OneToOne_wu
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ups_tip_oor 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upsdgxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_ups_uo2_oor
		"Analog signal for the O2 ratio outside an expected range detected failure counter increment"
		VALUE
		0x800583b4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_ups_uo2_oor 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_vb_h
		"Battery voltage above max threshold detected failure counter increment"
		VALUE
		0x80058aa4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_vb_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_vb_l
		"Battery voltage below min threshold detected failure counter increment"
		VALUE
		0x80058aa2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_vb_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_vb_rly_oc_scg
		"Open circuit or short circuit to ground on main relay detected failure counter increment"
		VALUE
		0x80058aa0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_vb_rly_oc_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_vb_rly_scw
		"Short circuit to battery relay detected failure counter increment"
		VALUE
		0x80058a9e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_vb_rly_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_vnt_h
		"VNT electrovalve high signal detected failurea counter increment"
		VALUE
		0x800400e6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_vnt_h 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_vnt_l
		"VNT electrovalve low signal detected failurea counter increment"
		VALUE
		0x800400e4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_vnt_l 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_wpmp_tcr_blk
		"ou_clo_coo_paotxxx/Unable to move the component to the commanded position of turbo water pump detected failure counter"
		VALUE
		0x800590e6
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_wpmp_tcr_blk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_wpmp_tcr_oc
		"ou_clo_coo_paotxxx/Circuit Open of turbo water pump detected failure counter increment"
		VALUE
		0x800590e4
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_wpmp_tcr_oc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_wpmp_tcr_scg
		"ou_clo_coo_paotxxx/Circuit Short to Ground of turbo water pump detected failure counter increment"
		VALUE
		0x800590e2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_wpmp_tcr_scg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dfinc_wpmp_tcr_scw
		"ou_clo_coo_paotxxx/Circuit Short to Battery of turbo water pump detected failure counter increment"
		VALUE
		0x800590e0
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dfinc_wpmp_tcr_scw 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dft_agb_tq_sp_lim
		"torque limitation applied when a wrong gear request occurs"
		VALUE
		0x80058770
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_dft_agb_tq_sp_lim 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dft_lght_off_tco_thd
		"offset for switching off the alert temperature lamp"
		VALUE
		0x80059050
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_dft_lght_off_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dft_lght_on_tco_thd
		"offset for switching ON the alert temperature lamp"
		VALUE
		0x8005904e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_dft_lght_on_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfz_fac_slop_neg
		"Negative slope of formating factor correction gain"
		VALUE
		0x8005d068
		RSA_RecordLayout_VALUE_UWORD
		327.67
		oztfsAd_CwctBpb_rFDnrpa_1__000a
		-327.67
		0.
    DISPLAY_IDENTIFIER Cxx_dfz_fac_slop_neg 
    FORMAT "%8.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dfz_fac_slop_pos
		"Positive slop of formatting factor correction gain"
		VALUE
		0x8005d066
		RSA_RecordLayout_VALUE_UWORD
		327.67
		FhAkxid_mcktvDd_ysgmcea_1__000a
		0.
		327.67
    DISPLAY_IDENTIFIER Cxx_dfz_fac_slop_pos 
    FORMAT "%7.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dhil_flat_thd
		"Cxx_dhil_flat_thd"
		VALUE
		0x80059768
		RSA_RecordLayout_VALUE_SWORD
		65535
		VA_F_1_p0_13
		-32768
		32767
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_ena_tefi_t
		"Diagnostic time for exhaust line test"
		VALUE
		0x80058dba
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_diag_ena_tefi_t 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_esti_tol_h
		"Max value allowed for drift measure before a high drift failure detection"
		VALUE
		0x800573f2
		RSA_RecordLayout_VALUE_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_diag_esti_tol_h 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_esti_tol_l
		"Min value allowed for drift measure before a low drift failure detection"
		VALUE
		0x800573f0
		RSA_RecordLayout_VALUE_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_diag_esti_tol_l 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_ffig_it_psn_min
		"Minimum ilet throttle measured position to allow ffig routine call"
		VALUE
		0x8006b218
		RSA_RecordLayout_VALUE_UWORD
		100
		Enocvxb_jcbhbrd_pbvbdrc_f_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_diag_ffig_it_psn_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_in_vvtc_tco_max
		"Maximum engine coolant temperature to allow VVT aftersales routine execution"
		VALUE
		0x8006b216
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_diag_in_vvtc_tco_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_in_vvtc_tco_min
		"Minimum engine coolant temperature to allow VVT aftersales routine execution"
		VALUE
		0x8006b214
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_diag_in_vvtc_tco_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_in_vvtc_toil_max
		"Maximum oil temperature to allow VVT aftersales routine execution"
		VALUE
		0x8006b212
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_diag_in_vvtc_toil_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_in_vvtc_toil_min
		"Minimum oil temperature to allow VVT aftersales routine execution"
		VALUE
		0x8006b210
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_diag_in_vvtc_toil_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_in_vvtc_vb_max
		"Maximum battery voltage to allow VVT aftersales routine execution"
		VALUE
		0x8006b20e
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_diag_in_vvtc_vb_max 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_in_vvtc_vb_min
		"Minimum battery voltage to allow VVT aftersales routine execution"
		VALUE
		0x8006b20c
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_diag_in_vvtc_vb_min 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_max_is_n
		"Maximum tuning idle speed setpoint offset authorized"
		VALUE
		0x8005ae68
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_diag_max_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_min_is_n
		"Minimum tuning idle speed setpoint offset authorized"
		VALUE
		0x8005ae66
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_diag_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_diag_nr
		"Diagnostic identification code"
		VALUE
		0x80056f7b
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_diag_nr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_205F_writ_max
		"Maximum value authorized to write on DID $205F"
		VALUE
		0x80056d70
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_did_205F_writ_max 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_205F_writ_min
		"Minimum value authorized to write on DID $205F"
		VALUE
		0x80056d6e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_did_205F_writ_min 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2105_writ_max
		"Maximum value authorized to write on DID $2105"
		VALUE
		0x80056d6d
		RSA_RecordLayout_VALUE_UBYTE
		4
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		5.
    DISPLAY_IDENTIFIER Cxx_did_2105_writ_max 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2105_writ_min
		"Minimum value authorized to write on DID $205F"
		VALUE
		0x80056d6c
		RSA_RecordLayout_VALUE_UBYTE
		4
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		5.
    DISPLAY_IDENTIFIER Cxx_did_2105_writ_min 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_210D_writ_max
		"Maximum value authorized to write on DID $210D"
		VALUE
		0x80056d68
		RSA_RecordLayout_VALUE_ULONG
		65535000
		igqhjec_noAABbd_Eqnyxwb_m_R0ooa
		0.
		65535000.
    DISPLAY_IDENTIFIER Cxx_did_210D_writ_max 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_210D_writ_min
		"Minimum value authorized to write on DID $210D"
		VALUE
		0x80056d64
		RSA_RecordLayout_VALUE_ULONG
		65535000
		igqhjec_noAABbd_Eqnyxwb_m_R0ooa
		0.
		65535000.
    DISPLAY_IDENTIFIER Cxx_did_210D_writ_min 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_210E_writ_max
		"Maximum value authorized to write on DID $210E"
		VALUE
		0x80056d60
		RSA_RecordLayout_VALUE_ULONG
		300000000
		jdkejcd_tjwodjc_Axqyxka_t_A_1oa
		0.
		300000000.
    DISPLAY_IDENTIFIER Cxx_did_210E_writ_max 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_210E_writ_min
		"Minimum value authorized to write on DID $210E"
		VALUE
		0x80056d5c
		RSA_RecordLayout_VALUE_ULONG
		300000000
		jdkejcd_tjwodjc_Axqyxka_t_A_1oa
		0.
		300000000.
    DISPLAY_IDENTIFIER Cxx_did_210E_writ_min 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2113_writ_max
		"Maximum value authorized to write on DID $2113"
		VALUE
		0x80056d5a
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_did_2113_writ_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2113_writ_min
		"Minimum value authorized to write on DID $2113"
		VALUE
		0x80056d58
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_did_2113_writ_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_211C_writ_max
		"Maximum value authorized to write on DID $211C"
		VALUE
		0x80056d54
		RSA_RecordLayout_VALUE_ULONG
		65535000
		igqhjec_noAABbd_Eqnyxwb_m_R0ooa
		0.
		65535000.
    DISPLAY_IDENTIFIER Cxx_did_211C_writ_max 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_211C_writ_min
		"Minimum value authorized to write on DID $211C"
		VALUE
		0x80056d50
		RSA_RecordLayout_VALUE_ULONG
		65535000
		igqhjec_noAABbd_Eqnyxwb_m_R0ooa
		0.
		65535000.
    DISPLAY_IDENTIFIER Cxx_did_211C_writ_min 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_212A_writ_max
		"Maximum value authorized to write on DID $212A"
		VALUE
		0x80056d4f
		RSA_RecordLayout_VALUE_UBYTE
		14
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		15.
    DISPLAY_IDENTIFIER Cxx_did_212A_writ_max 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_212A_writ_min
		"Minimum value authorized to write on DID $212A"
		VALUE
		0x80056d4e
		RSA_RecordLayout_VALUE_UBYTE
		14
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		15.
    DISPLAY_IDENTIFIER Cxx_did_212A_writ_min 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2425_writ_max
		"Maximum value authorized to write on DID $2425"
		VALUE
		0x80056d4c
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2425_writ_max 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2425_writ_min
		"Minimum value authorized to write on DID $2425"
		VALUE
		0x80056d4a
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2425_writ_min 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2426_writ_max
		"Maximum value authorized to write on DID $2426"
		VALUE
		0x80056d48
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2426_writ_max 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2426_writ_min
		"Minimum value authorized to write on DID $2426"
		VALUE
		0x80056d46
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2426_writ_min 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2427_writ_max
		"Maximum value authorized to write on DID $2427"
		VALUE
		0x80056d44
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2427_writ_max 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2427_writ_min
		"Minimum value authorized to write on DID $2427"
		VALUE
		0x80056d42
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2427_writ_min 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2428_writ_max
		"Maximum value authorized to write on DID $2428"
		VALUE
		0x80056d40
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2428_writ_max 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2428_writ_min
		"Minimum value authorized to write on DID $2428"
		VALUE
		0x80056d3e
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2428_writ_min 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2429_writ_max
		"Maximum value authorized to write on DID $2429"
		VALUE
		0x80056d3c
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2429_writ_max 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2429_writ_min
		"Minimum value authorized to write on DID $2429"
		VALUE
		0x80056d3a
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_2429_writ_min 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_242A_writ_max
		"Maximum value authorized to write on DID $242A"
		VALUE
		0x80056d38
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_242A_writ_max 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_242A_writ_min
		"Minimum value authorized to write on DID $242A"
		VALUE
		0x80056d36
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_242A_writ_min 
    FORMAT "%14.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_24C2_writ_max
		"Maximum value authorized to write on DID $24C2"
		VALUE
		0x80056cf8
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_did_24C2_writ_max 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_24C2_writ_min
		"Minimum value authorized to write on DID $24C2"
		VALUE
		0x80056cf6
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_did_24C2_writ_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_24DC_writ_max
		"Maximum value authorized to write on DID $24DC"
		VALUE
		0x80056cf5
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_did_24DC_writ_max 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_24DC_writ_min
		"Minimum value authorized to write on DID $24DC"
		VALUE
		0x80056cf4
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_did_24DC_writ_min 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_24EA_writ_max
		"Maximum value authorized to write on DID $24EA"
		VALUE
		0x80056cf0
		RSA_RecordLayout_VALUE_ULONG
		65535
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_did_24EA_writ_max 
    FORMAT "%11.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_24EA_writ_min
		"Minimum value authorized to write on DID $24EA"
		VALUE
		0x80056cec
		RSA_RecordLayout_VALUE_ULONG
		65535
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_did_24EA_writ_min 
    FORMAT "%11.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_24EC_writ_max
		"Maximum value authorized to write on DID $24EC"
		VALUE
		0x80056ce8
		RSA_RecordLayout_VALUE_ULONG
		100
		xbqgAic_iekFyac_DialEla_f_a999a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_24EC_writ_max 
    FORMAT "%11.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_24EC_writ_min
		"Minimum value authorized to write on DID $24EC"
		VALUE
		0x80056ce4
		RSA_RecordLayout_VALUE_ULONG
		100
		xbqgAic_iekFyac_DialEla_f_a999a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_did_24EC_writ_min 
    FORMAT "%11.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2868_writ_max
		"Maximum value authorized to write on DID $2868"
		VALUE
		0x80056cb8
		RSA_RecordLayout_VALUE_ULONG
		20000
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_did_2868_writ_max 
    FORMAT "%9.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_did_2868_writ_min
		"Minimum value authorized to write on DID $2868"
		VALUE
		0x80056cb4
		RSA_RecordLayout_VALUE_ULONG
		20000
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_did_2868_writ_min 
    FORMAT "%9.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dist_fac_ms_1
		"100 % of distance and xx% of soot mass (hot conditions)"
		VALUE
		0x80046da0
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_dist_fac_ms_1 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dist_fac_ms_2
		"a_at_pft_mng_chgtend/100% of distance and fac of soot mass (cold conditions)"
		VALUE
		0x80046d9f
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_dist_fac_ms_2 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dist_fac_ms_4
		"100% of distance and fac of soot mass (medium thermal regeneration conditions)"
		VALUE
		0x80046d9e
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_dist_fac_ms_4 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_seclcxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dly_chr_bgin_end_clu_cnt
		"Delay to enable the coherency diag due to the different contactors information time refresh"
		VALUE
		0x8005884c
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_dly_chr_bgin_end_clu_cnt 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dly_clu_pdl_use_rtn
		"Delay before stating that the driver retain his foot on clutch pedal and stop declutching"
		VALUE
		0x80058868
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_dly_clu_pdl_use_rtn 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dly_coup_fail
		"Delay to detect a problem on the coupler frame on CAN"
		VALUE
		0x80058853
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_dly_coup_fail 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dly_gear_fail
		"Delay to detect a problem on the gear frame on CAN"
		VALUE
		0x80058852
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_dly_gear_fail 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dly_is_val
		"Delay value in idle speed condition for EMTV failure mode"
		VALUE
		0x80043b70
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_dly_is_val 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dly_neut_gear_act
		"Delay before stating that the driver has engeged the neutral gear and the vehicle is running"
		VALUE
		0x80058866
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_dly_neut_gear_act 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dly_neut_gear_cnt
		"Delay before stating that neutral gear is engaged, taken from neutral gear contactor."
		VALUE
		0x80058864
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_dly_neut_gear_cnt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dly_ovr_val
		"Delay value in overun condition for EMTV failure mode"
		VALUE
		0x80043b6f
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_dly_ovr_val 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dly_pdl_rls
		"Delay before stating that the vehicle is declutched when the begin contactor was activated without a gear change"
		VALUE
		0x80058862
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_dly_pdl_rls 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_amp_lh_val
		"Default atmospheric pressure for Tedoc1 model"
		VALUE
		0x8005813a
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_doc1_amp_lh_val 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_cor_fac_temp_bfr_tbn
		"Corrective coefficient by the derivative of the Temperature before turbine"
		VALUE
		0x80058138
		RSA_RecordLayout_VALUE_SWORD
		2
		Dweusab_Abjlppc_wagagja_kCRa00a
		-1.
		1.
    DISPLAY_IDENTIFIER Cxx_doc1_cor_fac_temp_bfr_tbn 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_cor_th_loss
		"Correction of the thermal loss depending on Wing position"
		VALUE
		0x80058136
		RSA_RecordLayout_VALUE_SWORD
		655.35
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		-327.68
		327.67
    DISPLAY_IDENTIFIER Cxx_doc1_cor_th_loss 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_cor_wht_gaz
		"Corrective Mass for the gas"
		VALUE
		0x80058134
		RSA_RecordLayout_VALUE_UWORD
		6.5535
		Dweusab_Abjlppc_wagagja_kCRa00a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cxx_doc1_cor_wht_gaz 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_th_loss_rd
		"Thermal loss by radiation"
		VALUE
		0x80058132
		RSA_RecordLayout_VALUE_UWORD
		6.5535e-007
		hzphAid_Cwamssa_FDefygd_WC_000a
		0.
		6.5535E-07
    DISPLAY_IDENTIFIER Cxx_doc1_th_loss_rd 
    FORMAT "%13.11" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_dev_min
		"minimum temperature before oxydation 1 deviation"
		VALUE
		0x80058118
		RSA_RecordLayout_VALUE_SWORD
		2400
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_dev_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_h
		"maximum temperature before oxydation 1 for short to ground diagnosis"
		VALUE
		0x80058116
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_h 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_n_min
		"minimum engine speed for diagnosis condition"
		VALUE
		0x80058114
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_n_min 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_n_min_pup
		"minimum engine speed for diagnosis condition in case of pull up commutation"
		VALUE
		0x80058112
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_n_min_pup 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_no_dev_cdn
		"maximum difference between first and current filtered temperature"
		VALUE
		0x80058110
		RSA_RecordLayout_VALUE_SWORD
		2400
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_no_dev_cdn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_tco_min
		"minimum coolant temperature for non deviation diagnosis condition"
		VALUE
		0x8005810e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_tco_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_tco_min_pup
		"minimum engine coolant temperature for diagnosis condition in case of pull up commutation"
		VALUE
		0x8005810c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_tco_min_pup 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_temp_min
		"first break point of temperature before oxydation 1 or minimum possible value"
		VALUE
		0x8005810a
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_temp_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_tqi_min
		"minimum torque indicated for diagnosis condition"
		VALUE
		0x80058108
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_tqi_min 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_diag_tqi_min_pup
		"minimum torque indicated for diagnosis condition in case of pull up commutation"
		VALUE
		0x80058106
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_doc1_utp_diag_tqi_min_pup 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1cs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_utp_ftc
		"Filtering time constant for DOC1 up temperature"
		VALUE
		0x8005812e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_doc1_utp_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_doc1_wht_tbn
		"Mass of material"
		VALUE
		0x80058130
		RSA_RecordLayout_VALUE_UWORD
		65.535
