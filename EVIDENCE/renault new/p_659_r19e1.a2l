	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_inj_dist_rgn_3
		"Table (dep of injectors distance) of soot mass correction on threshold for mini conditions."
		CURVE
		0x80046e5e
		RSA_RecordLayout_CURVE_UWORD
		500
		tupwpzd_utsbzzc_twxawbc_g__1a0a
		-250.
		250.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_inj_dist_rgn_3 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_inj_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_inj_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_tia_mv_1
		"Table (dep of intake temp average value) of mass correction for hot conditions"
		CURVE
		0x80046e4e
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_tia_mv_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_thd
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_ms_rgn_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_tia_mv_2
		"Table (dep of intake temp average value) of mass correction for cold conditions"
		CURVE
		0x80046e3e
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_tia_mv_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_thd
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_ms_rgn_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_tia_mv_3
		"Table (dep of intake temp average value) of mass correction for maximum conditions"
		CURVE
		0x80046e2e
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_tia_mv_3 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_thd
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_ms_rgn_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_tia_mv_4
		"Table (dep of intake temp average value) of mass correction for medium conditions"
		CURVE
		0x80046e1e
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_tia_mv_4 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_thd
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_ms_rgn_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_tia_mv_forc
		"Table (dep of intake temp average value) of mass correction for forced regeneration"
		CURVE
		0x80046e0e
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_tia_mv_forc 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_thd
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_ms_rgn_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_vh_dist_rgn_1
		"Table (dep of vehicle distance) of soot mass correction on threshold for hot conditions."
		CURVE
		0x80046e02
		RSA_RecordLayout_CURVE_UWORD
		500
		tupwpzd_utsbzzc_twxawbc_g__1a0a
		-250.
		250.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_vh_dist_rgn_1 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_vh_dist_rgn_2
		"Table (dep of vehicle distance) of soot mass correction on threshold for cold conditions."
		CURVE
		0x80046df6
		RSA_RecordLayout_CURVE_UWORD
		500
		tupwpzd_utsbzzc_twxawbc_g__1a0a
		-250.
		250.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_vh_dist_rgn_2 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_vh_dist_rgn_3
		"Table (dep of vehicle distance) of soot mass correction on threshold for mini conditions."
		CURVE
		0x80046dea
		RSA_RecordLayout_CURVE_UWORD
		500
		tupwpzd_utsbzzc_twxawbc_g__1a0a
		-250.
		250.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_vh_dist_rgn_3 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_cor_vh_dist_rgn_4
		"Table (dep of vehicle distance) of soot mass correction on threshold for medium conditions."
		CURVE
		0x80046dde
		RSA_RecordLayout_CURVE_UWORD
		500
		tupwpzd_utsbzzc_twxawbc_g__1a0a
		-250.
		250.
    DISPLAY_IDENTIFIER Ctp_pft_ms_cor_vh_dist_rgn_4 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_rgn_1
		"Table (dep of CSF efficacity) of soot mass threshold for hot conditions"
		CURVE
		0x80046dd2
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_ms_rgn_1 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_rgn_2
		"Table (dep of CSF efficacity) of soot mass threshold for cold conditions"
		CURVE
		0x80046dc6
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_ms_rgn_2 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_rgn_3
		"Table (dep of CSF efficacity) of soot mass threshold for mini conditions"
		CURVE
		0x80046dba
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_ms_rgn_3 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_rgn_4
		"Table (dep of CSF efficacity) of soot mass threshold for medium thermal regeneration conditions"
		CURVE
		0x80046dae
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_ms_rgn_4 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_rgn_forc
		"Table (dep of CSF efficacity) of soot mass threshold for forced regeneration"
		CURVE
		0x80046da2
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_ms_rgn_forc 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_thd
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_stop
		"Mass for end of regeneration"
		CURVE
		0x80067fb8
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_ms_stop 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_efy_ms_stop */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_efy_ms_stop */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_efy_ms_stop */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_efy_ms_stop */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_efy_ms_stop */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct_comb
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			6
			0.
			200.
        AXIS_PTS_REF Ctb_pft_efy_ms_stop 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_wait_cdn
		"Table (dep of vehicle mileage) of soot mass threshold for waiting combustion mode"
		CURVE
		0x80046d24
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_ms_wait_cdn 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_wait_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_wait_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_wait_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_wait_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_wait_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_wait_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_ms_wait_cdn_cor_tia
		"Soot mass correction in waiting mode factor depending onn inlet ai temperature"
		CURVE
		0x80046d18
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_pft_ms_wait_cdn_cor_tia 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_wait_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_wait_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_wait_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_wait_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_wait_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_out
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_wait_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_n_tqi_sp_oil_eva
		"table of oil evaporation fraction to compute oil dilution saturation"
		CURVE
		0x800552fc
		RSA_RecordLayout_CURVE_UWORD
		655.35
		RB_CONV_Prc
		0.0
		655.35
    DISPLAY_IDENTIFIER Ctp_pft_n_tqi_sp_oil_eva 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_n_oil_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_n_oil_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_n_oil_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_n_oil_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_n_oil_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			RB_CONV_rpm
			15
			0
			16383.75
        AXIS_PTS_REF Ctb_pft_n_oil_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_oil_csm_cor
		"Table of engine oil consumption correction dependent on the engine ware"
		CURVE
		0x80058444
		RSA_RecordLayout_CURVE_UWORD
		65.535
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Ctp_pft_oil_csm_cor 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_vh_dist_oil_csm */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_vh_dist_oil_csm */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_vh_dist_oil_csm */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_vh_dist_oil_csm */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_vh_dist_oil_csm */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_pft_vh_dist_oil_csm 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_t_min_rgn_err_tia
		"Table of correction on minimum time after last regeneration (depend. of corrected air temp)"
		CURVE
		0x80046b9c
		RSA_RecordLayout_CURVE_UWORD
		10
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_pft_t_min_rgn_err_tia 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_dist_min */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_dist_min */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_lh
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_dist_min 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tco_oil_dil_cor
		"oil dilution increment correction depending on coolant temperature"
		CURVE
		0x800552ec
		RSA_RecordLayout_CURVE_UWORD
		65.535
		RB_CONV_Res_001
		0
		65.535
    DISPLAY_IDENTIFIER Ctp_pft_tco_oil_dil_cor 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_oil_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_oil_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_oil_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_oil_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_oil_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil_tco
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_tco_oil_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tco_oil_dil_cor_rij
		"oil dilution speed correction depending on engine intake air temperature"
		CURVE
		0x800552dc
		RSA_RecordLayout_CURVE_UWORD
		65.535
		RB_CONV_Res_001
		0
		65.535
    DISPLAY_IDENTIFIER Ctp_pft_tco_oil_dil_cor_rij 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_oil_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_oil_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_oil_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_oil_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_oil_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_oil_dil_tco
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_tco_oil_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tia_cata_hot
		"Table of coolant temperature depending on intake air temperature"
		CURVE
		0x80067f06
		RSA_RecordLayout_CURVE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Ctp_pft_tia_cata_hot 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_cata_hot */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_cata_hot */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_cata_hot */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_cata_hot */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_cata_hot */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_cata
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			5
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_cata_hot 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tia_chk_temp
		"Table of coolant temperature correction depending on intake air temperature"
		CURVE
		0x80067f68
		RSA_RecordLayout_CURVE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Ctp_pft_tia_chk_temp 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_chk_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_chk_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_chk_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_chk_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_chk_temp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_temp
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			5
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_chk_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tia_cold_cdn
		"Table of coolant temperature correction depending on air temperature ( cold conditions )"
		CURVE
		0x80068140
		RSA_RecordLayout_CURVE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Ctp_pft_tia_cold_cdn 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_cold_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_cold_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_cold_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_cold_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_cold_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			5
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_cold_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tia_forc_rgn
		"Table of coolant temperature correction depending on air temperature ( forced regeneration )"
		CURVE
		0x80068136
		RSA_RecordLayout_CURVE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Ctp_pft_tia_forc_rgn 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_forc_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_forc_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_forc_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_forc_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_forc_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			5
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_forc_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tia_hot_cdn
		"Table of coolant temperature correction depending on air temperature ( hot conditions )"
		CURVE
		0x8006812c
		RSA_RecordLayout_CURVE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Ctp_pft_tia_hot_cdn 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_hot_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_hot_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_hot_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_hot_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_hot_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			5
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_hot_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tia_load_spd_dft_cor
		"Calibration of a multiplicative correction for default soot load speed, depending on mean intake air temperature"
		CURVE
		0x80046cd2
		RSA_RecordLayout_CURVE_UBYTE
		12.75
		yuEqExb_buwnyAb_Fbvbdrc_n_R0ooa
		0.
		12.75
    DISPLAY_IDENTIFIER Ctp_pft_tia_load_spd_dft_cor 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_ms_rgn_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_thd
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_ms_rgn_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tia_med_cdn
		"Table of coolant temperature correction depending on air temperature (medium conditions )"
		CURVE
		0x80068122
		RSA_RecordLayout_CURVE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Ctp_pft_tia_med_cdn 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_med_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_med_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_med_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_med_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_med_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			5
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_med_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tia_oil_dil_spd_cor
		"oil dilution speed correction depending on engine intake air temperature"
		CURVE
		0x800552cc
		RSA_RecordLayout_CURVE_UWORD
		65.535
		RB_CONV_Res_001
		0
		65.535
    DISPLAY_IDENTIFIER Ctp_pft_tia_oil_dil_spd_cor 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_oil_dil_spd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_oil_dil_spd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_oil_dil_spd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_oil_dil_spd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_oil_dil_spd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_tia_oil_dil_spd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tia_oil_dil_spd_rij
		"oil dilution speed correction depending on engine intake air temperature"
		CURVE
		0x800552bc
		RSA_RecordLayout_CURVE_UWORD
		65.535
		RB_CONV_Res_001
		0
		65.535
    DISPLAY_IDENTIFIER Ctp_pft_tia_oil_dil_spd_rij 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_oil_dil_spd_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_oil_dil_spd_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_oil_dil_spd_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_oil_dil_spd_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_oil_dil_spd_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_tia_oil_dil_spd_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_toil_eva_kin_fac_cor
		"oil evaporation kinetic factor correction depending on oil temperature"
		CURVE
		0x800552ac
		RSA_RecordLayout_CURVE_UWORD
		65.535
		RB_CONV_Res_001
		0
		65.535
    DISPLAY_IDENTIFIER Ctp_pft_toil_eva_kin_fac_cor 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil_oil_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil_oil_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil_oil_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil_oil_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil_oil_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_toil_clc
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_toil_oil_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_toil_oil_eva_cor
		"oil evaporation correction depending on oil temperature"
		CURVE
		0x8005529c
		RSA_RecordLayout_CURVE_UWORD
		65.535
		RB_CONV_Res_001
		0
		65.535
    DISPLAY_IDENTIFIER Ctp_pft_toil_oil_eva_cor 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil_oil_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil_oil_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil_oil_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil_oil_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil_oil_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_toil_clc
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_toil_oil_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tt_efi_int
		"Table of dynamic viscosity value for internal enthalpy calculus depending on exhaust fuel injector temeprature"
		CURVE
		0x80058286
		RSA_RecordLayout_CURVE_UWORD
		0.065535
		oiuonjc_ndkeimc_Fgshlla_PCRa0a0
		0.
		0.065535
    DISPLAY_IDENTIFIER Ctp_pft_tt_efi_int 
    FORMAT "%8.6" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tt_efi_int */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tt_efi_int */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tt_efi_int */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tt_efi_int */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tt_efi_int */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tt_k
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			10
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_tt_efi_int 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_tt_efi_int_sph
		"Table of internal thermal conductivity value for internal enthalpy calculus depending on exhaust fuel injector temperature"
		CURVE
		0x80058272
		RSA_RecordLayout_CURVE_UWORD
		65.535
		pkbodxb_tneCdBc_Altqqhc_WKA_0a0
		0.
		65.535
    DISPLAY_IDENTIFIER Ctp_pft_tt_efi_int_sph 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tt_efi_int_sph */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tt_efi_int_sph */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tt_efi_int_sph */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tt_efi_int_sph */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tt_efi_int_sph */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tt_k
			yBrdDAa_dujFjAd_eiepCwc_K__1n0a
			10
			233.
			1473.
        AXIS_PTS_REF Ctb_pft_tt_efi_int_sph 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_utp_inj_fms_wup_slop
		"Table of global injection mass flow slope during CSF warm up"
		CURVE
		0x80043d90
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_pft_utp_inj_fms_wup_slop 
    FORMAT "%2.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_utp_inj_fms_wup_slop */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_utp_inj_fms_wup_slop */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_utp_inj_fms_wup_slop */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_utp_inj_fms_wup_slop */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_utp_inj_fms_wup_slop */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_utp_reg
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			1200.
        AXIS_PTS_REF Ctb_pft_utp_inj_fms_wup_slop 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_vh_dist_cold_ms_tgt
		"Calibration of the soot mass target used when we want to remain under the cold condition mass threshold"
		CURVE
		0x80047100
		RSA_RecordLayout_CURVE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_pft_vh_dist_cold_ms_tgt 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_vh_dist_max_ms_tgt
		"Calibration of maximum soot mass target (mass before which we ask to respect minimum rgn spacing)"
		CURVE
		0x800470f4
		RSA_RecordLayout_CURVE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_pft_vh_dist_max_ms_tgt 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			6
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_vnt_err_reg_max
		"Table of maximum global injection for boost air pressure governor error"
		CURVE
		0x80043d80
		RSA_RecordLayout_CURVE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_pft_vnt_err_reg_max 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_vnt_err_reg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_vnt_err_reg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_vnt_err_reg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_vnt_err_reg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_vnt_err_reg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_reg_spg_err
			BhendBa_Bnmgqnd_blgaFzd_hCRa10a
			8
			-10000.
			10000.
        AXIS_PTS_REF Ctb_pft_vnt_err_reg 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_pft_vs_max_rgn_t
		"Maximum regeneration time"
		CURVE
		0x80067fac
		RSA_RecordLayout_CURVE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Ctp_pft_vs_max_rgn_t 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_max_rgn_t_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_max_rgn_t_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_max_rgn_t_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_max_rgn_t_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_max_rgn_t_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_vs_fil
			uEardjb_BFoibqb_vkamstb_khA_00a
			6
			0.
			655.35
        AXIS_PTS_REF Ctb_pft_max_rgn_t_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_pn_ac_min_is_n
		"Cartography to compute a minimum idle speed for engine needs when AC is active (EGB in neutral mode or MGB)"
		CURVE
		0x8005ae72
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_pn_ac_min_is_n 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_ptqxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ptq_dp_form_fac
		"Curve of form factor for pumping torque calculation. Value is signed,so it can be + or - with losse"
		CURVE
		0x800415e7
		RSA_RecordLayout_CURVE_UBYTE
		9.9609375
		xwqvgta_Fpebsfa_ysaecca_n_Raooa
		0.
		9.9609375
    DISPLAY_IDENTIFIER Ctp_ptq_dp_form_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ptq_dp_form_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ptq_dp_form_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ptq_dp_form_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ptq_dp_form_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ptq_dp_form_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_dp_fil
			BhendBa_Bnmgqnd_blgaFzd_hCRa10a
			10
			-10000.
			10000.
        AXIS_PTS_REF Ctb_ptq_dp_form_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idctrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_raw_p_d_fac
		"Percentage of P torque and D torque considered for the calculation of the raw torque"
		CURVE
		0x8005ab02
		RSA_RecordLayout_CURVE_UWORD
		1
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_raw_p_d_fac 
    FORMAT "%11.9" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_n_dif */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_n_dif */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_n_dif */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_n_dif */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_n_dif */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_dif_n_sp
			cvxuqsa_qeEanfd_gyuanCd_rCRa38a
			8
			-8192.
			8191.75
        AXIS_PTS_REF Ctb_is_n_dif 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_rbst_el_csm_dsb_tco_thd
		"Cartography to compute engine coolant temperature threshold in engine robustness strategy"
		CURVE
		0x8005ce10
		RSA_RecordLayout_CURVE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Ctp_rbst_el_csm_dsb_tco_thd 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_rbst_el_csm_dsb_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_rbst_el_csm_dsb_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_rbst_el_csm_dsb_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_rbst_el_csm_dsb_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_rbst_el_csm_dsb_amp */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			9
			0.
			20000.
        AXIS_PTS_REF Ctb_rbst_el_csm_dsb_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_rps_amp_fac_pr
		"Factor of atmospheric pressure correction for rail pressure during pr"
		CURVE
		0x8004d208
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_rps_amp_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_rps_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_rps_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_rps_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_rps_amp_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_rps_amp_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_rps_amp_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsstax_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_rps_sp_amp_fac_sta
		"Atmospheric pressure dependant factor for rail pressure correction during starting combustion mode"
		CURVE
		0x80068e16
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_rps_sp_amp_fac_sta 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_rps_sp_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_rps_sp_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_rps_sp_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_rps_sp_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_rps_sp_amp_fac_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_rps_sp_amp_fac_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_rps_sp_fac_lim
		"Factor of rail pressure setpoint decrease by fuel temperature"
		CURVE
		0x80068eff
		RSA_RecordLayout_CURVE_UBYTE
		0.99609375
		fsjmcda_jujcsFa_ycbccca_n_Ra6oa
		0.
		0.99609375
    DISPLAY_IDENTIFIER Ctp_rps_sp_fac_lim 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fuel_rps_sp_fac_lim */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fuel_rps_sp_fac_lim */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fuel_rps_sp_fac_lim */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fuel_rps_sp_fac_lim */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fuel_rps_sp_fac_lim */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fuel_temp
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fuel_rps_sp_fac_lim 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_rps_tco_fac_pr
		"Rail pressure's factor of coolant temperature for 3D interpolation during pr"
		CURVE
		0x8004d1f8
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_rps_tco_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_rps_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_rps_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_rps_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_rps_tco_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_rps_tco_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_rps_tco_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_rps_tco_fac_rij
		"Rail pressure's factor of coolant temperature for 3D interpolation"
		CURVE
		0x8004dbaa
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_rps_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_rps_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_rps_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_rps_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_rps_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_rps_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_rps_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_rps_tia_fac_pr
		"Factor of intake air temperature correction for rail pressure during pr"
		CURVE
		0x8004d1e8
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_rps_tia_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_rps_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_rps_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_rps_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_rps_tia_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_rps_tia_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_rps_tia_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_sens_rup_acc
		"Table to take into account the nominal sensor accuracy"
		CURVE
		0x800580c8
		RSA_RecordLayout_CURVE_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Ctp_sens_rup_acc 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sens_rup_acc */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sens_rup_acc */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sens_rup_acc */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sens_rup_acc */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sens_rup_acc */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_raw_sens_pft_rel_up_prs_cor
			BhendBa_Bnmgqnd_blgaFzd_hCRa10a
			10
			-10000.
			10000.
        AXIS_PTS_REF Ctb_sens_rup_acc 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_smk_pft_load_cold_fac
		"Weighting factor on richness offset for takeoff in RIJ mode depending on soot load speed in cold driving condition for PFT"
		CURVE
		0x8004231a
		RSA_RecordLayout_CURVE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_smk_pft_load_cold_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_mv_pos_sot_load_spd
			tqfnykb_zrjpzpb_cvihkvb_gC_o00a
			8
			0.002
			0.35
        AXIS_PTS_REF Ctb_smk_tkof_pft_load_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_smk_pft_load_med_fac
		"Weighting factor on richness offset for takeoff in RIJ mode depending on soot load speed in medium driving condition for PFT"
		CURVE
		0x80042312
		RSA_RecordLayout_CURVE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_smk_pft_load_med_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_mv_pos_sot_load_spd
			tqfnykb_zrjpzpb_cvihkvb_gC_o00a
			8
			0.002
			0.35
        AXIS_PTS_REF Ctb_smk_tkof_pft_load_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_smk_pft_load_nul_fac
		"Weighting factor on richness offset for takeoff in RIJ mode depending on soot load speed in critical driving condition for PFT"
		CURVE
		0x8004230a
		RSA_RecordLayout_CURVE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_smk_pft_load_nul_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_tkof_pft_load_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_mv_pos_sot_load_spd
			tqfnykb_zrjpzpb_cvihkvb_gC_o00a
			8
			0.002
			0.35
        AXIS_PTS_REF Ctb_smk_tkof_pft_load_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_smk_rich_lim_fac_amp_rij
		"Correction factor of richness limitation depending on atmospheric pressure in rij mode"
		CURVE
		0x800422fe
		RSA_RecordLayout_CURVE_UWORD
		8
		EufABca_arlgeCc_grheqod_BCRao0a
		-4.
		4.
    DISPLAY_IDENTIFIER Ctp_smk_rich_lim_fac_amp_rij 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_fac_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_fac_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_fac_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_fac_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_fac_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_smk_rich_lim_fac_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkppxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_smk_rich_lim_fac_vs_pp
		"Correction factor of richness limitation depending on vehicle speed in pp mode"
		CURVE
		0x80041984
		RSA_RecordLayout_CURVE_UWORD
		8
		EufABca_arlgeCc_grheqod_BCRao0a
		-4.
		4.
    DISPLAY_IDENTIFIER Ctp_smk_rich_lim_fac_vs_pp 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			10
			0.
			655.35
        AXIS_PTS_REF Ctb_smk_rich_lim_fac_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_smk_rich_lim_fac_vs_rij
		"Correction factor of richness limitation depending on vehicle speed in rij mode"
		CURVE
		0x800422ea
		RSA_RecordLayout_CURVE_UWORD
		8
		EufABca_arlgeCc_grheqod_BCRao0a
		-4.
		4.
    DISPLAY_IDENTIFIER Ctp_smk_rich_lim_fac_vs_rij 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_fac_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			10
			0.
			655.35
        AXIS_PTS_REF Ctb_smk_rich_lim_fac_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_smk_tkof_fac_pr
		"Weighting factor on richness offset for takeoff in PR mode"
		CURVE
		0x80041fe3
		RSA_RecordLayout_CURVE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_smk_tkof_fac_pr 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_tkof_ass_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_tkof_ass_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_tkof_ass_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_tkof_ass_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_tkof_ass_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_fac
			ltluECa_kDentwc_ulilrCa_roA_50a
			8
			0.
			1.
        AXIS_PTS_REF Ctb_smk_tkof_ass_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_smk_tkof_fac_rij
		"Weighting factor on richness offset for takeoff in RIJ mode depending on takeoff factor"
		CURVE
		0x800422e2
		RSA_RecordLayout_CURVE_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_smk_tkof_fac_rij 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_tkof_ass_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_tkof_ass_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_tkof_ass_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_tkof_ass_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_tkof_ass_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_fac
			ltluECa_kDentwc_ulilrCa_roA_50a
			8
			0.
			1.
        AXIS_PTS_REF Ctb_smk_tkof_ass_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_spg_fail_val_cor
		"Boost pressure default value correction table"
		CURVE
		0x800577f6
		RSA_RecordLayout_CURVE_UWORD
		2
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_spg_fail_val_cor 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_spg_fail_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_spg_fail_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_spg_fail_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_spg_fail_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_spg_fail_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_spg_fail_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_sta_ac_ptc_dsb_dly
		"Cartography to compute air conditioning and PTC deactivation duration at engine start"
		CURVE
		0x8005cdfe
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_sta_ac_ptc_dsb_dly 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_sta_alt_dsb_dly
		"Cartography to compute alternator deactivation duration at engine start"
		CURVE
		0x8005cdec
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_sta_alt_dsb_dly 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_engstxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_sta_dly
		"Table of driven delay function of the coolant temperature"
		CURVE
		0x80041504
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_sta_dly 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_sta_dspl_arw_up_dly
		"Ctp_sta_dspl_arw_up_dly"
		CURVE
		0x800592ec
		RSA_RecordLayout_CURVE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_sta_off_ofs
		"Offset (depending coolant temperature) about idle speed setpoint to create start state threshold"
		CURVE
		0x8005aab4
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Ctp_sta_off_ofs 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_sta_tco_dly
		"Time value depending on starting coolant temperature"
		CURVE
		0x8005af55
		RSA_RecordLayout_CURVE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Ctp_sta_tco_dly 
    FORMAT "%4.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_stal_ac_dsb_n_ofs
		"Cartography to compute engine speed offset to start stalling anticipation in anti-stall strategy"
		CURVE
		0x8005cdda
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_stal_ac_dsb_n_ofs 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_stal_acs_dsb_n
		"Cartography to compute engine speed threshold to request accessories deactivation in anti-stall strategy"
		CURVE
		0x8005cdc8
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_stal_acs_dsb_n 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_swi_fil_fac
		"Table for torque slope limitation during natural re-injection"
		CURVE
		0x8005aff2
		RSA_RecordLayout_CURVE_UWORD
		65535
		xmoyqad_zuxgeuc_aAwwvka_NsA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_swi_fil_fac 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_act_amp_fac_rij
		"Curve of atmospheric pressure factor for activation regulator in RIJ mode"
		CURVE
		0x80048cb2
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_act_amp_fac_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_act_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_act_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_act_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_act_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_act_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_tbt_act_amp_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_adv_max_amp_fac_pr
		"Weighting curve of the maximal advance correction function of the atmospheric pressure in PR mode"
		CURVE
		0x80047266
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_adv_max_amp_fac_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_tbt_adv_cor_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_adv_max_tia_fac_pr
		"Weighting curve of the maximal advance correction function of the air temperature in PR mode"
		CURVE
		0x80047256
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_adv_max_tia_fac_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tbt_adv_cor_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_adv_min_amp_fac_pr
		"Weighting curve of the minimal advance correction function of the atmospheric pressure in PR mode"
		CURVE
		0x80047246
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_adv_min_amp_fac_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_tbt_adv_cor_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_adv_min_tia_fac_pr
		"Weighting curve of the minimal advance correction function of the air temperature in PR mode"
		CURVE
		0x80047236
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_adv_min_tia_fac_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tbt_adv_cor_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_dg_fac_rij
		"Curve of D part gain in RIJ mode"
		CURVE
		0x80048c9a
		RSA_RecordLayout_CURVE_UWORD
		3
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		0.
		3.
    DISPLAY_IDENTIFIER Ctp_tbt_dg_fac_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_dg_fac_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_dg_fac_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_dg_fac_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_dg_fac_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_dg_fac_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_dg_fac_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_err_dg_pr
		"Weighting curve of D part factor depending on loop deviation in PR mode"
		CURVE
		0x8004721e
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_err_dg_pr 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_dg_fac_err_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_dg_fac_err_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_dg_fac_err_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_dg_fac_err_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_dg_fac_err_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tbt_err_ulim_dif_pr
			dFBFEab_bkAlFtb_ewgpawa_q__110a
			12
			-1200.
			1200.
        AXIS_PTS_REF Ctb_tbt_dg_fac_err_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_err_dg_rij
		"Weighting curve of D part factor depending on loop deviation in RIJ mode"
		CURVE
		0x80048c82
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_err_dg_rij 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_dg_fac_err_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_dg_fac_err_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_dg_fac_err_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_dg_fac_err_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_dg_fac_err_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tbt_err_ulim_dif_rij
			dFBFEab_bkAlFtb_ewgpawa_q__110a
			12
			-1200.
			1200.
        AXIS_PTS_REF Ctb_tbt_dg_fac_err_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_err_ig_pr
		"Weighting curve of I part factor depending on loop deviation in PR mode"
		CURVE
		0x80047206
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_err_ig_pr 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_ig_fac_err */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_ig_fac_err */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_ig_fac_err */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_ig_fac_err */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_ig_fac_err */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tbt_err_ulim
			dFBFEab_bkAlFtb_ewgpawa_q__110a
			12
			-1200.
			1200.
        AXIS_PTS_REF Ctb_tbt_ig_fac_err 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_err_ig_rij
		"Weighting curve of I part factor depending on loop deviation in RIJ mode"
		CURVE
		0x80048c6a
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_err_ig_rij 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_ig_fac_err */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_ig_fac_err */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_ig_fac_err */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_ig_fac_err */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_ig_fac_err */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tbt_err_ulim
			dFBFEab_bkAlFtb_ewgpawa_q__110a
			12
			-1200.
			1200.
        AXIS_PTS_REF Ctb_tbt_ig_fac_err 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_err_pg_pr
		"Weighting curve of P part factor depending on loop deviation in PR mode"
		CURVE
		0x800471ee
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_err_pg_pr 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pg_fac_err */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pg_fac_err */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pg_fac_err */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pg_fac_err */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pg_fac_err */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tbt_err_ulim
			dFBFEab_bkAlFtb_ewgpawa_q__110a
			12
			-1200.
			1200.
        AXIS_PTS_REF Ctb_tbt_pg_fac_err 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_err_pg_rij
		"Weighting curve of P part factor depending on loop deviation in RIJ mode"
		CURVE
		0x80048c52
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_err_pg_rij 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pg_fac_err */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pg_fac_err */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pg_fac_err */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pg_fac_err */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pg_fac_err */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tbt_err_ulim
			dFBFEab_bkAlFtb_ewgpawa_q__110a
			12
			-1200.
			1200.
        AXIS_PTS_REF Ctb_tbt_pg_fac_err 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_fpo_max_amp_fac_pr
		"Weighting curve of the maximal fuel post correction function of the atmospheric pressure in PR mode"
		CURVE
		0x800471de
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_fpo_max_amp_fac_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_tbt_fpo_cor_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_fpo_max_tia_fac_pr
		"Weighting curve of the maximal fuel post correction function of the air temperature in PR mode"
		CURVE
		0x800471ce
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_fpo_max_tia_fac_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tbt_fpo_cor_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_fpo_min_amp_fac_pr
		"Weighting curve of the minimal fuel post correction function of the atmospheric pressure in PR mode"
		CURVE
		0x800471be
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_fpo_min_amp_fac_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_tbt_fpo_cor_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_fpo_min_tia_fac_pr
		"Weighting curve of the minimal fuel post correction function of the air temperature in PR mode"
		CURVE
		0x800471ae
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_fpo_min_tia_fac_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tbt_fpo_cor_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_ig_fac_rij
		"Curve of I part gain in RIJ mode"
		CURVE
		0x80048c3a
		RSA_RecordLayout_CURVE_UWORD
		3
		rEBznhd_Dkorjta_Aqgesjb_1CC_1o0
		0.
		3.
    DISPLAY_IDENTIFIER Ctp_tbt_ig_fac_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_pid_fac_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_pg_fac_rij
		"Curve for P part gain in RIJ mode"
		CURVE
		0x80048c22
		RSA_RecordLayout_CURVE_UWORD
		3
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		0.
		3.
    DISPLAY_IDENTIFIER Ctp_tbt_pg_fac_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_pid_fac_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_sp_fac_amp_pr
		"Curve of the tbt target depending on the intake air temperature in PR mode"
		CURVE
		0x8004719e
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_sp_fac_amp_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_tbt_sp_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_sp_fac_ms_pr
		"Curve of the tbt target depending on the intake air temperature in PR mode"
		CURVE
		0x8004718e
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_sp_fac_ms_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_ms_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_ms_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_ms_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_ms_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_ms_pr */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			8
			0.
			100.
        AXIS_PTS_REF Ctb_tbt_sp_ms_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_sp_fac_tia_pr
		"Curve of the tbt target depending on the intake air temperature in PR mode"
		CURVE
		0x8004717e
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_sp_fac_tia_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tbt_sp_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_sp_fac_tia_rij
		"Curve of the tbt target depending on the intake air temperature in RIJ mode"
		CURVE
		0x80048c12
		RSA_RecordLayout_CURVE_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Ctp_tbt_sp_fac_tia_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tbt_sp_tia_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_sp_max_n_pr
		"Curve of the maximal target temperature before turbine in PR mode"
		CURVE
		0x8004716e
		RSA_RecordLayout_CURVE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Ctp_tbt_sp_max_n_pr 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_min_max_n_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_sp_max_n_rij
		"Curve of the maximal temperature before turbine setpoint in RIJ mode"
		CURVE
		0x80048c02
		RSA_RecordLayout_CURVE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Ctp_tbt_sp_max_n_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_min_max_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_min_max_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_min_max_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_min_max_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_min_max_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_min_max_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_sp_min_n_pr
		"Curve of the minimal target temperature before turbine in PR mode"
		CURVE
		0x8004715e
		RSA_RecordLayout_CURVE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Ctp_tbt_sp_min_n_pr 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_min_max_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_min_max_n_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tbt_sp_min_n_rij
		"Curve of the minimal temperature before turbine setpoint in RIJ mode"
		CURVE
		0x80048bf2
		RSA_RecordLayout_CURVE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Ctp_tbt_sp_min_n_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_min_max_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_min_max_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_min_max_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_min_max_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_min_max_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_min_max_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_cor
		"Coolant correction for final temperature estimation"
		CURVE
		0x800578fc
		RSA_RecordLayout_CURVE_UBYTE
		2
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_tco_cor 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			10
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_cor_egrless
		"The engine temperature correction curve for the fixed area turbocharger model"
		CURVE
		0x80056fd8
		RSA_RecordLayout_CURVE_UWORD
		6
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.
    DISPLAY_IDENTIFIER Ctp_tco_cor_egrless 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_tco_cor_egrless */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_tco_cor_egrless */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_tco_cor_egrless */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_tco_cor_egrless */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_tco_cor_egrless */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_x_tco_cor_egrless 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_cut_decl_off_dly
		"delay table in function of coolant temperature"
		CURVE
		0x8004331e
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_tco_cut_decl_off_dly 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_cut 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_fms_pinj_cut
		"index breakpoint of coolant temperature"
		CURVE
		0x8004c5e2
		RSA_RecordLayout_CURVE_UWORD
		7
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1.
		8.
    DISPLAY_IDENTIFIER Ctp_tco_fms_pinj_cut 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_pinj_cut 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_ini_i_sta
		"Initial power value of idle speed regulator integral correction table in start state"
		CURVE
		0x8005ab5c
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_tco_ini_i_sta 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_n_ini
		"Engine speed initialization depending on coolant temperature"
		CURVE
		0x80058922
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_tco_n_ini 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_ovh_tq
		"torque offset for overheat protection versus coolant temperature"
		CURVE
		0x8005b8c4
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_tco_ovh_tq 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ovh_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ovh_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ovh_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ovh_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ovh_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_ovh_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_statqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_sta_is_trs_dly
		""
		CURVE
		0x8004188e
		RSA_RecordLayout_CURVE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_tco_sta_is_trs_dly 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_toil_ofs
		"Table of corrective terms for basic oil temerature computing"
		CURVE
		0x80058540
		RSA_RecordLayout_CURVE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Ctp_tco_toil_ofs 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_dif */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_dif */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_dif */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_dif */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_dif */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco_dif
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			17
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_dif 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_tqe_max_is_i
		"Basic value of maximum integral torque correction table"
		CURVE
		0x8005ab4a
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_tco_tqe_max_is_i 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_vnt_cold_sta_dly
		"Time delay for cold start"
		CURVE
		0x8004339a
		RSA_RecordLayout_CURVE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctp_tco_vnt_cold_sta_dly 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_cold_sta_dly */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_cold_sta_dly */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_cold_sta_dly */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_cold_sta_dly */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_cold_sta_dly */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			10
			-40.
			200.
        AXIS_PTS_REF Ctb_x_vnt_cold_sta_dly 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tco_vnt_ctl_rij
		"Engine coolant temperature correction curve for vnt control value"
		CURVE
		0x8005e062
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_tco_vnt_ctl_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_tco_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_tco_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_tco_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_tco_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_tco_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			7
			-40.
			200.
        AXIS_PTS_REF Ctb_x_vnt_ctl_tco_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_temp_ovh_tq
		"torque offset for overheat protection versus air or oil temperature"
		CURVE
		0x8005b8b8
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_temp_ovh_tq 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ovh_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ovh_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ovh_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ovh_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ovh_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_ovh_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_air_heat_tqi_min
		"Minimum torque demand for regeneration filter"
		CURVE
		0x800432ba
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_thpl_air_heat_tqi_min 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_thpl_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_thpl_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_thpl_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_thpl_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_thpl_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_thpl_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_diag
		"Alt PWM value to reach if there is no default (with all THP on)"
		CURVE
		0x800590a2
		RSA_RecordLayout_CURVE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_diag 
    FORMAT "%12.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_thpl_diag_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_thpl_diag_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_thpl_diag_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_thpl_diag_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_thpl_diag_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_thpl_diag_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_err_neg
		"Engine speed dependent cartography of alternator PWM negative error"
		CURVE
		0x8005cfda
		RSA_RecordLayout_CURVE_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_err_neg 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_thpl_alt_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_thpl_alt_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_thpl_alt_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_thpl_alt_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_thpl_alt_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_VfEmgCtl_thpl_alt_n
			ryhzxDd_bDsnzFa_Ehryxwb_r_A_1oa
			8
			0.
			65535.
        AXIS_PTS_REF Ctb_thpl_alt_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_err_pos
		"Engine speed dependent cartography of alternator PWM positive error"
		CURVE
		0x8005cfca
		RSA_RecordLayout_CURVE_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_err_pos 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_thpl_alt_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_thpl_alt_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_thpl_alt_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_thpl_alt_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_thpl_alt_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_VfEmgCtl_thpl_alt_n
			ryhzxDd_bDsnzFa_Ehryxwb_r_A_1oa
			8
			0.
			65535.
        AXIS_PTS_REF Ctb_thpl_alt_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_ig_neg
		"Alt PWM governor negative integral gain dependent on coolant temperature (without PTC)"
		CURVE
		0x8005cfc2
		RSA_RecordLayout_CURVE_UWORD
		1
		kwurkla_ttkCtib_tonninb_1aC_1a0
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_ig_neg 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_ig_neg_ptc
		"Alt PWM governor negative integral gain dependent on coolant temperature (with PTC active)"
		CURVE
		0x8005cfba
		RSA_RecordLayout_CURVE_UWORD
		1
		kwurkla_ttkCtib_tonninb_1aC_1a0
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_ig_neg_ptc 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_ig_pos
		"Alt PWM governor positive integral gain dependent on coolant temperature (without PTC)"
		CURVE
		0x8005cfb2
		RSA_RecordLayout_CURVE_UWORD
		1
		kwurkla_ttkCtib_tonninb_1aC_1a0
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_ig_pos 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_ig_pos_ptc
		"Alt PWM governor positive integral gain dependent on coolant temperature (with PTC active)"
		CURVE
		0x8005cfaa
		RSA_RecordLayout_CURVE_UWORD
		1
		kwurkla_ttkCtib_tonninb_1aC_1a0
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_ig_pos_ptc 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_pg_neg
		"Alt PWM governor negative proportional gain dependent on coolant temperature (without PTC)"
		CURVE
		0x8005cfa2
		RSA_RecordLayout_CURVE_UWORD
		0.5
		BtFhkBa_DFkireb_EeDBpgd_1__000a
		0.
		0.5
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_pg_neg 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_pg_neg_ptc
		"Alt PWM governor negative proportional gain dependent on coolant temperature (with PTC active)"
		CURVE
		0x8005cf9a
		RSA_RecordLayout_CURVE_UWORD
		0.5
		BtFhkBa_DFkireb_EeDBpgd_1__000a
		0.
		0.5
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_pg_neg_ptc 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_pg_pos
		"Alt PWM governor positive proportional gain dependent on coolant temperature (without PTC)"
		CURVE
		0x8005cf92
		RSA_RecordLayout_CURVE_UWORD
		0.5
		BtFhkBa_DFkireb_EeDBpgd_1__000a
		0.
		0.5
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_pg_pos 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_alt_pwm_pg_pos_ptc
		"Alt PWM governor positive proportional gain dependent on coolant temperature (with PTC active)"
		CURVE
		0x8005cf8a
		RSA_RecordLayout_CURVE_UWORD
		0.5
		BtFhkBa_DFkireb_EeDBpgd_1__000a
		0.
		0.5
    DISPLAY_IDENTIFIER Ctp_thpl_alt_pwm_pg_pos_ptc 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_vb_ig_neg
		"Voltage governor negative integral gain dependent on coolant temperature (without PTC)"
		CURVE
		0x8005cf82
		RSA_RecordLayout_CURVE_UWORD
		10
		obckiAc_Dodygqd_swoAikd_1aCR1a0
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_thpl_vb_ig_neg 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_vb_ig_neg_ptc
		"Voltage governor negative integral gain dependent on coolant temperature (with PTC active)"
		CURVE
		0x8005cf7a
		RSA_RecordLayout_CURVE_UWORD
		10
		obckiAc_Dodygqd_swoAikd_1aCR1a0
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_thpl_vb_ig_neg_ptc 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_vb_ig_pos
		"Voltage governor positive integral gain dependent on coolant temperature (without PTC)"
		CURVE
		0x8005cf72
		RSA_RecordLayout_CURVE_UWORD
		10
		obckiAc_Dodygqd_swoAikd_1aCR1a0
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_thpl_vb_ig_pos 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_vb_ig_pos_ptc
		"Voltage governor positive integral gain dependent on coolant temperature (with PTC active)"
		CURVE
		0x8005cf6a
		RSA_RecordLayout_CURVE_UWORD
		10
		obckiAc_Dodygqd_swoAikd_1aCR1a0
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_thpl_vb_ig_pos_ptc 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_vb_pg_neg
		"Voltage governor negative proportional gain dependent on coolant temperature (without PTC)"
		CURVE
		0x8005cf62
		RSA_RecordLayout_CURVE_UWORD
		10
		tjaueDb_oDycymc_yApmcia_1__000a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_thpl_vb_pg_neg 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_vb_pg_neg_ptc
		"Voltage governor negative proportional gain dependent on coolant temperature (with PTC active)"
		CURVE
		0x8005cf5a
		RSA_RecordLayout_CURVE_UWORD
		10
		tjaueDb_oDycymc_yApmcia_1__000a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_thpl_vb_pg_neg_ptc 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_vb_pg_pos
		"Voltage governor positive proportional gain dependent on coolant temperature (without PTC)"
		CURVE
		0x8005cf52
		RSA_RecordLayout_CURVE_UWORD
		10
		tjaueDb_oDycymc_yApmcia_1__000a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_thpl_vb_pg_pos 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_thpl_vb_pg_pos_ptc
		"Voltage governor positive proportional gain dependent on coolant temperature (with PTC active)"
		CURVE
		0x8005cf4a
		RSA_RecordLayout_CURVE_UWORD
		10
		tjaueDb_oDycymc_yApmcia_1__000a
		0.
		10.
    DISPLAY_IDENTIFIER Ctp_thpl_vb_pg_pos_ptc 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			4
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tia_cor_egrless
		"The ambiant temperature corection curve for the fixed area turbocherger model"
		CURVE
		0x80056fc6
		RSA_RecordLayout_CURVE_UWORD
		6
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.
    DISPLAY_IDENTIFIER Ctp_tia_cor_egrless 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_tia_cor_egrless */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_tia_cor_egrless */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_tia_cor_egrless */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_tia_cor_egrless */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_tia_cor_egrless */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_x_tia_cor_egrless 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tia_fms_pinj_cut
		"Index breakpoint of intake air temperature"
		CURVE
		0x8004c5d2
		RSA_RecordLayout_CURVE_UWORD
		7
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1.
		8.
    DISPLAY_IDENTIFIER Ctp_tia_fms_pinj_cut 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_fms_pinj_cut 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tia_spg_sp_cor_pr
		"Bap setpoint intake temperature correction for regeneration mode"
		CURVE
		0x8005f086
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_tia_spg_sp_cor_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_tia_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_tia_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_tia_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_tia_spg_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_tia_spg_sp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			7
			-40.
			200.
        AXIS_PTS_REF Ctb_x_tia_spg_sp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tia_spg_sp_cor_rij
		"Boost air pressure setpoint intake temperature correction for regular injection mode"
		CURVE
		0x8005f886
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_tia_spg_sp_cor_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_tia_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_tia_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_tia_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_tia_spg_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_tia_spg_sp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			7
			-40.
			200.
        AXIS_PTS_REF Ctb_x_tia_spg_sp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tia_vnt_ctl_pr
		"Intake air temperature correction curve for vnt control value for delayed main injection operation"
		CURVE
		0x8005d7fc
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_tia_vnt_ctl_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			7
			-40.
			200.
        AXIS_PTS_REF Ctb_x_vnt_ctl_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tia_vnt_ctl_rij
		"Intake air temperature correction curve for vnt control value"
		CURVE
		0x8005e054
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_tia_vnt_ctl_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			7
			-40.
			200.
        AXIS_PTS_REF Ctb_x_vnt_ctl_tia_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tkof_amp
		"Atmospheric pressure reference value"
		CURVE
		0x80040204
		RSA_RecordLayout_CURVE_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_tkof_amp 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tkof_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tkof_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tkof_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tkof_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tkof_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_tkof_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tkof_ass_h_vs_mv
		"High vehicle speed average factor reference value"
		CURVE
		0x800401fe
		RSA_RecordLayout_CURVE_UBYTE
		5.1
		sDwtuec_riAActa_vnpvdDd_ri__50a
		0.
		5.1
    DISPLAY_IDENTIFIER Ctp_tkof_ass_h_vs_mv 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tkof_ass_h_vs_mv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tkof_ass_h_vs_mv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tkof_ass_h_vs_mv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tkof_ass_h_vs_mv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tkof_ass_h_vs_mv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_h_vs_mv
			uEardjb_BFoibqb_vkamstb_khA_00a
			6
			0.
			655.35
        AXIS_PTS_REF Ctb_tkof_ass_h_vs_mv 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tkof_ass_l_vs_mv
		"Low vehicle speed average factor reference value"
		CURVE
		0x800401f8
		RSA_RecordLayout_CURVE_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_tkof_ass_l_vs_mv 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tkof_ass_l_vs_mv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tkof_ass_l_vs_mv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tkof_ass_l_vs_mv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tkof_ass_l_vs_mv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tkof_ass_l_vs_mv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_l_vs_mv
			uEardjb_BFoibqb_vkamstb_khA_00a
			6
			0.
			655.35
        AXIS_PTS_REF Ctb_tkof_ass_l_vs_mv 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tkof_tenv
		"Environmental temperature reference value"
		CURVE
		0x800401f2
		RSA_RecordLayout_CURVE_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_tkof_tenv 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tkof_tenv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tkof_tenv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tkof_tenv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tkof_tenv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tkof_tenv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tenv
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tkof_tenv 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tkof_vnt_ctl_pr
		"Take off assistance factor correction curve for vnt control value in PR mode"
		CURVE
		0x8005d7ee
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_tkof_vnt_ctl_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_tkof_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_tkof_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_tkof_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_tkof_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_tkof_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_fac
			ltluECa_kDentwc_ulilrCa_roA_50a
			7
			0.
			1.
        AXIS_PTS_REF Ctb_x_vnt_ctl_tkof_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tkof_vnt_ctl_rij
		"Take off assistance factor correction curve for vnt control value"
		CURVE
		0x8005e046
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctp_tkof_vnt_ctl_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_fac
			ltluECa_kDentwc_ulilrCa_roA_50a
			7
			0.
			1.
        AXIS_PTS_REF Ctb_x_vnt_ctl_tkof_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_toil_fil
		"Map of filtering coefficients for dynamic oil temperature computing  in engine running conditions"
		CURVE
		0x80058534
		RSA_RecordLayout_CURVE_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_toil_fil 
    FORMAT "%12.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n4 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n4 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n4 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n4 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n4 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n4 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_toil_is_n_ofs
		"Idle speed offset table for protection in case of igh oil temperature"
		CURVE
		0x8005adee
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_toil_is_n_ofs 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_toil_t_ctr_err_fac
		""
		CURVE
		0x80068048
		RSA_RecordLayout_CURVE_UWORD
		655
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		655.
    DISPLAY_IDENTIFIER Ctp_toil_t_ctr_err_fac 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil_rgn_err */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil_rgn_err */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil_rgn_err */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil_rgn_err */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil_rgn_err */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_toil_clc
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_toil_rgn_err 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tq_dif_tco_fac
		"Ctp_tq_dif_tco_fac"
		CURVE
		0x800597c8
		RSA_RecordLayout_CURVE_UBYTE
		1
		VA_F_0v004_p0_4
		0
		1
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tq_dif_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tq_dif_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tq_dif_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tq_dif_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tq_dif_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			VA_F_0v1_m40_2
			6
			-40
			200
        AXIS_PTS_REF Ctb_tq_dif_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_tq_res
		"Ctp_tq_res"
		CURVE
		0x80059788
		RSA_RecordLayout_CURVE_UWORD
		32768
		VA_F_1_p0_5
		0
		32768
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tq_dif_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tq_dif_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tq_dif_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tq_dif_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tq_dif_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			VA_F_0v01_p0_3
			10
			0
			655.35
        AXIS_PTS_REF Ctb_tq_dif_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_adv_fac_pr
		"Advance f(fuel quantity correction) to apply to maintain torque realisation in pr mode"
		CURVE
		0x8005bc44
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_tqi_adv_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_adv_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_adv_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_adv_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_adv_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_adv_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			dkcyncd_nblDwgd_fhtbmxa_q__0a00
			12
			-360.
			360.
        AXIS_PTS_REF Ctb_tqi_adv_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_adv_fac_rij
		"Advance f(fuel quantity correction) to apply to maintain torque realisation in rij mode"
		CURVE
		0x8005c3b8
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_tqi_adv_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_adv_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_adv_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_adv_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_adv_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_adv_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			dkcyncd_nblDwgd_fhtbmxa_q__0a00
			12
			-360.
			360.
        AXIS_PTS_REF Ctb_tqi_adv_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_fil
		"Filter time constants for dowstream compressor estimation"
		CURVE
		0x800578e8
		RSA_RecordLayout_CURVE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Ctp_tqi_fil 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_maf_fac_ocd
		"Air mass corrective factor for torque compensation in ocd mode"
		CURVE
		0x8005bb2e
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_tqi_maf_fac_ocd 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_maf_fac_ocd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_maf_fac_ocd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_maf_fac_ocd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_maf_fac_ocd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_maf_fac_ocd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_maf_err_fil_ocd
			tClffab_hirDflc_mxtqjrd_mtA_o00
			12
			-3000.
			3000.
        AXIS_PTS_REF Ctb_tqi_maf_fac_ocd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_maf_fac_pr
		"Air mass f(fuel quantity correction) to apply to maintain torque realisation in pr mode"
		CURVE
		0x8005bc2c
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_tqi_maf_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_maf_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_maf_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_maf_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_maf_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_maf_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			tClffab_hirDflc_mxtqjrd_mtA_o00
			12
			-3000.
			3000.
        AXIS_PTS_REF Ctb_tqi_maf_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_maf_fac_rij
		"Air mass f(fuel quantity correction) to apply to maintain torque realisation in rij mode"
		CURVE
		0x8005c3a0
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_tqi_maf_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_maf_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_maf_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_maf_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_maf_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_maf_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			tClffab_hirDflc_mxtqjrd_mtA_o00
			12
			-3000.
			3000.
        AXIS_PTS_REF Ctb_tqi_maf_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_post_efy_phi_fac_pr
		"Post efficiency correction curve f(difference between current and basic post timing) in pr mode"
		CURVE
		0x8005cb1e
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_tqi_post_efy_phi_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_post_efy_phi_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_post_efy_phi_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_post_efy_phi_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_post_efy_phi_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_post_efy_phi_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tpo_dif_pr
			dkcyncd_nblDwgd_fhtbmxa_q__0a00
			8
			-360.
			360.
        AXIS_PTS_REF Ctb_tqi_post_efy_phi_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_post_efy_ti_dif_fac_pr
		"Post efficiency correction curve f(difference between post and last injection timing) in pr mode"
		CURVE
		0x8005cb0e
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_tqi_post_efy_ti_dif_fac_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_post_efy_ti_dif_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_post_efy_ti_dif_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_post_efy_ti_dif_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_post_efy_ti_dif_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_post_efy_ti_dif_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_dif_post
			wtkCiEa_ekAonmb_Erxavpb_vCRa38a
			8
			-32768.
			32767.
        AXIS_PTS_REF Ctb_tqi_post_efy_ti_dif_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_t_fil_down_ocd
		"Low pass filter time curve for torque model filtration down in ocd mode"
		CURVE
		0x8005bb1e
		RSA_RecordLayout_CURVE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Ctp_tqi_t_fil_down_ocd 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_t_fil_down_ocd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_t_fil_down_ocd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_t_fil_down_ocd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_t_fil_down_ocd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_t_fil_down_ocd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_t_fil_down_ocd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tqi_t_fil_up_ocd
		"Low pass filter time curve for torque model filtration up in ocd mode"
		CURVE
		0x8005bb0e
		RSA_RecordLayout_CURVE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Ctp_tqi_t_fil_up_ocd 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_t_fil_up_ocd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_t_fil_up_ocd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_t_fil_up_ocd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_t_fil_up_ocd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_t_fil_up_ocd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_t_fil_up_ocd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tsp_tp1_amp_fac_sta
		"Atmospheric pressure dependant factor for pre injection 1 separation correction during Starting combustion mode"
		CURVE
		0x8006aec4
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_tsp_tp1_amp_fac_sta 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tsp_tp1_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tsp_tp1_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tsp_tp1_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tsp_tp1_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tsp_tp1_amp_fac_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_tsp_tp1_amp_fac_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_tsp_tp2_amp_fac_sta
		"Atmospheric pressure dependant factor for pre injection 2 separation correction during Starting combustion mode"
		CURVE
		0x8006afa6
		RSA_RecordLayout_CURVE_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Ctp_tsp_tp2_amp_fac_sta 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tsp_tp2_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tsp_tp2_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tsp_tp2_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tsp_tp2_amp_fac_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tsp_tp2_amp_fac_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_tsp_tp2_amp_fac_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_up_it_temp_max_tqi_cor_pr
		"Corrector coefficient table for Max indicated engine torque in function of upstream throttle temperature"
		CURVE
		0x8005b22a
		RSA_RecordLayout_CURVE_UBYTE
		0.99609375
		Bnlvuab_ejuenvc_iFEorkc_n__2a8a
		0.5
		1.49609375
    DISPLAY_IDENTIFIER Ctp_up_it_temp_max_tqi_cor_pr 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_up_it_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_up_it_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_up_it_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_up_it_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_up_it_temp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_up_it_temp
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tqi_max_up_it_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_up_it_temp_max_tqi_cor_rij
		"Corrector coefficient table for Max indicated engine torque in function of upstream throttle temperature"
		CURVE
		0x8005b4ec
		RSA_RecordLayout_CURVE_UBYTE
		0.99609375
		Bnlvuab_ejuenvc_iFEorkc_n__2a8a
		0.5
		1.49609375
    DISPLAY_IDENTIFIER Ctp_up_it_temp_max_tqi_cor_rij 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_up_it_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_up_it_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_up_it_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_up_it_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_up_it_temp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_up_it_temp
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tqi_max_up_it_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_v1000
		"Ctp_v1000"
		CURVE
		0x800593d2
		RSA_RecordLayout_CURVE_UWORD
		200
		VA_F_0v01_p0_11
		0
		200
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vb_efi_dly_cor
		"Voltage battery correction table"
		CURVE
		0x80058dbc
		RSA_RecordLayout_CURVE_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_vb_efi_dly_cor 
    FORMAT "%12.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_efi_mv_vb */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_efi_mv_vb */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_efi_mv_vb */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_efi_mv_vb */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_efi_mv_vb */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_mv_vb
			hBgaFxb_zbgejFb_ewnyxac_mC__ooa
			9
			0.
			25000.
        AXIS_PTS_REF Ctb_efi_mv_vb 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_floatcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_vb_flot_min_n_ena
		"Minimal engine speed for battery floating authorization"
		CURVE
		0x8005d012
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_vb_flot_min_n_ena 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_floatcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_vb_flot_sta_ena_dly
		"Battery floating authorization delay after engine start"
		CURVE
		0x8005d008
		RSA_RecordLayout_CURVE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctp_vb_flot_sta_ena_dly 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vb_vnt_pwm_fac
		"Battery voltage correction factor on turbocharger pwm"
		CURVE
		0x800400ee
		RSA_RecordLayout_CURVE_UWORD
		6.5535
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Ctp_vb_vnt_pwm_fac 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vb_vnt_pwm_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vb_vnt_pwm_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vb_vnt_pwm_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vb_vnt_pwm_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vb_vnt_pwm_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vb
			Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
			8
			0.
			60.
        AXIS_PTS_REF Ctb_vb_vnt_pwm_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_vh_wht_eq
		"Ctp_vh_wht_eq"
		CURVE
		0x8005977c
		RSA_RecordLayout_CURVE_UWORD
		4096
		VA_F_1_p0_6
		0
		4096
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_drv_neg_typ_1
		"Negative membership function fot the derivative error gear type 1"
		CURVE
		0x8005edc6
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_drv_neg_typ_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_drv_neg_typ_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_drv_neg_typ_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_drv_neg_typ_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_drv_neg_typ_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_drv_neg_typ_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_drv_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_drv_neg_typ_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_drv_neg_typ_2
		"Negative membership function fot the derivative error gear type 2"
		CURVE
		0x8005edbc
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_drv_neg_typ_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_drv_neg_typ_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_drv_neg_typ_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_drv_neg_typ_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_drv_neg_typ_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_drv_neg_typ_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_drv_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_drv_neg_typ_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_drv_neg_typ_3
		"Negative membership function fot the derivative error gear type 3"
		CURVE
		0x8005edb2
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_drv_neg_typ_3 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_drv_neg_typ_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_drv_neg_typ_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_drv_neg_typ_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_drv_neg_typ_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_drv_neg_typ_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_drv_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_drv_neg_typ_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_drv_nul_typ_1
		"Zero membership function fot the derivative error gear type 1"
		CURVE
		0x8005eda8
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_drv_nul_typ_1 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_drv_nul_typ_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_drv_nul_typ_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_drv_nul_typ_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_drv_nul_typ_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_drv_nul_typ_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_drv_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_drv_nul_typ_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_drv_nul_typ_2
		"Zero membership function fot the derivative error gear type 2"
		CURVE
		0x8005ed9e
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_drv_nul_typ_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_drv_nul_typ_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_drv_nul_typ_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_drv_nul_typ_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_drv_nul_typ_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_drv_nul_typ_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_drv_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_drv_nul_typ_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_drv_nul_typ_3
		"Zero membership function fot the derivative error gear type 3"
		CURVE
		0x8005ed94
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_drv_nul_typ_3 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_drv_nul_typ_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_drv_nul_typ_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_drv_nul_typ_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_drv_nul_typ_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_drv_nul_typ_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_drv_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_drv_nul_typ_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_drv_pos_typ_1
		"Positive membership function fot the derivative error gear type 1"
		CURVE
		0x8005ed8a
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_drv_pos_typ_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_drv_pos_typ_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_drv_pos_typ_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_drv_pos_typ_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_drv_pos_typ_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_drv_pos_typ_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_drv_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_drv_pos_typ_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_drv_pos_typ_2
		"Positive membership function fot the derivative error gear type 2"
		CURVE
		0x8005ed80
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_drv_pos_typ_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_drv_pos_typ_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_drv_pos_typ_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_drv_pos_typ_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_drv_pos_typ_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_drv_pos_typ_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_drv_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_drv_pos_typ_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_drv_pos_typ_3
		"Positive membership function fot the derivative error gear type 3"
		CURVE
		0x8005ed76
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_drv_pos_typ_3 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_drv_pos_typ_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_drv_pos_typ_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_drv_pos_typ_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_drv_pos_typ_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_drv_pos_typ_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_drv_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_drv_pos_typ_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_neg_typ_1
		"Negative membership function fot the error gear type 1"
		CURVE
		0x8005ed6c
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_neg_typ_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_neg_typ_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_neg_typ_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_neg_typ_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_neg_typ_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_neg_typ_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_neg_typ_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_neg_typ_2
		"Negative membership function fot the error gear type 2"
		CURVE
		0x8005ed62
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_neg_typ_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_neg_typ_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_neg_typ_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_neg_typ_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_neg_typ_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_neg_typ_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_neg_typ_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_neg_typ_3
		"Negative membership function fot the error gear type 3"
		CURVE
		0x8005ed58
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_neg_typ_3 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_neg_typ_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_neg_typ_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_neg_typ_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_neg_typ_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_neg_typ_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_neg_typ_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_nul_typ_1
		"Zero membership function fot the error gear type 1"
		CURVE
		0x8005ed4e
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_nul_typ_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_nul_typ_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_nul_typ_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_nul_typ_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_nul_typ_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_nul_typ_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_nul_typ_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_nul_typ_2
		"Zero membership function fot the error gear type 2"
		CURVE
		0x8005ed44
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_nul_typ_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_nul_typ_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_nul_typ_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_nul_typ_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_nul_typ_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_nul_typ_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_nul_typ_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_nul_typ_3
		"Zero membership function fot the error gear type 3"
		CURVE
		0x8005ed3a
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_nul_typ_3 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_nul_typ_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_nul_typ_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_nul_typ_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_nul_typ_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_nul_typ_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			5
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_nul_typ_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_pos_typ_1
		"Positive membership function fot the error gear type 1"
		CURVE
		0x8005ed26
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_pos_typ_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_pos_typ_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_pos_typ_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_pos_typ_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_pos_typ_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_pos_typ_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			10
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_pos_typ_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_pos_typ_2
		"Positive membership function fot the error gear type 2"
		CURVE
		0x8005ed12
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_pos_typ_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_pos_typ_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_pos_typ_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_pos_typ_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_pos_typ_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_pos_typ_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			10
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_pos_typ_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_err_pos_typ_3
		"Positive membership function fot the error gear type 3"
		CURVE
		0x8005ecfe
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_err_pos_typ_3 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_err_pos_typ_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_err_pos_typ_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_err_pos_typ_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_err_pos_typ_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_err_pos_typ_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vnt_err_fzy
			lkejytd_cutavkd_xfybptd_nA_0a0a
			10
			-1.
			1.
        AXIS_PTS_REF Ctb_vnt_err_pos_typ_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_ex_reg_i_fac_pr
		"I part correction factor in normal injection mode for exhaust pressure limitation"
		CURVE
		0x8005d294
		RSA_RecordLayout_CURVE_UWORD
		3.2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		3.2
    DISPLAY_IDENTIFIER Ctp_vnt_ex_reg_i_fac_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ex_reg_i_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ex_reg_i_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ex_reg_i_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ex_reg_i_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ex_reg_i_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm_cyl_comb
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_ex_reg_i_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_ex_reg_i_fac_rij
		"I part correction factor in normal injection mode for exhaust pressure limitation"
		CURVE
		0x8005d552
		RSA_RecordLayout_CURVE_UWORD
		3.2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		3.2
    DISPLAY_IDENTIFIER Ctp_vnt_ex_reg_i_fac_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ex_reg_i_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ex_reg_i_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ex_reg_i_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ex_reg_i_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ex_reg_i_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm_cyl_comb
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_ex_reg_i_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_pwm_i_rst_ena
		"Boost controller error thresholds to inhibit  I reset   f( consumation )"
		CURVE
		0x8005ecea
		RSA_RecordLayout_CURVE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Ctp_vnt_pwm_i_rst_ena 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vnt_pwm_i_rst_ena */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vnt_pwm_i_rst_ena */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vnt_pwm_i_rst_ena */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vnt_pwm_i_rst_ena */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vnt_pwm_i_rst_ena */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_vnt_pwm_i_rst_ena 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_reg_dfz_fac_pr
		"Formatting factor correction gain in pr mode"
		CURVE
		0x8005d280
		RSA_RecordLayout_CURVE_UWORD
		3.2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		3.2
    DISPLAY_IDENTIFIER Ctp_vnt_reg_dfz_fac_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_dfz_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_dfz_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_dfz_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_dfz_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_dfz_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_reg_dfz_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_reg_dfz_fac_rij
		"Formatting factor correction gain in rij mode"
		CURVE
		0x8005d53e
		RSA_RecordLayout_CURVE_UWORD
		3.2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		3.2
    DISPLAY_IDENTIFIER Ctp_vnt_reg_dfz_fac_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_dfz_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_dfz_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_dfz_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_dfz_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_dfz_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_reg_dfz_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_reg_i_fac_pr
		"I part correction factor in normal injection mode"
		CURVE
		0x8005d26c
		RSA_RecordLayout_CURVE_UWORD
		3.2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		3.2
    DISPLAY_IDENTIFIER Ctp_vnt_reg_i_fac_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_i_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_i_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_i_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_i_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_i_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_reg_i_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_reg_i_fac_rij
		"I part correction factor in normal injection mode"
		CURVE
		0x8005d52a
		RSA_RecordLayout_CURVE_UWORD
		3.2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		3.2
    DISPLAY_IDENTIFIER Ctp_vnt_reg_i_fac_rij 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_i_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_i_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_i_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_i_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_i_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_reg_i_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vnt_tran_amp_cor
		"Curve for  saturation rco maps correction depending on atmospheric pressure"
		CURVE
		0x800434c4
		RSA_RecordLayout_CURVE_UWORD
		1
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_vnt_tran_amp_cor 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_tran_amp_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_tran_amp_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_tran_amp_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_tran_amp_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_tran_amp_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			10
			0.
			20000.
        AXIS_PTS_REF Ctb_x_vnt_tran_amp_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctp_vs_efi_ext_sph
		"Table of exhaust fuel injector external enthalpy value depending on vehicle speed"
		CURVE
		0x8005825e
		RSA_RecordLayout_CURVE_UWORD
		655.35
		CpAjotd_qajwitb_dexwBid_W2CR1a0
		0.
		655.35
    DISPLAY_IDENTIFIER Ctp_vs_efi_ext_sph 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vs_efi_ext_sph */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vs_efi_ext_sph */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vs_efi_ext_sph */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vs_efi_ext_sph */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vs_efi_ext_sph */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			10
			0.
			655.35
        AXIS_PTS_REF Ctb_vs_efi_ext_sph 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctt_cf_conf_thpl
		"Conversion Levels of failure state to connector of failure state."
		CURVE
		0x80059092
		RSA_RecordLayout_CURVE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Ctt_cf_conf_thpl 
    FORMAT "%1.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_cf_conf_thpl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_cf_conf_thpl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_cf_conf_thpl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_cf_conf_thpl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_cf_conf_thpl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_thpl_lvl_cf
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			16
			0.
			15.
        AXIS_PTS_REF Ctb_cf_conf_thpl 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[0]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d2c
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[0] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[1]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d2d
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[1] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[2]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d2e
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[2] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[3]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d2f
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[3] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[4]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d30
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[4] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[5]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d31
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[5] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[6]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d32
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[6] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[7]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d33
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[7] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[8]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d34
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[8] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_max[9]
		"Maximum value authorized to write on DID $2468"
		VALUE
		0x80056d35
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_max[9] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[0]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d22
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[0] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[1]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d23
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[1] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[2]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d24
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[2] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[3]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d25
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[3] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[4]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d26
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[4] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[5]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d27
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[5] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[6]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d28
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[6] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[7]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d29
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[7] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[8]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d2a
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[8] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2468_writ_min[9]
		"Minimum value authorized to write on DID $2468"
		VALUE
		0x80056d2b
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2468_writ_min[9] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[0]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d18
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[0] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[1]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d19
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[1] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[2]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d1a
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[2] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[3]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d1b
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[3] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[4]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d1c
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[4] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[5]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d1d
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[5] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[6]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d1e
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[6] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[7]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d1f
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[7] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[8]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d20
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[8] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_max[9]
		"Maximum value authorized to write on DID $2469"
		VALUE
		0x80056d21
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_max[9] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[0]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d0e
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[0] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[1]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d0f
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[1] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[2]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d10
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[2] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[3]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d11
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[3] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[4]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d12
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[4] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[5]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d13
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[5] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[6]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d14
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[6] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[7]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d15
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[7] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[8]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d16
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[8] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_2469_writ_min[9]
		"Minimum value authorized to write on DID $2469"
		VALUE
		0x80056d17
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_2469_writ_min[9] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[0]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d04
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[0] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[1]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d05
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[1] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[2]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d06
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[2] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[3]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d07
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[3] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[4]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d08
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[4] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[5]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d09
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[5] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[6]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d0a
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[6] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[7]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d0b
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[7] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[8]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d0c
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[8] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_max[9]
		"Maximum value authorized to write on DID $246A"
		VALUE
		0x80056d0d
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_max[9] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[0]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056cfa
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[0] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[1]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056cfb
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[1] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[2]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056cfc
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[2] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[3]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056cfd
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[3] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[4]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056cfe
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[4] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[5]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056cff
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[5] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[6]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056d00
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[6] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[7]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056d01
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[7] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[8]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056d02
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[8] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_246A_writ_min[9]
		"Minimum value authorized to write on DID $246A"
		VALUE
		0x80056d03
		RSA_RecordLayout_VALUE_UBYTE
		100.8
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		0.
		100.8
    DISPLAY_IDENTIFIER Ctx_did_246A_writ_min[9] 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[0]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056cd0
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[0] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[1]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056cd2
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[1] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[2]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056cd4
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[2] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[3]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056cd6
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[3] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[4]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056cd8
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[4] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[5]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056cda
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[5] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[6]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056cdc
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[6] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[7]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056cde
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[7] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[8]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056ce0
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[8] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_max[9]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056ce2
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_max[9] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[0]
		"Maximum value authorized to write on DID $24EF"
		VALUE
		0x80056cbc
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[0] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[1]
		"Minimum value authorized to write on DID $24EF"
		VALUE
		0x80056cbe
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[1] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[2]
		"Minimum value authorized to write on DID $24EF"
		VALUE
		0x80056cc0
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[2] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[3]
		"Minimum value authorized to write on DID $24EF"
		VALUE
		0x80056cc2
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[3] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[4]
		"Minimum value authorized to write on DID $24EF"
		VALUE
		0x80056cc4
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[4] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[5]
		"Minimum value authorized to write on DID $24EF"
		VALUE
		0x80056cc6
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[5] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[6]
		"Minimum value authorized to write on DID $24EF"
		VALUE
		0x80056cc8
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[6] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[7]
		"Minimum value authorized to write on DID $24EF"
		VALUE
		0x80056cca
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[7] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[8]
		"Minimum value authorized to write on DID $24EF"
		VALUE
		0x80056ccc
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[8] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_did_24EF_writ_min[9]
		"Minimum value authorized to write on DID $24EF"
		VALUE
		0x80056cce
		RSA_RecordLayout_VALUE_UWORD
		100
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		0.
		100.
    DISPLAY_IDENTIFIER Ctx_did_24EF_writ_min[9] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_down[0]
		"Turbocharger negative deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d04c
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_down[0] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_down[1]
		"Turbocharger negative deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d04e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_down[1] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_down[2]
		"Turbocharger negative deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d050
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_down[2] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_down[3]
		"Turbocharger negative deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d052
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_down[3] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_down[4]
		"Turbocharger negative deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d054
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_down[4] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_down[5]
		"Turbocharger negative deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d056
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_down[5] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_up[0]
		"Turbocharger positive deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d040
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_up[0] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_up[1]
		"Turbocharger positive deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d042
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_up[1] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_up[2]
		"Turbocharger positive deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d044
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_up[2] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_up[3]
		"Turbocharger positive deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d046
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_up[3] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_up[4]
		"Turbocharger positive deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d048
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_up[4] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_esd_did_spg_reg_apl_up[5]
		"Turbocharger positive deviation RSA_API_ExtendedSnapshotData table of DID to store"
		VALUE
		0x8005d04a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_esd_did_spg_reg_apl_up[5] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[0]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f3c
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[0] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[10]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f50
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[10] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[11]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f52
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[11] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[12]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f54
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[12] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[13]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f56
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[13] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[14]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f58
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[14] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[15]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f5a
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[15] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[1]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f3e
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[1] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[2]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f40
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[2] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[3]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f42
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[3] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[4]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f44
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[4] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[5]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f46
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[5] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[6]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f48
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[6] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[7]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f4a
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[7] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[8]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f4c
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[8] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_cold_dist_intv[9]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80067f4e
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_cold_dist_intv[9] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[0]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cac
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[0] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[10]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cc0
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[10] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[11]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cc2
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[11] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[12]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cc4
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[12] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[13]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cc6
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[13] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[14]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cc8
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[14] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[15]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cca
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[15] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[1]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cae
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[1] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[2]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cb0
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[2] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[3]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cb2
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[3] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[4]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cb4
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[4] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[5]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cb6
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[5] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[6]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cb8
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[6] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[7]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cba
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[7] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[8]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cbc
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[8] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_dist_intv[9]
		"Table of default values for distance intervals between two successive hot or medium or cold opportunities"
		VALUE
		0x80046cbe
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_dist_intv[9] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[0]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f1c
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[0] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[10]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f30
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[10] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[11]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f32
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[11] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[12]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f34
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[12] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[13]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f36
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[13] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[14]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f38
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[14] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[15]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f3a
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[15] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[1]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f1e
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[1] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[2]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f20
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[2] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[3]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f22
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[3] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[4]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f24
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[4] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[5]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f26
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[5] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[6]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f28
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[6] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[7]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f2a
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[7] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[8]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f2c
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[8] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_dft_hot_med_dist_intv[9]
		"Table of default values for distance intervals between two successive hot or medium opportunities"
		VALUE
		0x80067f2e
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_pft_dft_hot_med_dist_intv[9] 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_efy_bkp[0]
		"Programmable breakpoints table of efficiency dependency"
		VALUE
		0x8004667e
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctx_pft_efy_bkp[0] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_efy_bkp[1]
		"Programmable breakpoints table of efficiency dependency"
		VALUE
		0x80046680
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctx_pft_efy_bkp[1] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_efy_bkp[2]
		"Programmable breakpoints table of efficiency dependency"
		VALUE
		0x80046682
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctx_pft_efy_bkp[2] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_efy_bkp[3]
		"Programmable breakpoints table of efficiency dependency"
		VALUE
		0x80046684
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctx_pft_efy_bkp[3] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_efy_bkp[4]
		"Programmable breakpoints table of efficiency dependency"
		VALUE
		0x80046686
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctx_pft_efy_bkp[4] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_efy_bkp[5]
		"Programmable breakpoints table of efficiency dependency"
		VALUE
		0x80046688
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctx_pft_efy_bkp[5] 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[0]
		"Vector of upper limits for air flow zones"
		VALUE
		0x8004666a
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[0] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[1]
		"Vector of upper limits for air flow zones"
		VALUE
		0x8004666c
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[1] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[2]
		"Vector of upper limits for air flow zones"
		VALUE
		0x8004666e
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[2] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[3]
		"Vector of upper limits for air flow zones"
		VALUE
		0x80046670
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[3] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[4]
		"Vector of upper limits for air flow zones"
		VALUE
		0x80046672
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[4] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[5]
		"Vector of upper limits for air flow zones"
		VALUE
		0x80046674
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[5] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[6]
		"Vector of upper limits for air flow zones"
		VALUE
		0x80046676
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[6] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[7]
		"Vector of upper limits for air flow zones"
		VALUE
		0x80046678
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[7] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[8]
		"Vector of upper limits for air flow zones"
		VALUE
		0x8004667a
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[8] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_h[9]
		"Vector of upper limits for air flow zones"
		VALUE
		0x8004667c
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_h[9] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[0]
		"Vector of lower limits for air flow zones"
		VALUE
		0x80046656
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[0] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[1]
		"Vector of lower limits for air flow zones"
		VALUE
		0x80046658
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[1] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[2]
		"Vector of lower limits for air flow zones"
		VALUE
		0x8004665a
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[2] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[3]
		"Vector of lower limits for air flow zones"
		VALUE
		0x8004665c
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[3] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[4]
		"Vector of lower limits for air flow zones"
		VALUE
		0x8004665e
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[4] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[5]
		"Vector of lower limits for air flow zones"
		VALUE
		0x80046660
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[5] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[6]
		"Vector of lower limits for air flow zones"
		VALUE
		0x80046662
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[6] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[7]
		"Vector of lower limits for air flow zones"
		VALUE
		0x80046664
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[7] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[8]
		"Vector of lower limits for air flow zones"
		VALUE
		0x80046666
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[8] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctx_pft_egaf_lim_l[9]
		"Vector of lower limits for air flow zones"
		VALUE
		0x80046668
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Ctx_pft_egaf_lim_l[9] 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf1[0]
		"Boolean relay command vector"
		VALUE
		0x80059042
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf1_0_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf1[1]
		"Boolean relay command vector"
		VALUE
		0x80059043
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf1_1_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf1[2]
		"Boolean relay command vector"
		VALUE
		0x80059044
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf1_2_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf2[0]
		"Boolean relay command vector"
		VALUE
		0x8005903f
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf2_0_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf2[1]
		"Boolean relay command vector"
		VALUE
		0x80059040
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf2_1_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf2[2]
		"Boolean relay command vector"
		VALUE
		0x80059041
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf2_2_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf3[0]
		"Boolean relay command vector"
		VALUE
		0x8005903c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf3_0_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf3[1]
		"Boolean relay command vector"
		VALUE
		0x8005903d
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf3_1_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf3[2]
		"Boolean relay command vector"
		VALUE
		0x8005903e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf3_2_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf4[0]
		"Boolean relay command vector"
		VALUE
		0x80059039
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf4_0_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf4[1]
		"Boolean relay command vector"
		VALUE
		0x8005903a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf4_1_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf4[2]
		"Boolean relay command vector"
		VALUE
		0x8005903b
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf4_2_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf5[0]
		"Boolean relay command vector"
		VALUE
		0x80059036
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf5_0_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf5[1]
		"Boolean relay command vector"
		VALUE
		0x80059037
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf5_1_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf5[2]
		"Boolean relay command vector"
		VALUE
		0x80059038
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf5_2_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf6[0]
		"Boolean relay command vector"
		VALUE
		0x80059033
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf6_0_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf6[1]
		"Boolean relay command vector"
		VALUE
		0x80059034
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf6_1_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf6[2]
		"Boolean relay command vector"
		VALUE
		0x80059035
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf6_2_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf7[0]
		"Boolean relay command vector"
		VALUE
		0x80059030
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf7_0_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf7[1]
		"Boolean relay command vector"
		VALUE
		0x80059031
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf7_1_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_thpl_stt_rly_conf7[2]
		"Boolean relay command vector"
		VALUE
		0x80059032
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Ctx_thpl_stt_rly_conf7_2_ 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[0]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f7f
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[0] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[10]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f89
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[10] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[11]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f8a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[11] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[12]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f8b
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[12] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[13]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f8c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[13] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[14]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f8d
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[14] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[15]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f8e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[15] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[16]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f8f
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[16] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[17]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f90
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[17] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[18]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f91
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[18] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[1]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f80
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[1] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[2]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f81
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[2] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[3]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f82
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[3] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[4]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f83
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[4] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[5]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f84
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[5] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[6]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f85
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[6] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[7]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f86
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[7] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[8]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f87
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[8] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctx_vin_crc_ini_data[9]
		"Calibration value of VIN and CRC data"
		VALUE
		0x80056f88
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctx_vin_crc_ini_data[9] 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_1_gear_rat_tgt
		"First gear ratio target"
		VALUE
		0x8006b25c
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_1_gear_rat_tgt 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_2_gear_rat_tgt
		"Second gear ratio target"
		VALUE
		0x8006b25a
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_2_gear_rat_tgt 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_3_gear_rat_tgt
		"Third gear ratio target"
		VALUE
		0x8006b258
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_3_gear_rat_tgt 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_4_gear_rat_tgt
		"Fourth gear ratio target"
		VALUE
		0x8006b256
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_4_gear_rat_tgt 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_5_gear_rat_tgt
		"Fifth gear ratio target"
		VALUE
		0x8006b254
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_5_gear_rat_tgt 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_6_gear_rat_tgt
		"Sixth gear ratio target"
		VALUE
		0x8006b252
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_6_gear_rat_tgt 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ACC_CANHS_R_01_id
		"ACC_CANHS_RNr_01 CAN frame identifier"
		VALUE
		0x80055c1a
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_ACC_CANHS_R_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_AIRBAGCrash_id
		"AIRBAGCrash frame identifier"
		VALUE
		0x80055c18
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_AIRBAGCrash_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_BCM_CANHS_RNr_01_id
		"BCM_CANHS_RNr_01 CAN frame identifier"
		VALUE
		0x80055c16
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_BCM_CANHS_RNr_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_BCM_CANHS_RNr_02_id
		"BCM_CANHS_RNr_02 CAN frame identifier"
		VALUE
		0x80055c14
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_BCM_CANHS_RNr_02_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_BCM_VERLOG_id
		"BCM_VERLOG CAN frame identifier"
		VALUE
		0x80055c12
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_BCM_VERLOG_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_BRAKE_CANHS_RNr_01_id
		"BRAKE_CANHS_RNr_01 frame identifier"
		VALUE
		0x80055c10
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_BRAKE_CANHS_RNr_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_BRAKE_CANHS_RNr_02_id
		"BRAKE_CANHS_RNr_02 frame identifier"
		VALUE
		0x80055c0e
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_BRAKE_CANHS_RNr_02_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_BRAKE_CANHS_RNr_03_id
		"BRAKE_CANHS_RNr_03 frame identifier"
		VALUE
		0x80055c0c
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_BRAKE_CANHS_RNr_03_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_BRAKE_CANHS_RNr_04_id
		"BRAKE_CANHS_RNr_04 frame identifier"
		VALUE
		0x80055c0a
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_BRAKE_CANHS_RNr_04_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_BRAKE_CANHS_R_01_id
		"BRAKE_CANHS_R_01 CAN frame identifier"
		VALUE
		0x80055c08
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_BRAKE_CANHS_R_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_CLIM_CANHS_R_01_id
		"CLIM_CANHS_R_01 CAN frame identifier"
		VALUE
		0x80055c06
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_CLIM_CANHS_R_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_CLUSTER_CANHS_RNr_01_id
		"CLUSTER_CANHS_RNr_01 CAN frame identifier"
		VALUE
		0x80055c04
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_CLUSTER_CANHS_RNr_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_CLUSTER_CANHS_R_01_id
		"CLUSTER_CANHS_R_01 CAN frame identifier"
		VALUE
		0x80055c02
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_CLUSTER_CANHS_R_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_DDCM_CANLSFT_R_01_id
		"DDCM_CANLSFT_R_01 CAN frame identifier"
		VALUE
		0x80055c00
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_DDCM_CANLSFT_R_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ECM_CANHS_RNr_01_id
		"ECM_CANHS_RNr_01 CAN frame identifier"
		VALUE
		0x80055bfe
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_ECM_CANHS_RNr_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ECM_CANHS_RNr_02_id
		"ECM_CANHS_RNr_02 CAN frame identifier"
		VALUE
		0x80055bfc
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_ECM_CANHS_RNr_02_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ECM_VERLOG_id
		"ECM_VERLOG CAN frame identifier"
		VALUE
		0x80055bfa
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_ECM_VERLOG_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_FORCE_ECM_CANHS_R_01_id
		"FORCE_ECM_CANHS_R_01 CAN frame identifier"
		VALUE
		0x80055bf8
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_FORCE_ECM_CANHS_R_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_MMI_ECM_CANHS_RNr_01_id
		"MMI_ECM_CANHS_RNr_01 CAN frame identifier"
		VALUE
		0x80055bf6
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_MMI_ECM_CANHS_RNr_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_SWA_CANHS_RNr_01_id
		"SWA_CANHS_RNr_01 CAN frame identifier"
		VALUE
		0x80055bf4
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_SWA_CANHS_RNr_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_TORQUE_AT_CANHS_RNr_01_id
		"TORQUE_AT_CANHS_RNr_01 CAN frame identifier"
		VALUE
		0x80055bf2
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_TORQUE_AT_CANHS_RNr_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_TORQUE_AT_CANHS_RNr_02_id
		"TORQUE_AT_CANHS_RNr_02 CAN frame identifier"
		VALUE
		0x80055bf0
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_TORQUE_AT_CANHS_RNr_02_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_TORQUE_ECM_CANHS_RNr_01_id
		"TORQUE_ECM_CANHS_RNr_01 CAN frame identifier"
		VALUE
		0x80055bee
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_TORQUE_ECM_CANHS_RNr_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_TORQUE_ECM_CANHS_RNr_02_id
		"TORQUE_ECM_CANHS_RNr_02 CAN frame identifier"
		VALUE
		0x80055bec
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_TORQUE_ECM_CANHS_RNr_02_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_TORQUE_ECM_CANHS_R_01_id
		"TORQUE_ECM_CANHS_R_01 CAN frame identifier"
		VALUE
		0x80055bea
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_TORQUE_ECM_CANHS_R_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_USM_CANHS_RNr_01_id
		"USM_CANHS_RNr_01 CAN frame identifier"
		VALUE
		0x80055be8
		RSA_RecordLayout_VALUE_UWORD
		2047
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2047.
    DISPLAY_IDENTIFIER Cxx_USM_CANHS_RNr_01_id 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_abs_abst_frm_dly
		"Brake Control Unit absence detection time-out"
		VALUE
		0x80055be7
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_abs_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_abs_ecu_conf
		"Brake Control Unit feature for Mux Network configuration detection (always present or optional)"
		VALUE
		0x80055be6
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_abs_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_abs_vld_abst_frm_dec
		"Brake Control Unit : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055be5
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_abs_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_abs_vld_abst_frm_inc
		"Brake Control Unit : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055be4
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_abs_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_abst_frm_dly
		"Climate Control Unit absence detection time-out"
		VALUE
		0x80055be3
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ac_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_acel_is_dly
		"Air conditioning accelerated idle speed prolongation duration"
		VALUE
		0x8005ae70
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ac_acel_is_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_bfr_clu_dly
		"Air conditioning compressor before clutching state delay"
		VALUE
		0x8004335a
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ac_bfr_clu_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_clu_dly
		"Air conditioning compressor clutching delay"
		VALUE
		0x80043359
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ac_clu_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_dclu_dly
		"Air conditioning compressor declutching delay"
		VALUE
		0x80043358
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ac_dclu_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_dsb_tco_thd
		"Offset on Cxx_mdf_1_cmd_ena_thd_tco for the Water Temp. threshold to disable the air conditioning system."
		VALUE
		0x8006b0ba
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ac_dsb_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_dsb_tco_thd_h
		"Offset on Water Temp. to disable the air conditioning system on High Temp. regulation mode."
		VALUE
		0x8006b0b8
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ac_dsb_tco_thd_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_ecu_conf
		"Climate Control Unit feature for Mux Network configuration detection (always present or optional)"
		VALUE
		0x80055be2
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ac_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_ena_tco_thd
		"Offset on Cxx_mdf_1_cmd_ena_thd_tco to enable the air conditioning system."
		VALUE
		0x8006b0b6
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ac_ena_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_ena_tco_thd_h
		"Offset on Cxx_mdf_1_cmd_ena_thd_tco to enable the air conditioning system on High Temp. regulation mode."
		VALUE
		0x8006b0b4
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ac_ena_tco_thd_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_ext_clu_dly
		"Air conditioning compressor external clutching delay (USM delay)"
		VALUE
		0x80043357
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ac_ext_clu_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_ext_dclu_dly
		"Air conditioning compressor external declutching delay (USM delay)"
		VALUE
		0x80043356
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ac_ext_dclu_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_is_in_cdn_ofs
		"Offset on the threshold determined by the derivate of engine speed when the air conditioning compressor is clutched"
		VALUE
		0x8005aab0
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ac_is_in_cdn_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_is_in_cdn_ofs2
		"Offset on the threshold determined by the derivate of engine speed when the air conditioning compressor is clutched and when we are not entered in active ISR at the end of a temporization"
		VALUE
		0x8005aaae
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ac_is_in_cdn_ofs2 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_is_in_dly
		"Delay to enter in activate state after condition state with air conditioning compressor clutched (coming out IS)"
		VALUE
		0x8005aaac
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ac_is_in_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_is_out_n_ofs
		"Offset about setpoint to exit condition state when acc is clutch"
		VALUE
		0x8005aaaa
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ac_is_out_n_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_lk_stt_dly
		"Duration of air conditioning connection/detection filtering"
		VALUE
		0x80058a84
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ac_lk_stt_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_prs_hys
		"AC pressure hysteresis for fans activation"
		VALUE
		0x8005ced0
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ac_mdf_prs_hys 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_prs_thd1
		"AC pressure threshold n° 1 for fans activation"
		VALUE
		0x8005cece
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ac_mdf_prs_thd1 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_prs_thd2
		"AC pressure threshold n° 2 for fans activation"
		VALUE
		0x8005cecc
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ac_mdf_prs_thd2 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_prs_thd3
		"AC pressure threshold n° 3 for fans activation"
		VALUE
		0x8005ceca
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ac_mdf_prs_thd3 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_secu_prs_hys
		"Security AC pressure hysteresis for fans activation when there is no ac presnce"
		VALUE
		0x8005cec8
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ac_mdf_secu_prs_hys 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_secu_prs_thd
		"Security AC pressure threshold for fans activation when there is no ac request"
		VALUE
		0x8005cec6
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ac_mdf_secu_prs_thd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_vs_hys
		"Vehicle speed hysteresis for fans activation"
		VALUE
		0x8005cec4
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ac_mdf_vs_hys 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_vs_thd1
		"Vehicle speed threshold n° 1 for fans activation"
		VALUE
		0x8005cec3
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ac_mdf_vs_thd1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_vs_thd2
		"Vehicle speed threshold n° 2 for fans activation"
		VALUE
		0x8005cec2
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ac_mdf_vs_thd2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_vs_thd3
		"Vehicle speed threshold n° 3 for fans activation"
		VALUE
		0x8005cec1
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ac_mdf_vs_thd3 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_mdf_vs_thd4
		"Vehicle speed threshold n° 4 for fans activation"
		VALUE
		0x8005cec0
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ac_mdf_vs_thd4 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_pow_max
		"Maximum AC absorbed power"
		VALUE
		0x8005897c
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_ac_pow_max 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_pow_min
		"Minimum AC absorbed power"
		VALUE
		0x8005897a
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_ac_pow_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_pow_n_fac
		"B coefficient to calculate the AC absorbed power"
		VALUE
		0x80058978
		RSA_RecordLayout_VALUE_UWORD
		4.99992370605469
		braFrkc_srbpgAb_eBozlbc_W__199a
		0.
		4.99992370605469
    DISPLAY_IDENTIFIER Cxx_ac_pow_n_fac 
    FORMAT "%1.16" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_pow_prs_fac
		"A coefficient to calculate the AC absorbed power"
		VALUE
		0x80058976
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		kwzBeob_ebfpBdd_lmndEeb_Wa__10a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ac_pow_prs_fac 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_pow_prs_n_fac
		"C coefficient to calculate the AC absorbed power"
		VALUE
		0x80058974
		RSA_RecordLayout_VALUE_UWORD
		4.99992370605469
		vfeacpa_aoflexb_dCifcCa_WBA119o
		0.
		4.99992370605469
    DISPLAY_IDENTIFIER Cxx_ac_pow_prs_n_fac 
    FORMAT "%1.16" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_prs_fac
		"Air conditioning pressure sensor gain value"
		VALUE
		0x80058a82
		RSA_RecordLayout_VALUE_UBYTE
		0.255
		iFzvbxb_yFwnaca_FlrjjEb_VrA_0a0
		0.
		0.255
    DISPLAY_IDENTIFIER Cxx_ac_prs_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_prs_lk_stt_dly
		"Duration of air conditioning pressure sensor connection filtering"
		VALUE
		0x80058a80
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ac_prs_lk_stt_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_prs_ofs
		"Air conditioning pressure sensor offset value"
		VALUE
		0x80058a7e
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_ac_prs_ofs 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_prs_v_max
		"High threshold for AC pressure sensor failure detection"
		VALUE
		0x80058a7c
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_ac_prs_v_max 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_prs_v_min
		"Low threshold for AC pressure sensor failure detection"
		VALUE
		0x80058a7a
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_ac_prs_v_min 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_mngtxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_req_dly
		"Delay to filter an AC clutching request"
		VALUE
		0x80058a8c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ac_req_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_mngtxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_req_dsb_dly
		"Delay to filter an AC clutching request inhibition"
		VALUE
		0x80058a8a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ac_req_dsb_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_accluxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_req_off_ac_acel_is_sp
		"Default value of engine idle speed setpoint for AC when calculation is disabled"
		VALUE
		0x8005888a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ac_req_off_ac_acel_is_sp 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_rly_prot_dly
		"Minimum duration in clutched state for relay protection"
		VALUE
		0x80043355
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ac_rly_prot_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_vld_abst_frm_dec
		"Climate Control Unit : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055be1
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ac_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_vld_abst_frm_inc
		"Climate Control Unit : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055be0
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ac_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ac_vs_nok_dly
		"Delay to filter an unavailable vehicle speed received on the CAN network"
		VALUE
		0x8005cee8
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ac_vs_nok_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_acc_abst_frm_dly
		"Automatic Cruise Control Unit absence detection time-out"
		VALUE
		0x80055bdf
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_acc_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_acc_ecu_conf
		"Automatic Cruise Control Unit feature for Mux Network config. detection (always present or optional)"
		VALUE
		0x80055bde
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acc_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_acc_vld_abst_frm_dec
		"Automatic Cruise Control Unit : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bdd
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acc_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_acc_vld_abst_frm_inc
		"Automatic Cruise Control Unit : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bdc
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_acc_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_in_brk_ass_thd
		"Cxx_acel_in_brk_ass_thd"
		VALUE
		0x80059754
		RSA_RecordLayout_VALUE_SLONG
		25.5
		VA_F_0v0004_p0_1
		-12
		13.5
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_is_ac_dsb_dly
		"Minimum duration on accelerated idle speed before authorizing air conditioning compressor clutching"
		VALUE
		0x8005cdb0
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_acel_is_ac_dsb_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_is_ac_dsb_rat
		"Accelerated idle speed ratio to authorize air conditioning compressor clutching"
		VALUE
		0x8005cdae
		RSA_RecordLayout_VALUE_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_is_ac_dsb_rat 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_out_brk_ass_thd
		"Cxx_acel_out_brk_ass_thd"
		VALUE
		0x80059750
		RSA_RecordLayout_VALUE_SLONG
		25.5
		VA_F_0v0004_p0_1
		-12
		13.5
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_0_rat_v_nok
		"Uref ratio value defining 0 pedal ratio position if failure on track 1 and no failure on track 2"
		VALUE
		0x8005879a
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_0_rat_v_nok 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_0_rat_v_ok
		"Uref ratio value defining 0 pedal ratio position when pedal sensor is in nominal operation (track 1)"
		VALUE
		0x80058798
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_0_rat_v_ok 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_100_rat_v_hys
		"Uref ratio hysteresis linked with 100% pedal ratio flag"
		VALUE
		0x80058796
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_100_rat_v_hys 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_100_rat_v_max_nok
		"Uref ratio maximum value defining 100% pedal ratio flag if failure on track 1 and no failure on track 2"
		VALUE
		0x80058794
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_100_rat_v_max_nok 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_100_rat_v_max_ok
		"Uref ratio maximum value defining 100% pedal ratio flag when pedal sensor is in nominal operation (track 1)"
		VALUE
		0x80058792
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_100_rat_v_max_ok 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_100_rat_v_nok
		"Uref ratio value defining 100% pedal ratio position if failure on track 1 and no failure on track 2"
		VALUE
		0x80058790
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_100_rat_v_nok 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_100_rat_v_ok
		"Uref ratio value defining 100% pedal ratio position when pedal sensor is in nominal operation (track 1)"
		VALUE
		0x8005878e
		RSA_RecordLayout_VALUE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_acel_pdl_100_rat_v_ok 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_dif_t
		"Time constant for accelerator pedal difference calculation"
		VALUE
		0x80059194
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_acel_pdl_dif_t 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_acel_pdl_fmt_mnl_fac
