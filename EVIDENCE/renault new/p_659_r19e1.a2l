/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[10]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[10] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[11]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[11] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[12]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[12] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[13]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[13] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[14]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[14] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[15]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[15] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[1]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[1] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[2]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[2] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[3]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[3] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[4]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[4] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[5]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[5] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[6]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[6] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[7]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[7] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[8]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[8] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[9]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[9] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[0]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[0] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[10]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[10] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[11]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[11] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[12]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[12] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[13]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[13] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[14]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[14] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[15]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[15] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[1]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[1] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020bd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[2]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[2] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[3]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[3] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020bf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[4]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[4] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[5]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[5] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[6]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[6] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[7]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[7] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[8]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[8] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_intv_sum_rat[9]
		"Array whose each of the 16 val = ratio of dist driven with [dist to following hot or med opp < 1 of learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_intv_sum_rat[9] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020c5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_ms_test[0]
		"Vector of soot mass test : first component = increased value, second component = decreased value"
		UWORD
		arAgssb_cAzswia_pjzaDlc_gA_020a
		1
		100
		-255.
		255.
    DISPLAY_IDENTIFIER Vtx_pft_ms_test[0] 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00064e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_ms_test[1]
		"Vector of soot mass test : first component = increased value, second component = decreased value"
		UWORD
		arAgssb_cAzswia_pjzaDlc_gA_020a
		1
		100
		-255.
		255.
    DISPLAY_IDENTIFIER Vtx_pft_ms_test[1] 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00064e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[0]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[0] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[1]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[1] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[2]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[2] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[3]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[3] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[4]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[4] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[5]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[5] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[6]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[6] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[7]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[7] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[8]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[8] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_egaf_zon[9]
		"Vector of average air flow in each zone"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_egaf_zon[9] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[0]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[0] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[1]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[1] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[2]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[2] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[3]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[3] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[4]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[4] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006500 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[5]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[5] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006502 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[6]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[6] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006504 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[7]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[7] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006506 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[8]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[8] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006508 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_mv_prs_each_zon[9]
		"Vector of mean value of pressure for each zone"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vtx_pft_mv_prs_each_zon[9] 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000650a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[0]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[0] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[1]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[1] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c13 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[2]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[2] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[3]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[3] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c15 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[4]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[4] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[5]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[5] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c17 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[6]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[6] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[7]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[7] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c19 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[8]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[8] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vtx_pft_mv_sp_each_zon[9]
		"Vector for displaying newly established mean value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_mv_sp_each_zon[9] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c1b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[0]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[0] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002072 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[1]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[1] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002073 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[2]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[2] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002074 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[3]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[3] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002075 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[4]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[4] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002076 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[5]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[5] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002077 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[6]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[6] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002078 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[7]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[7] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002079 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[8]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[8] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000207a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_nr_sp_each_zon[9]
		"Vector of number of points in each zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_pft_nr_sp_each_zon[9] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000207b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_clc[0]
		"Vector of interpolated pressure"
		SWORD
		CrotiCd_FAysnkb_hfbjdrc_h___00a
		1
		100
		-3276.8
		3276.7
    DISPLAY_IDENTIFIER Vtx_pft_prs_clc[0] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000650c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_clc[1]
		"Vector of interpolated pressure"
		SWORD
		CrotiCd_FAysnkb_hfbjdrc_h___00a
		1
		100
		-3276.8
		3276.7
    DISPLAY_IDENTIFIER Vtx_pft_prs_clc[1] 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000650e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_err[0]
		"Vector of errors between measured and calculated pressure"
		ULONG
		Egtxmlc_gaqadlc_lumDsea_B2__0a0
		1
		100
		0.
		4294967.
    DISPLAY_IDENTIFIER Vtx_pft_prs_err[0] 
    FORMAT "%11.3" 
    ECU_ADDRESS 0xd0004fbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_err[1]
		"Vector of errors between measured and calculated pressure"
		ULONG
		Egtxmlc_gaqadlc_lumDsea_B2__0a0
		1
		100
		0.
		4294967.
    DISPLAY_IDENTIFIER Vtx_pft_prs_err[1] 
    FORMAT "%11.3" 
    ECU_ADDRESS 0xd0004fc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[0]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[0] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[1]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[1] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[2]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[2] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[3]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[3] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[4]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[4] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[5]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[5] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[6]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[6] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[7]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[7] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fe0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[8]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[8] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fe4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_prs_sum[9]
		"Vector of sum of pressures"
		SLONG
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-32767.
		32768.
    DISPLAY_IDENTIFIER Vtx_pft_prs_sum[9] 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0004fe8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_fzy_para_mux.field_1
		""
		UWORD
		bCyeoab_zijwjxc_htqocrc_h___o0a
		1
		100
		2.
		100000.
    DISPLAY_IDENTIFIER Vtx_vnt_fzy_para_mux.field_1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001376 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_fzy_para_mux.field_2
		""
		UWORD
		uxdoaqa_BznFwjc_okphcBc_hp__00a
		1
		100
		2.
		100000.
    DISPLAY_IDENTIFIER Vtx_vnt_fzy_para_mux.field_2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001378 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_fzy_para_mux.field_3
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_fzy_para_mux.field_3 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000137a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_fzy_para_mux.field_4
		""
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_fzy_para_mux.field_4 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000137c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_fzy_para_mux.field_5
		""
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_fzy_para_mux.field_5 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000137e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_ex_para_mux.field_1
		""
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vtx_vnt_i_ex_para_mux.field_1 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000138c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_ex_para_mux.field_2
		""
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vtx_vnt_i_ex_para_mux.field_2 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000138e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_ex_para_mux.field_3
		""
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vtx_vnt_i_ex_para_mux.field_3 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001390 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_ex_para_mux.field_4
		""
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vtx_vnt_i_ex_para_mux.field_4 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001392 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_ex_para_mux.field_5
		""
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vtx_vnt_i_ex_para_mux.field_5 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001394 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_ex_para_mux.field_6
		""
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_i_ex_para_mux.field_6 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001396 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_mux.field_1
		""
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_mux.field_1 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001380 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_mux.field_2
		""
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_mux.field_2 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001382 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_mux.field_3
		""
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_mux.field_3 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001384 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_mux.field_4
		""
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_mux.field_4 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001386 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_mux.field_5
		""
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_mux.field_5 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001388 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_mux.field_6
		""
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_mux.field_6 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000138a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_spg_mux.field_1
		""
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_spg_mux.field_1 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001398 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_spg_mux.field_2
		""
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_spg_mux.field_2 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000139a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_spg_mux.field_3
		""
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_spg_mux.field_3 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000139c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_spg_mux.field_4
		""
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_spg_mux.field_4 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000139e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_spg_mux.field_5
		""
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_spg_mux.field_5 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_i_para_spg_mux.field_6
		""
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_i_para_spg_mux.field_6 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00013a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_para_mux_npu.field_1
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_para_mux_npu.field_1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_para_mux_npu.field_2
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_para_mux_npu.field_2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_para_mux_pr.field_1
		""
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vtx_vnt_para_mux_pr.field_1 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_para_mux_pr.field_2
		""
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vtx_vnt_para_mux_pr.field_2 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_para_mux_rij.field_1
		""
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vtx_vnt_para_mux_rij.field_1 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001e52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_para_mux_rij.field_2
		""
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vtx_vnt_para_mux_rij.field_2 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001e54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_reg_ex_lim_mux.field_1
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_reg_ex_lim_mux.field_1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_reg_ex_lim_mux.field_2
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_reg_ex_lim_mux.field_2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_reg_lim_mux.field_1
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_reg_lim_mux.field_1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001372 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_reg_lim_mux.field_2
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_reg_lim_mux.field_2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001374 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_reg_spg_lim_mux.field_1
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_reg_spg_lim_mux.field_1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_reg_spg_lim_mux.field_2
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_reg_spg_lim_mux.field_2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_npu.field_1
		"Activation time of anti-surging mode"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_npu.field_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00013b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_npu.field_2
		"Value of the high threshold for anti-surging mode activation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_npu.field_2 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00013b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_npu.field_3
		"Value of the low threshold for anti-surging mode activation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_npu.field_3 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00013ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_npu.field_4
		"Boost rco command during anti-surging mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_npu.field_4 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_npu.field_5
		"Activation calibration of anti-surging mode after combustion mode arbitration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_npu.field_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00013be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_pr.field_1
		"Activation time of anti-surging mode"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_pr.field_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00013c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_pr.field_2
		"Value of the high threshold for anti-surging mode activation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_pr.field_2 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00013c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_pr.field_3
		"Value of the low threshold for anti-surging mode activation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_pr.field_3 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00013c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_pr.field_4
		"Boost rco command during anti-surging mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_pr.field_4 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_pr.field_5
		"Activation calibration of anti-surging mode after combustion mode arbitration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_pr.field_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00013cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_rij.field_1
		"Activation time of anti-surging mode"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_rij.field_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00013d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_rij.field_2
		"Value of the high threshold for anti-surging mode activation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_rij.field_2 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00013da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_rij.field_3
		"Value of the low threshold for anti-surging mode activation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_rij.field_3 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00013dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_rij.field_4
		"Boost rco command during anti-surging mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_rij.field_4 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_sge_para_mux_rij.field_5
		"Activation calibration of anti-surging mode after combustion mode arbitration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_vnt_sge_para_mux_rij.field_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00013e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpnpux_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_stt_thd_mux_npu.field1
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_stt_thd_mux_npu.field1 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001436 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpnpux_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_stt_thd_mux_npu.field2
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_stt_thd_mux_npu.field2 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001438 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_stt_thd_mux_pr.field1
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_stt_thd_mux_pr.field1 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001446 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_stt_thd_mux_pr.field2
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_stt_thd_mux_pr.field2 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001448 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_stt_thd_mux_rij.field1
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_stt_thd_mux_rij.field1 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001456 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_stt_thd_mux_rij.field2
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_stt_thd_mux_rij.field2 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001458 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpnpux_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_npu.field1
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_npu.field1 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000143a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpnpux_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_npu.field2
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_npu.field2 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000143c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpnpux_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_npu.field3
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_npu.field3 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000143e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpnpux_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_npu.field4
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_npu.field4 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001440 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpnpux_stbxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_npu.field5
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_npu.field5 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001442 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_pr.field1
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_pr.field1 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000144a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_pr.field2
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_pr.field2 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000144c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_pr.field3
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_pr.field3 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000144e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_pr.field4
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_pr.field4 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001450 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_pr.field5
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_pr.field5 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001452 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_rij.field1
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_rij.field1 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000145a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_rij.field2
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_rij.field2 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000145c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_rij.field3
		""
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_rij.field3 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000145e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_rij.field4
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_rij.field4 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001460 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_vnt_zon_thd_mux_rij.field5
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_vnt_zon_thd_mux_rij.field5 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001462 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n.factor
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxb_n.factor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n.index
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n.index 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n.num_dp
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n.num_dp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cc5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n2.factor
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxb_n2.factor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n2.index
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n2.index 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n2.num_dp
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n2.num_dp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cc9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_filspxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n2_mv.factor
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxb_n2_mv.factor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_filspxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n2_mv.index
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n2_mv.index 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_filspxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n2_mv.num_dp
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n2_mv.num_dp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cbd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxb_n_eng_amp.factor
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxb_n_eng_amp_factor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007780 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxb_n_eng_amp.index
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n_eng_amp_index 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007782 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxb_n_eng_amp.num_dp
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n_eng_amp_num_dp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007783 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_filspxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n_mv.factor
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxb_n_mv.factor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_filspxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n_mv.index
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n_mv.index 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_filspxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_n_mv.num_dp
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_n_mv.num_dp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cc1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_sta_tco.factor
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxb_sta_tco.factor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_sta_tco.index
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_sta_tco.index 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_sta_tco.num_dp
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_sta_tco.num_dp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022db 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_tco.factor
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxb_tco.factor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_tco.index
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_tco.index 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_tco.num_dp
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_tco.num_dp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022df 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_tco2.factor
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxb_tco2.factor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_tco2.index
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_tco2.index 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxb_tco2.num_dp
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxb_tco2.num_dp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022e3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_LID
		"Memorized requested actuator identifier"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_LID 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_VfEmgCtl_thpl_alt_n
		"online data for Ctb_thpl_alt_n"
		UWORD
		ryhzxDd_bDsnzFa_Ehryxwb_r_A_1oa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_VfEmgCtl_thpl_alt_n 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00077dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_abs_ecu_stt
		"State of Brake Control Unit for CAN failure detection."
		UBYTE
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_abs_ecu_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a6b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_abs_ecu_stt_ctr
		"Brake Control Unit counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_abs_ecu_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a7f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_abs_ecu_stt_ctr_mem_dec
		"Brake Control Unit : current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_abs_ecu_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_abs_ecu_stt_ctr_mem_prev
		"Brake Control Unit : current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_abs_ecu_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a81 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_abs_ecu_stt_diag
		"State of Brake Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_abs_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_abs_tra_acel_mv
		"Absolut value of the temporal average of the transverse acceleration"
		UWORD
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		1
		100
		0.
		13.5
    DISPLAY_IDENTIFIER Vxx_abs_tra_acel_mv 
    FORMAT "%7.4" 
    ECU_ADDRESS 0xd0000e7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_acclucs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ac_acel_is_sp
		"Accelerated engine idle speed setpoint request for air conditionning"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_ac_acel_is_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000764e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ac_cmd_dly
		"Air conditioning compressor command timer"
		UBYTE
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		2.55
    DISPLAY_IDENTIFIER Vxx_ac_cmd_dly 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd00019ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ac_ecu_stt
		"State of Climate Control Unit for CAN failure detection."
		UBYTE
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_ac_ecu_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ac_ecu_stt_ctr
		"Climate Control Unit counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ac_ecu_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ac_ecu_stt_ctr_mem_dec
		"AC current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ac_ecu_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a83 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ac_ecu_stt_ctr_mem_prev
		"AC current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ac_ecu_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ac_ecu_stt_diag
		"State of Climate Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ac_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ac_max_pow_ena
		"Air conditioning maximum power authorized by ECM"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_ac_max_pow_ena 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00077ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ac_min_is_n
		"Air conditioning idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_ac_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000776e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ac_pow
		"Air conditioning absorbed power (compressor)"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_ac_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001930 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ac_prs
		"Relative air conditioning pressure"
		UWORD
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_ac_prs 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000e66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ac_prs_lvl
		"Climate pressure area"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ac_prs_lvl 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001e31 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ac_stt_dly
		"Air conditioning compressor state timer"
		UBYTE
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		2.55
    DISPLAY_IDENTIFIER Vxx_ac_stt_dly 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd00019af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ac_vs
		"Vehicle speed used by ac strategy"
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ac_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000237c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acc_cmd_stt
		"ACC steering wheel commands transmitted to ACC ECU"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		31.
    DISPLAY_IDENTIFIER Vxx_acc_cmd_stt 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001c55 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_acc_ecu_stt
		"State of Automatic Cruise Control Unit for CAN."
		UBYTE
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_acc_ecu_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a85 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_acc_ecu_stt_ctr
		"Automatic Cruise Control Unit counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_acc_ecu_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_acc_ecu_stt_ctr_mem_dec
		"ACC current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_acc_ecu_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a87 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_acc_ecu_stt_ctr_mem_prev
		"ACC current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_acc_ecu_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_acc_ecu_stt_diag
		"State of Automatic Cruise Control Unit failure detection for Mux Network frame²"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_acc_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciacc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciacc_noaccxx_data.c' */
/begin MEASUREMENT
		Vxx_acc_forc_sp
		"Driving force requested by active cruise control."
		UWORD
		mbowslc_inojbha_jnBnagc_N__010a
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER VXX_ACC_FORC_SP 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007b12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acc_pwt_sp
		"Powertrain setpoint (%) requested by ACC"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acc_pwt_sp 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0000940 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acc_swi
		"ACC/speed limiter main switch position transmitted to ACC ECU"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_acc_swi 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00022f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_0_rat_v
		"Uref ratio value defining 0 pedal ratio position"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_0_rat_v 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0000dfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_100_rat_v
		"Uref ratio value defining 1 pedal ratio position"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_100_rat_v 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0000dfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_100_rat_v_max
		"Uref ratio value defining the activation of 100% pedal ratio flag"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_100_rat_v_max 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0000e00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_dif
		"Difference between raw and filtered accelerator pedal ratio, to detect strong acceleration demands."
		UWORD
		Fyedevd_rnBqacd_ulakuub_roA_00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_dif 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0007722 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_fil_sens_v1
		"filtered accelerator pedal sensor output voltage: track 1"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_fil_sens_v1 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00018e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_fil_sens_v2
		"filtered accelerator pedal sensor output voltage: track 2"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_fil_sens_v2 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00018e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_fmt_fac
		"Interpolation factor between pedal progressivity maps (0<=>map1, 1<=>map2)"
		UBYTE
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_fmt_fac 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0001dc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_forc_sp
		"Driving force requested by the driver via the accelerator pedal"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_forc_sp 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00049a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_grd
		"Accelerator pedal gradient"
		SWORD
		pikndba_Biezwsc_vivAhda_roCR5a0
		1
		100
		-64.
		63.998046875
    DISPLAY_IDENTIFIER Vxx_acel_pdl_grd 
    FORMAT "%7.3" 
    ECU_ADDRESS 0xd00077c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_grd_abs
		"Absolute value of accelerator pedal ratio gradient"
		UWORD
		xrnmuaa_rEFCrod_vifAgta_roCR1a0
		1
		100
		0.
		20.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_grd_abs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007724 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_grd_abs_fil
		"Absolute value of accelerator pedal ratio gradient"
		UWORD
		xrnmuaa_rEFCrod_vifAgta_roCR1a0
		1
		100
		0.
		20.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_grd_abs_fil 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007726 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_kd_in_thd
		"Uref ratio entry threshold for accelerato pedal kick-down detection"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_kd_in_thd 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0000e02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_n_dif
		"Difference between engine speed setpoint and measured engine speed in pedal limp home"
		SWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_n_dif 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000111e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_n_i
		"Integrate term of engine speed regulator in pedal limp home"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_n_i 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001120 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_n_sp
		"Engine speed setpoint in pedal limp home (after slope)"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_n_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001122 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_n_tqe
		"Pedal limp home engine torque from the engine speed regulator"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_n_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001124 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_pwt
		"Powertrain setpoint calculated by the regulators (before the application of the foot-up)"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_pwt 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0001126 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_pwt_load
		"Powertrain setpoint calculated by the regulators (transition with normal mode and pedal level)"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_pwt_load 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0001128 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_pwt_sp
		"Powertrain setpoint (%) requested by accelerator pedal safety strategy"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_pwt_sp 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd000111c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_tqe_sp
		"Accelerator pedal limp home engine torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_tqe_sp 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000112a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_vs_dif
		"Difference between vehicle speed setpoint and measured vehicle speed in pedal limp home"
		SWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		-255.
		255.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_vs_dif 
    FORMAT "%8.3" 
    ECU_ADDRESS 0xd000112c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_vs_i
		"Integrate term of vehicle speed regulator in pedal limp home"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_vs_i 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000112e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_vs_sp
		"Vehicle speed setpoint in pedal limp home (after slope)"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_vs_sp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001130 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_lih_vs_tqe
		"Pedal limp home engine torque from the vehicle speed regulator"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_acel_pdl_lih_vs_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001132 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_pwt_sp
		"Powertrain setpoint (%) requested by the driver via the accelerator pedal"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_pwt_sp 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0001108 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_rat
		"Normalised accelerator pedal position"
		UWORD
		omqfgpc_fbAwBcc_yctdhkb_f_Ra0oa
		1
		100
		0.
		1.25
    DISPLAY_IDENTIFIER Vxx_acel_pdl_rat 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0000dfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_sens_rat1
		"Accelerator pedal sensor output voltage ratio : track 1"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_sens_rat1 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00018e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_sens_rat2
		"Accelerator pedal sensor output voltage ratio : track 2"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_sens_rat2 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00018e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_sens_v
		"filtered accelerator pedal sensor output voltage: track 1"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_sens_v 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0000e04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acel_pdl_v
		"Accelerator pedal sensor output voltage (Upot1 or Upot2 or safety replacement value)"
		UWORD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_v 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0000e06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acs_ena_dly
		"Accessories reactivation timer"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_acs_ena_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00077c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_acs_min_is_n
		"Accessories idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_acs_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007770 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_act_deact_id_buf_2
		"Root cause of the deactivation or activation stored in RAM in the second buffer"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_act_deact_id_buf_2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_10ms_t
		"Scheduler recurence"
		UBYTE
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		0.255
    DISPLAY_IDENTIFIER Vxx_agb_10ms_t 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00022ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_csm_tq
		"coupler torque losses"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_agb_csm_tq 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0000ddc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_csm_tq_dft
		"coupler torque losses in degraded mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_agb_csm_tq_dft 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007640 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_csm_tq_fil
		"coupler torque losses filtered"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_agb_csm_tq_fil 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007642 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_csm_tq_is_n_fac
		"Factor on torque converter losses according to the difference between the nominal engine speed setpoint and the real setpoint"
		UBYTE
		ftmodod_Ffszhha_Fbvahrc_n_R0ooa
		1
		100
		0.
		3.984375
    DISPLAY_IDENTIFIER Vxx_agb_csm_tq_is_n_fac 
    FORMAT "%8.6" 
    ECU_ADDRESS 0xd00022ed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_csm_tq_ofs
		"Torque offset to estimate the gearbox losses"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_agb_csm_tq_ofs 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007644 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_csm_tq_slop
		"coupler torque losses with the slew rate"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_agb_csm_tq_slop 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007646 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_spcxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_driv_spt_fac
		"Sportivity factor calculated by Automatic Transmission"
		UBYTE
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_agb_driv_spt_fac 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0001c15 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_agb_ecu_stt
		"Automatic Gear Box Control Unit counter for validated CAN failure detection."
		UBYTE
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_agb_ecu_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_agb_ecu_stt_ctr
		"Automatic Gear Box Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_agb_ecu_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a89 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_agb_ecu_stt_ctr_mem_dec
		"AGB : current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_agb_ecu_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_agb_ecu_stt_ctr_mem_prev
		"AGB : current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_agb_ecu_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_agb_ecu_stt_diag
		"State of Automatic Gear Box Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_agb_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a71 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_int_t
		"Delay between two consecutive calls to SDFTA"
		UBYTE
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		0.255
    DISPLAY_IDENTIFIER Vxx_agb_int_t 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00022ef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_agbspcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_is_acel_sp
		"Automatic Transmission idle speed setpoint acceleration required"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_agb_is_acel_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007652 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_lim_tqe
		"AGB engine torque limitation"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_agb_lim_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000dee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_max_tqe_sp
		"setpoint request wich will be sent to torque arbitration in max bloc"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_agb_max_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000df0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_max_tqe_tgt
		"Slow request wich will be sent to torque arbitration in max bloc"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_agb_max_tqe_tgt 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000df2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_atissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_min_is_n
		"Automatic Transmission idle speed setpoint required"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_agb_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000122a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_min_tqe_sp
		"Setpoint request wich will be sent to torque arbitration in min bloc"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_agb_min_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000df4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_min_tqe_tgt
		"Slow request wich will be sent to torque arbitration in min bloc"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_agb_min_tqe_tgt 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000df6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_agb_tq_dif_n_is_n_sp
		"Difference between the engine speed and the idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_agb_tq_dif_n_is_n_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000dde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_air_dens_ex
		"Air density"
		UWORD
		yvyupqb_iFBfdid_awzApyb_kE__0a0
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_air_dens_ex 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0007558 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_air_dens_in
		"Air density"
		UWORD
		yvyupqb_iFBfdid_awzApyb_kE__0a0
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_air_dens_in 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000755a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiesi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiesi_mngtxcs_data.c' */
/begin MEASUREMENT
		Vxx_airb1
		"Byte n°1 of the AIRBAGCrash frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_airb1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiesi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiesi_mngtxcs_data.c' */
/begin MEASUREMENT
		Vxx_airb2
		"Byte n°2 of the AIRBAGCrash frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_airb2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cdb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_aux_tql
		"Torque losses due to accessories, for Anti-Jerk Strategy"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_ajs_aux_tql 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000118e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_dyn_tqe
		"Torque correction calculated by AJCOR function"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_dyn_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0000960 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_dz_dly_spc
		"Specific time delay of AJCOR dead zone"
		UBYTE
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		25.5
    DISPLAY_IDENTIFIER Vxx_ajs_cor_dz_dly_spc 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd000198d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_dz_tqe
		"torque value threshold of AJCOR dead zone"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_dz_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000962 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_dz_tqe_spc
		"Specific torque threshold of the AJCOR dead zone"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_dz_tqe_spc 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000986 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_fast_cor_dly
		"Maximum time to inhibate the anti-jerk correction during the boost of the curative anti-jerk function."
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_ajs_cor_fast_cor_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000964 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_lim_dyn_tqe
		"Limited torque correction calculated by AJCOR function"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_lim_dyn_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0000966 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_lim_dz_dyn_tqe
		"Limited torque correction calculated by AJCOR function. This torque calculation included dead zone"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_lim_dz_dyn_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0000968 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_max_cor_dyn
		"Maximum dynamic torque correction autorized for AJCOR when driveline is closed"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_max_cor_dyn 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000096a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_max_cor_dyn_spc
		"Specific maximum dynamic torque correction autorized for AJCOR"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_max_cor_dyn_spc 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000988 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_min_cor_dyn
		"Minimum dynamic torque correction autorized for AJCOR when driveline is closed"
		UWORD
		zbhcjic_qmhpFyc_chelcsd_N__338a
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_min_cor_dyn 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000096c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_min_cor_dyn_spc
		"Specific minimum dynamic torque correction autorized for AJCOR"
		UWORD
		zbhcjic_qmhpFyc_chelcsd_N__338a
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_min_cor_dyn_spc 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000098a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_n_diff
		"Difference between engine speed and idle speed setpoint in AJCOR function"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_ajs_cor_n_diff 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000096e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_spc_rat
		"Specific ratio for AJCOR parameters interpolation"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_cor_spc_rat 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000098c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_t1
		"AJCOR final time constant value"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_cor_t1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000970 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_t1_acel
		"AJCOR time constant value calculated for vehicle acceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_cor_t1_acel 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000972 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_t1_acel_dt_clos_spc
		"Specific AJCOR time constant value calculated for vehicle acceleration when driveline is closed"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_cor_t1_acel_dt_clos_spc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000098e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_t1_decl
		"AJCOR time constant value calculated for vehicle deceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_cor_t1_decl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000974 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_t1_decl_dt_clos_spc
		"Specific AJCOR time constant value calculated for vehicle deceleration when driveline is closed"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_cor_t1_decl_dt_clos_spc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000990 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_t1_fast_cor
		"AJCOR time constant value used during the boost of the curative anti-jerk function"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_cor_t1_fast_cor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000976 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_td
		"AJCOR final gain value (NB:unit=(N.m/rpm)^(1/2))"
		UWORD
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_cor_td 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000978 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_td_acel
		"AJCOR gain value calculated for vehicle acceleration (unit=(N.m/rpm)^(1/2))"
		UWORD
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_cor_td_acel 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000097a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_td_acel_dt_clos_spc
		"Specific AJCOR gain value calculated for vehicle acceleration when driveline is closed"
		UWORD
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_cor_td_acel_dt_clos_spc 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000992 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_td_decl
		"AJCOR gain value calculated for vehicle deceleration (unit=(N.m/rpm)^(1/2))"
		UWORD
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_cor_td_decl 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000097c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_td_decl_dt_clos_spc
		"Specific AJCOR gain value calculated for vehicle deceleration when driveline is closed"
		UWORD
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_cor_td_decl_dt_clos_spc 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000994 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_td_fast_cor
		"AJCOR gain value used during the boost of the curative anti-jerk function (NB:unit=(N.m/rpm)^(1/2))"
		UWORD
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_cor_td_fast_cor 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000097e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_td_tq_fac
		"AjCOR modulation factor for the filter gain"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_ajs_cor_td_tq_fac 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000980 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_td_tq_fac_spc
		"Specific modulation factor of the AJCOR filter gain when driveline is closed"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_ajs_cor_td_tq_fac_spc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000996 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_tqe
		"Torque correction calculated by AJCOR function but not limited"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0000982 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_cor_tqe_tmp
		"Intermediate calculation of the torque correction in the AJCOR filter"
		UWORD
		Dkodjkb_csClkBa_ikdmeDa_ippA01a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_cor_tqe_tmp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000984 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_coup_grip_rat
		"Coupler grip ratio (tuned with coupler state)"
		UBYTE
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_coup_grip_rat 
    FORMAT "%3.1" 
    ECU_ADDRESS 0xd0001dd5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_driv_pwt_sp_grd
		"Driver powertrain setpoint derivative used in the anti-jerk strategy"
		UWORD
		pEmaegc_clacCDa_mtFteua_roCRa0a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_ajs_driv_pwt_sp_grd 
    FORMAT "%8.3" 
    ECU_ADDRESS 0xd0001192 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_driv_tq_drv
		"Derivative of the driver torque demand"
		UWORD
		skzzggb_gryEsta_lpfamqd_n__420a
		1
		100
		-5000.
		5000.
    DISPLAY_IDENTIFIER Vxx_ajs_driv_tq_drv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001194 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_dt_grip_rat
		"Driveline grip ratio (integrates coupler grip ratio and calculated declutch state)"
		UBYTE
		yuEqExb_buwnyAb_Fbvbdrc_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_dt_grip_rat 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001dd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_dt_tq_rat
		"Driveline torque ratio : wheel_torque/engine_torque"
		UWORD
		vtyvFka_akFtnud_rnCproc_n__1a0a
		1
		100
		-10.
		200.
    DISPLAY_IDENTIFIER Vxx_ajs_dt_tq_rat 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001190 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_estixxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ajs_esti_tqe
		"Estimated effective engine torque used in the anti-jerk strategy"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_esti_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000119e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_gear_rat_n
		"Gear rotary speed ratio : wheel_speed/engine_speed (tuned with gear state)"
		UWORD
		vtyvFka_akFtnud_rnCproc_n__1a0a
		1
		100
		-10.
		200.
    DISPLAY_IDENTIFIER Vxx_ajs_gear_rat_n 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001196 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_n_mv
		"Filtered engine speed after status validation"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_ajs_modu_n_mv 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001144 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_n_mv_spc
		"Specific filtered engine speed after status validation"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_ajs_modu_n_mv_spc 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000095e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1
		"AJMOD time constant value before slack effect"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001146 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_acel
		"AJMOD time constant value calculated for vehicle acceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_acel 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001148 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_acel_dt_clos
		"AJMOD time constant value calculated when driveline is closed for vehicle acceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_acel_dt_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000114a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_acel_dt_modu
		"AJMOD time constant value when driveline is in modulation mode for vehicle acceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_acel_dt_modu 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000114c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_acel_dt_open
		"AJMOD time constant value for the declutched state for vehicle acceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_acel_dt_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000114e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_acel_fac
		"AJMOD modulation factor for the filter time constant when driveline is closed for vehicle acceleration"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_acel_fac 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001150 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_acel_spc
		"Specific time constant value calculated for vehicle acceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_acel_spc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000094a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_bfr_drag
		"AJMOD time constant value before drag error correction"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_bfr_drag 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001152 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_decl
		"AJMOD time constant value calculated for vehicle deceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_decl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001154 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_decl_dt_clos
		"AJMOD time constant value calculated when driveline is closed for vehicle deceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_decl_dt_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001156 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_decl_fac
		"AJMOD modulation factor for the filter time constant when driveline is closed for vehicle deceleration"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_decl_fac 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001158 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_decl_spc
		"Specific time constant value calculated for vehicle deceleration"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_decl_spc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000094c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_sp
		"AJMOD time constant for filtering action on torque setpoint"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_sp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000115a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_t1_tgt
		"AJMOD time constant for filtering action on torque target"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_modu_t1_tgt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000115c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td
		"AJMOD gain value before slack effect"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000115e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_acel
		"AJMOD gain value calculated for vehicle acceleration"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_acel 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0001160 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_acel_dt_clos
		"AJMOD gain value calculated when driveline is closed for vehicle acceleration"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_acel_dt_clos 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0001162 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_acel_dt_modu
		"AJMOD gain value when driveline is in modulation mode for vehicle acceleration"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_acel_dt_modu 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0001164 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_acel_dt_open
		"AJMOD gain value for the declutched state for vehicle acceleration"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_acel_dt_open 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0001166 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_acel_fac
		"AJMOD modulation factor for the filter gain when driveline is closed for vehicle acceleration"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_acel_fac 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001168 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_acel_spc
		"Specific gain value calculated for vehicle acceleration"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_acel_spc 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000094e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_decl
		"AJMOD gain value calculated for vehicle deceleration"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_decl 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000116a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_decl_dt_clos
		"AJMOD gain value calculated when driveline is closed for vehicle deceleration"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_decl_dt_clos 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd000116c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_decl_fac
		"AJMOD modulation factor for the filter gain when driveline is closed for vehicle deceleration"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_decl_fac 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000116e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_decl_spc
		"Specific gain value calculated for vehicle deceleration"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_decl_spc 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000950 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_sp
		"AJMOD gain for filtering action on torque setpoint"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_sp 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0001170 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_td_tgt
		"AJMOD gain for filtering action on torque target"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_modu_td_tgt 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0001172 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_tqe_sp
		"Final torque setpoint after AJMOD action"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_modu_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001140 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_tqe_sp_fil
		"Torque setpoint after AJMOD filtering action"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_modu_tqe_sp_fil 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001174 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_tqe_tgt
		"Final Torque Target after AJS Modulation action"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_modu_tqe_tgt 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001142 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_modu_tqe_tgt_fil
		"Torque target after AJMOD filtering action"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_modu_tqe_tgt_fil 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001176 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_slk_dly_t1
		"Delay of action of the slack effect calculated"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_slk_dly_t1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001178 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_slk_dly_t1_spc
		"Specific delay of action of the slack effect calculated"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_slk_dly_t1_spc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000952 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_slk_t1_ini_max
		"Calculated value of filter time constant initial offset added by the slack at it's activation"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_slk_t1_ini_max 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000117a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_slk_t1_ini_max_spc
		"Specific calculated value of filter time constant initial offset added by the slack at its activation"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_ajs_slk_t1_ini_max_spc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000954 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_slk_tqe_off_acel_spc
		"Specific torque high threshold to deactivate the slack effect for vehicle acceleration"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_slk_tqe_off_acel_spc 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000956 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_slk_tqe_off_decl_spc
		"Specific torque high threshold to deactivate the slack effect for vehicle deceleration"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_slk_tqe_off_decl_spc 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000958 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_slk_tqe_on_acel_spc
		"Specific torque low threshold to deactivate the slack effect for vehicle acceleration"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_slk_tqe_on_acel_spc 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000095a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_slk_tqe_on_decl_spc
		"Specific torque low threshold to deactivate the slack effect for vehicle deceleration"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_slk_tqe_on_decl_spc 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000095c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_slk_tqe_sp
		"Effective engine torque selected for the slack effect activation"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_ajs_slk_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001198 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spccdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ajs_spc_rat
		"Specific ratio for Anti Jerk parameters interpolation"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_spc_rat 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000948 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_spd_diff
		"Difference between engine speed and primary shaft speed."
		SWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vxx_ajs_spd_diff 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000119a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_spv_driv_tq_drv
		"Formated derivative of driver torque demand"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_spv_driv_tq_drv 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001dd7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_spv_driv_tq_fac
		"Normalized driver torque factor"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_spv_driv_tq_fac 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001dd3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_spv_driv_tq_rat
		"Torque ratio between the driver demand and the available torque"
		SBYTE
		wzddcwc_BwcCemc_Fbfbcrc_n_R0ooa
		1
		100
		-1.
		1.
    DISPLAY_IDENTIFIER Vxx_ajs_spv_driv_tq_rat 
    FORMAT "%8.5" 
    ECU_ADDRESS 0xd0001dd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ajs_spv_fast_cor_dly
		"Maximum time for the application of the boost of the curative anti-jerk"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_ajs_spv_fast_cor_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000119c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_alt_max_pow_ena
		"Alternator maximum power authorized by the ECM"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_alt_max_pow_ena 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00077bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_alt_pow
		"Alternator mechanical power"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_alt_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007654 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_alt_pow_fil_fac
		"Alternator power filtering factor"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_alt_pow_fil_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0007656 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_alt_pow_load
		"Alternator power load"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_alt_pow_load 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007658 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_altdfcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_alt_pwm
		"Filtered alternator load"
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_alt_pwm 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0001cd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_alt_slop_req
		"Power slope sent to the USM"
		UBYTE
		sBxEEjc_FDsdgfc_lunhtFd_WCRana0
		1
		100
		0.
		10200.
    DISPLAY_IDENTIFIER Vxx_alt_slop_req 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000237b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_amp
		"Atmospheric pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_amp 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_amp_conv
		"Atmospheric pressure used in tedoc1 model"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_amp_conv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00075ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_amp_reg
		"Local atmospheric pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_amp_reg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006442 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ant_coup
		"Anticipated (forecast) transmission coupler state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ant_coup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c77 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ant_gear
		"Anticipated gear engaged"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vxx_ant_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001c78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ant_gear_2
		"Anticipated gear engaged high precision"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vxx_ant_gear_2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00018f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ant_gear_mem
		"Last lower gear high precision"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vxx_ant_gear_mem 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00018f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ant_vs
		"Vxx_ant_vs"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_apmp_gear
		"Vxx_apmp_gear"
		UBYTE
		VA_F_1_p2_23
		2
		100
		2
		257
    ECU_ADDRESS 0xd0001d86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapmxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_apmp_gear_sel
		"Vxx_apmp_gear_sel"
		UBYTE
		VA_F_1_p1_2
		2
		100
		1
		256
    ECU_ADDRESS 0xd0001d8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_arb_dec_slop
		"Arbitrated decrease slope applied to the current arbitrated idle speed"
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vxx_arb_dec_slop 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000099a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_arb_driv_pwt_sp
		"Powertrain setpoint (%) requested by real (pedal) and virtual (ACC/CC/SL) drivers before foot-up correction"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_arb_driv_pwt_sp 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0000942 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_arb_inc_slop
		"Arbitrated decrease slope applied to the current arbitrated idle speed"
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_arb_inc_slop 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000099c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_arb_lim_is
		"Arbitrated decrease slope applied to the current arbitrated idle speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_arb_lim_is 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000099e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_arbitxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_arb_no_agb_tqe
		"torque request wihout agb request"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_arb_no_agb_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00011a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_arb_raw_is
		"Arbitrated raw idle speed setpoint (without min/max limitation)"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_arb_raw_is 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00009a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_arbitxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_arb_tqe_raw
		"Slow torque withour AT request and without anti-jerk."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_arb_tqe_raw 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00011a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_arbitxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_arb_tqe_sp
		"Torque Setpoint before AJS Correction action"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_arb_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00011a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_arbitxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_arb_tqe_tgt
		"Torque Target before AJS Correction action"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_arb_tqe_tgt 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00011aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_asr_msr_20ms_t
		"Reccurence time of the block"
		UBYTE
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		0.255
    DISPLAY_IDENTIFIER Vxx_asr_msr_20ms_t 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0001cb7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_asr_tqe_sp
		"ASR setpoint torque sent to torque arbitration"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_asr_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000e2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_asr_tqe_tgt
		"ASR target torque sent to torque arbitration"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_asr_tqe_tgt 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000e30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_lossxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_aux_tql_sp
		"Torque losses due to accessories"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_aux_tql_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_bus_off_stt
		"State of Bus Off for CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_bus_off_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001a8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_bus_off_stt_ctr
		"Bus Off counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_bus_off_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a8d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_bus_off_stt_ctr_mem_dec
		"Bus Off Control Unit : current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_bus_off_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_bus_off_stt_ctr_mem_prev
		"Bus Off Control Unit : current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_bus_off_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a8f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_bus_off_stt_diag
		"State of Bus Off Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_bus_off_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_byp_03_sub_val
		"Replacement value requested by Monitool to control identifier 03"
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_byp_03_sub_val 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001b08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_byp_06_sub_val
		"Replacement value requested to control identifier 06"
		UWORD
		rkcmmwd_dnCngmd_ycnokbb_B__000a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_byp_06_sub_val 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000d0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vxx_byp_0a_sub_val
		"Replacement value requested by Monitool to control identifier 0a"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_byp_0a_sub_val 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000276f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_byp_1d_sub_val
		"Replacement value requested by Monitool to control identifier 1d"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_byp_1d_sub_val 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_byp_1e_sub_val
		"Replacement value requested by Monitool to control identifier 1e"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_byp_1e_sub_val 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0000d0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_byp_1f_sub_val
		"Replacement value requested to control identifier 1f"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_byp_1f_sub_val 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_byp_29_sub_val
		"Replacement value requested to control identifier 29"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_byp_29_sub_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_byp_3d_sub_val
		"Replacement value requested by Monitool to control identifier 3d"
		UWORD
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_byp_3d_sub_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vxx_byp_3e_sub_val
		"Replacement value requested by Monitool to control identifier 3e"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_byp_3e_sub_val 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002770 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_byp_3f_sub_val
		"Replacement value requested by Monitool to control identifier 3f"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vxx_byp_3f_sub_val 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001b09 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_byp_40_sub_val
		"Replacement value requested by Monitool to control identifier 40"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_byp_40_sub_val 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001b0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vxx_byp_46_sub_val
		"Replacement value requested by Monitool to control identifier 46"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_byp_46_sub_val 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002771 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vxx_byp_47_sub_val
		"Replacement value requested by Monitool to control identifier 47"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_byp_47_sub_val 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002772 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_capture_all_nr
		"Current number of DTC matching the StatusMask by RSA_API_CaptureAllDTCStatus function call"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_capture_all_nr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007adc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_capture_all_pres_iter
		"Current last index updated by RSA_API_CaptureAllDTCStatus function"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_capture_all_pres_iter 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007ade 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_capture_obd_nr
		"Current number of DTC matching the StatusMask by RSA_API_CaptureAllOBDDTCStatus function call"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_capture_obd_nr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007ae0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_capture_obd_pres_iter
		"Current last index updated by RSA_API_CaptureAllOBDDTCStatus function"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_capture_obd_pres_iter 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007ae2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_cata_nok_cge_max_nom
		"Diagnosis maximum threshold for mod6 before hidden OBD switch"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_cata_nok_cge_max_nom 
    ECU_ADDRESS 0xd00063d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_cata_nok_cge_min_nom
		"Diagnosis minimum threshold for mod6 before hidden OBD switch"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_cata_nok_cge_min_nom 
    ECU_ADDRESS 0xd00063d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_cata_nok_cge_val_nom
		"Diagnosis criterion for mod6 before hidden OBD switch"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_cata_nok_cge_val_nom 
    ECU_ADDRESS 0xd00063ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ccu_ecu_stt
		"State of BCM Control Unit for CAN failure detection."
		UBYTE
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_ccu_ecu_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ccu_ecu_stt_ctr
		"BCM Control Unit counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ccu_ecu_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ccu_ecu_stt_ctr_mem_dec
		"BCM : current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ccu_ecu_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a91 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ccu_ecu_stt_ctr_mem_prev
		"BCM : current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ccu_ecu_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ccu_ecu_stt_diag
		"State of BCM Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ccu_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_checkxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_chk_arb_tqi_raw
		"Raw indicated torque after check"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_chk_arb_tqi_raw 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001314 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_checkxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_chk_arb_tqi_sp
		"Setpoint indicated torque after check"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_chk_arb_tqi_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001316 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_checkxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_chk_arb_tqi_tgt
		"Target indicated torque after check"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_chk_arb_tqi_tgt 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001318 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_cchkclc_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_chks_c_sw_1
		"Most significant byte of the CVN"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_chks_c_sw_1 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007ae6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_cchkclc_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_chks_c_sw_2
		"Less significant byte of the CVN"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_chks_c_sw_2 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007ae8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_clock_ecu
		"Number of the trame in ECU"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_clock_ecu 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_clock_init_timeout
		"Byte 5 of the request"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_clock_init_timeout 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b0d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_comb_efy
		"Current efficiency combustion"
		UWORD
		uobbrza_onEavnc_ryxBhwb_Ngj_ao0
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_comb_efy 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00009e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_cor_comb_efy_sta
		"Corrected combustion efficiency during Starting Combustion Mode"
		UWORD
		uobbrza_onEavnc_ryxBhwb_Ngj_ao0
		1
		100
		0.001
		10.
    DISPLAY_IDENTIFIER Vxx_cor_comb_efy_sta 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00009e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_coup
		"Coupler state (1 : closed ; 2 : sliding ; 8 : open)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_coup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_cpr_prs_rat
		"Compressor pressure ratio"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_cpr_prs_rat 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0000d90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_cpr_rat_pr
		"Compression ratio"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_cpr_rat_pr 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00013d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_cpr_rat_rij
		"Compression ratio"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_cpr_rat_rij 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00013e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_crt_is
		"Arbitrated decrease slope applied to the current arbitrated idle speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_crt_is 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00009a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_act_deact_id
		"Root cause of the deactivation or activation stored in RAM in the first buffer"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_act_deact_id 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_act_deact_id_to_saved
		"Root cause of the deactivation or activation to be stored from the buffer 1 or 2"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_act_deact_id_to_saved 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_cmp_diag_new
		"carrier for safety failure diagnosis"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_cmp_diag_new 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_cmp_diag_prev
		"Previous carrier for safety failure diagnosis"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_cmp_diag_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d55 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[0]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[0] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[10]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[10] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004ba4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[11]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[11] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004ba8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[12]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[12] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004bac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[13]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[13] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004bb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[14]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[14] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004bb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[15]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[15] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004bb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[16]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[16] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004bbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[17]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[17] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004bc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[18]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[18] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004bc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[19]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[19] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004bc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[1]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[1] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[2]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[2] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[3]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[3] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[4]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[4] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[5]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[5] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[6]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[6] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[7]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[7] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[8]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[8] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dist_buf[9]
		"Mileage associated to the activation or shut off n° 1"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_cru_dist_buf[9] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004ba0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[0]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[0] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[10]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[10] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[11]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[11] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d7b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[12]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[12] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[13]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[13] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d7d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[14]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[14] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[15]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[15] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d7f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[16]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[16] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[17]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[17] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d81 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[18]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[18] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[19]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[19] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d83 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[1]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[1] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d71 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[2]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[2] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[3]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[3] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[4]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[4] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[5]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[5] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[6]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[6] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[7]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[7] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d77 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[8]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[8] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_dsb_buf[9]
		"Root cause of the activation or shut off n°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dsb_buf[9] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_fil_vs_ref
		"CC filtred speed at the corrector input"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_cru_fil_vs_ref 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000908 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_fil_vs_ref_init
		"First of previous CC filtred speed at the corrector input"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_cru_fil_vs_ref_init 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000090a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_fil_vs_ref_prev
		"Previous CC filtred speed at the corrector input"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_cru_fil_vs_ref_prev 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000090c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_forc_sp
		"Driving force requested by Cruise Control"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_cru_forc_sp 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0004ae4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_forc_sp_nom
		"Driving force requested by Cruise Control"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_cru_forc_sp_nom 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0004980 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_pwt_sp
		"Powertrain setpoint (%) requested by Cruise Control"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_cru_pwt_sp 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd000093c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_acel
		"Filtered vehicle acceleration for cruise control  and speed limiter"
		SWORD
		egzsxdd_khlsmxa_bqjovCc_msA_10a
		1
		100
		-12.
		13.5
    DISPLAY_IDENTIFIER Vxx_cru_sl_acel 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000934 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_stflwxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_dacn
		"Compilation of all the cru/sl normal causes of deactivation."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_dacn 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000196b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_stflwxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_dacn_prev
		"Previous compilation of all the cru/sl normal causes of deactivation"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_dacn_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000196d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_stflwxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_dacn_sys_prev
		"Previous compilation of all the cru/sl normal deactivations due to system causes."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_dacn_sys_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000196e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_driv_vs_sp
		"Requested speed selected by the driver (Cruise Control or Speed Limiter)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_driv_vs_sp 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001960 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_driv_vs_sp_kmh
		"Requested speed selected by the driver (Cruise Control or Speed Limiter) in km/h"
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_driv_vs_sp_kmh 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001961 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_dyn_forc_ini
		"Initial resistive force (function of the vehicle speed)"
		UBYTE
		llaAkia_mlcicDa_bdBfbsd_N__400a
		1
		100
		0.
		6375.
    DISPLAY_IDENTIFIER Vxx_cru_sl_dyn_forc_ini 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000195a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_fil_vs_ref
		"Filtered speed at the corrector input"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_cru_sl_fil_vs_ref 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000090e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_forc_ref
		"Force request delivred by the control loop of the cruise control and speed limiter strategy"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_cru_sl_forc_ref 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0004988 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_long_step
		"Value of requested speed step when accel or decel switch pressed continuously"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_long_step 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001984 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_max_vs
		"CC/SL maximal speed setpoint"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_max_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001985 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_min_vs
		"CC/SL minimal speed setpoint"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_min_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001986 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_no_efv_vs_thd
		"Difference between vehicle speed and requested speed to declare CC/SL ineffective"
		UBYTE
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		1
		100
		0.
		25.5
    DISPLAY_IDENTIFIER Vxx_cru_sl_no_efv_vs_thd 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd0001987 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_raw_vs
		"Raw vehicle speed for cruise control and speed limiter strategy"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_cru_sl_raw_vs 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd000093a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_smal_step
		"Value of requested speed step when accel or decel switch pressed during a short time"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_smal_step 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001988 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_sp_inc_dec_dly_cnt
		"Timer for long switch press"
		UBYTE
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		2.55
    DISPLAY_IDENTIFIER Vxx_cru_sl_sp_inc_dec_dly_cnt 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001964 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_stt
		"Cruise control and speed limiter status : parameter sent to the gearbox on the can network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_cru_sl_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001d56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_stt_ip
		"Cruise control and speed limiter status : parameter sent to the cluster on the can network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_cru_sl_stt_ip 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001d57 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_stt_ip_nom
		"Cruise control and speed limiter status : parameter sent to the cluster by CAN for display"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_cru_sl_stt_ip_nom 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001962 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_stflwxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_stt_nom
		"Cruise control and speed limiter status : parameter sent to the gearbox on the CAN network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_cru_sl_stt_nom 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000196c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_acel_ref
		"Acceleration command delivred by the control loop"
		SWORD
		Cnqgazb_fqFBleb_mEzjcxc_kA49o40
		1
		100
		-62.5
		62.4980926513672
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_acel_ref 
    FORMAT "%2.4" 
    ECU_ADDRESS 0xd0000910 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_forc
		"Force command delivered by the control loop"
		SWORD
		lAFjxCa_eiyjaxb_Eqnyxqd_N_R0ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_forc 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0000912 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_forc_ref
		"Total wheel force command delivered by the control loop"
		SWORD
		lAFjxCa_eiyjaxb_Eqnyxqd_N_R0ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_forc_ref 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000914 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_ig
		"Integral gain"
		UWORD
		xhkomjb_oEsFhsa_hslCgmd_1C_522a
		1
		100
		0.
		1953.09519763205
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_ig 
    FORMAT "%9.3" 
    ECU_ADDRESS 0xd0000916 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_max_i_cor
		"maximum value of the integral correction"
		SWORD
		Cnqgazb_fqFBleb_mEzjcxc_kA49o40
		1
		100
		-62.5
		62.4980926513672
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_max_i_cor 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd0000918 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_min_i_cor
		"Minimum value of the integral correction"
		SWORD
		Cnqgazb_fqFBleb_mEzjcxc_kA49o40
		1
		100
		-62.5
		62.4980926513672
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_min_i_cor 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd000091a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_p_cor
		"Propotional correction"
		SWORD
		Cnqgazb_fqFBleb_mEzjcxc_kA49o40
		1
		100
		-62.5
		62.4980926513672
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_p_cor 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd000091c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_pg
		"Proportional gain"
		UWORD
		BAEcsta_ghvaACd_foyhjAa_1_0o00a
		1
		100
		0.
		124.998092651367
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_pg 
    FORMAT "%9.6" 
    ECU_ADDRESS 0xd000091e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_vs_i_cor
		"Integral correction"
		SLONG
		civwepa_tvdpkEc_oqmzysb_k_46480
		1
		100
		-62.5
		62.4999999708962
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_vs_i_cor 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd000498c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_vs_i_cor_init
		"First or previous integral correction"
		SLONG
		civwepa_tvdpkEc_oqmzysb_k_46480
		1
		100
		-62.5
		62.4999999708962
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_vs_i_cor_init 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd0004990 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_svkl_vs_i_cor_prev
		"Previous integral correction"
		SLONG
		civwepa_tvdpkEc_oqmzysb_k_46480
		1
		100
		-62.5
		62.4999999708962
    DISPLAY_IDENTIFIER Vxx_cru_sl_svkl_vs_i_cor_prev 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd0004994 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_vs
		"Vehicle speed filtered by the cruise control/speed limiter strategy"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_cru_sl_vs 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0000936 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_vs_kmh
		"Vehicle speed filtered by the cruise control/speed limiter strategy in km/h"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_cru_sl_vs_kmh 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000938 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_vs_sp
		"Cruise control and speed limiter requested speed sent to the cluster on the can network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_vs_sp 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_vs_sp_nom
		"Cruise control or speed limiter requested speed sent to the cluster by CAN for display"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_vs_sp_nom 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001963 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_whl_cmd_raw
		"State of the steering wheel buttons : not filtered"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vxx_cru_sl_whl_cmd_raw 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00022f7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_sl_whl_cmd_stt
		"State of the steering wheel push buttons"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vxx_cru_sl_whl_cmd_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cru_vs_ref_ofs
		"Reference speed increment"
		UWORD
		aEbBibb_eAtEfyc_nerkgtd_kp__1a0
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_cru_vs_ref_ofs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000920 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_csl_forc_sp
		"Driving force requested by Costumer Speed Limiter"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_csl_forc_sp 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0004ae8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_csl_forc_sp_nom
		"Driving force requested by Costumer Speed Limiter"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_csl_forc_sp_nom 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0004984 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm
		"fuel consumption"
		UWORD
		uztFExb_owBhqra_ykamwda_l__000a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_csm 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000101c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_cyl_comb
		"fuel consumption, sum of fuel mass burn on the cylinder, pinj1, pinj2, main, after, post"
		UWORD
		uztFExb_owBhqra_ykamwda_l__000a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_csm_cyl_comb 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000101e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_cyl_tot
		"fuel consumption, sum of fuel mass injecte on the cylinder, pinj1, pinj2, main, after, post, late post"
		UWORD
		uztFExb_owBhqra_ykamwda_l__000a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_csm_cyl_tot 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001024 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_fil
		"filtered fuel consumption"
		UWORD
		RB_CONV_flconsum
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vxx_csm_fil 
    ECU_ADDRESS 0xd00016f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_rij
		"Consumption in regular injection mode"
		UWORD
		uztFExb_owBhqra_ykamwda_l__000a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_csm_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001020 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_sum_mux
		"Total fuel consumption"
		UBYTE
		cyoczhd_qiwFCea_wcovmmd_mCR1ea0
		1
		100
		0.
		20400.
    DISPLAY_IDENTIFIER Vxx_csm_sum_mux 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001d3f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_sum_mux_rij
		"Nominal fuel consumption"
		UBYTE
		cyoczhd_qiwFCea_wcovmmd_mCR1ea0
		1
		100
		0.
		20400.
    DISPLAY_IDENTIFIER Vxx_csm_sum_mux_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001d40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_ctlcsmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_sum_sta
		"Quantity of fuel injected since engine start"
		UWORD
		kcAgawb_cszkxob_ykbdhoa_l_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_csm_sum_sta 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007584 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_ctlcsmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_sum_sta_drv
		"Injected fuel quantity per second"
		UWORD
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_csm_sum_sta_drv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007586 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_ctlcsmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_sum_sta_drv_fil
		"Filtered injected fuel quantity"
		UWORD
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_csm_sum_sta_drv_fil 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007582 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_sum_sta_drv_fil_rgn
		"Local filtered injected fuel quantity"
		UWORD
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_csm_sum_sta_drv_fil_rgn 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007a20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_csm_sum_sta_drv_ms
		"Filtered injected fuel quantity for soot mass left integration"
		UWORD
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_csm_sum_sta_drv_ms 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006526 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ctr_dspl_up
		"Vxx_ctr_dspl_up"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0002357 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cur_dly
		"Vxx_cur_dly"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0001d8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cur_tra_acel_thd
		"Vxx_cur_tra_acel_thd"
		UWORD
		VA_F_0v0004_p0_1
		2
		100
		0
		26.214
    ECU_ADDRESS 0xd00010a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cut_fil_fac
		"Torque slope limitation for injection cut"
		UWORD
		zlhAlxa_lflywEd_dCwmhyc_NsA_n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vxx_cut_fil_fac 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001280 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_cut_tq_cor_fil
		"Correction to the minimum driver engine torque during injection cut or re-injection"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_cut_tq_cor_fil 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001282 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ddcm_ecu_stt
		"State of DDCM control unit for CAN failure detection"
		UBYTE
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_ddcm_ecu_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ddcm_ecu_stt_ctr
		"DDCM Control Unit counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ddcm_ecu_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a93 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ddcm_ecu_stt_ctr_mem_dec
		"DDCM current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ddcm_ecu_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ddcm_ecu_stt_ctr_mem_prev
		"DDCM current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ddcm_ecu_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ddcm_ecu_stt_diag
		"State of DDCM Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ddcm_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_emtv_cutt_1
		"Number of cutting presence failures noticed on successive driving cycles."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_cutt_1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cf5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_emtv_cutt_2
		"Value of Vxx_dfctr_emtv_cutt_eprm +1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_cutt_2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_emtv_cutt_sta
		"Corresponds to the value red in EEPROM for the variable Vxx_dfctr_emtv_cutt_eprm (at ECU power start)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_cutt_sta 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cf7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_emtv_ofs_no_norm_1
		"Number of first offset learning failures noticed on successive driving cycles."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_ofs_no_norm_1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cf8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_emtv_ofs_no_norm_2
		"Value of Vxx_dfctr_emtv_ofs_no_norm_eprm+1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_ofs_no_norm_2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cf9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_emtv_ofs_no_norm_sta
		"Corresponds to the value red in EEPROM for the variable Vxx_dfctr_emtv_ofs_no_norm_eprm (at ECU power start)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_ofs_no_norm_sta 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_emtv_reg_dirt_1
		"Number of dirty closed thrust failures noticed on successive driving cycles."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_reg_dirt_1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cfb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_emtv_reg_dirt_2
		"Value of Vxx_dfctr_emtv_reg_dirt_eprm + 1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_reg_dirt_2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_emtv_reg_dirt_sta
		"Corresponds to the value red in EEPROM for the variable Vxx_dfctr_emtv_reg_dirt_eprm (at ECU power start)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_reg_dirt_sta 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cfd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_cutt_1
		"Number of cutting presence failures noticed on successive driving cycles"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_cutt_1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_cutt_2
		"Value of Vxx_dfctr_it_cutt_nvm + 1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_cutt_2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_cutt_sta
		"Number of cutting presence failures noticed on successive driving cycles."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_cutt_sta 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d13 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_dirt_clos_1
		"Number of dirty closed thrust failures noticed on successive driving cycles"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_dirt_clos_1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_dirt_clos_2
		"Value of Vxx_dfctr_it_dirt_clos_nvm + 1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_dirt_clos_2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d15 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_dirt_clos_sta
		"Number of dirty closed thrust failures noticed on successive driving cycles."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_dirt_clos_sta 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_ofs_clos_frst_1
		"Number of first offset learning failures noticed on successive driving cycles (closed thrust)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_ofs_clos_frst_1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d17 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_ofs_clos_frst_2
		"Value of Vxx_dfctr_it_ofs_clos_frst_nvm + 1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_ofs_clos_frst_2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_ofs_clos_frst_sta
		"Number of first offset learning failures noticed on successive driving cycles (closed thrust)."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_ofs_clos_frst_sta 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d19 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_ofs_open_frst_1
		"Number of first offset learning failures noticed on successive driving cycles (open thrust)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_ofs_open_frst_1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_ofs_open_frst_2
		"Value of Vxx_dfctr_it_ofs_open_frst_nvm + 1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_ofs_open_frst_2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d1b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfctr_it_ofs_open_frst_sta
		"Number of first offset learning failures noticed on successive driving cycles (open thrust)."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_ofs_open_frst_sta 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfdec_ex_prs_nok
		"Ex man pres sens plausibility detected failure counter decrement"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfdec_ex_prs_nok 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007574 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfinc_doc1_utp_l
		"doc1_utp_l detected failure counter increment"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfinc_doc1_utp_l 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00075c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfinc_ex_prs_nok
		"Ex man pres sens plausibility detected failure counter increment"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfinc_ex_prs_nok 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007576 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfinc_pft_nok_cge
		"Variable malfunctioning CSF detected failure counter increment."
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfinc_pft_nok_cge 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006498 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfinc_pft_utp_l
		"pft_utp low signal detected failure counter increment"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfinc_pft_utp_l 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007618 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dfinc_tbt_l
		"tbt low signal detected failure counter increment"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfinc_tbt_l 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000761e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dhil_gear_sel
		"Vxx_dhil_gear_sel"
		UBYTE
		VA_F_1_p1_2
		2
		100
		1
		256
    ECU_ADDRESS 0xd0001da9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dhil_n_up_shf_in_thd
		"Vxx_dhil_n_up_shf_in_thd"
		UWORD
		VA_F_0v25_p0_7
		2
		100
		0
		16383.75
    ECU_ADDRESS 0xd00010b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dhil_n_up_shf_out_thd
		"Vxx_dhil_n_up_shf_out_thd"
		UWORD
		VA_F_0v25_p0_7
		2
		100
		0
		16383.75
    ECU_ADDRESS 0xd00010b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dhil_vs_down_shf_thd
		"Vxx_dhil_vs_down_shf_thd"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_diag_byp_stab_dly
		"Stabilization delay for EGR by-pass throttle diagnosis"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_diag_byp_stab_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_diag_comb_bas
		"OBD request of active combustion mode"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		15.
    DISPLAY_IDENTIFIER Vxx_diag_comb_bas 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0002290 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_diag_min_is_ofs
		"Temporary tuning idle speed setpoint offset"
		SWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vxx_diag_min_is_ofs 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000775e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_diag_vvtc_min_is_n
		"VVTC routine idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_diag_vvtc_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007746 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dif_n_sp
		""
		SWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vxx_dif_n_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001224 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dif_n_sp_grd
		"Derivative of difference between engine speed and idle speed setpoint by report to the time"
		SWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		-8192.
		8191.
    DISPLAY_IDENTIFIER Vxx_dif_n_sp_grd 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00011ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_diff_rel_err
		"Difference between relative error of the speeds of rear wheels and the delayed average relative error"
		SWORD
		ihlElic_Eatfvkd_DxdrElb_n_o7300
		1
		100
		-0.450002
		0.450002
    DISPLAY_IDENTIFIER Vxx_diff_rel_err 
    FORMAT "%9.6" 
    ECU_ADDRESS 0xd0000e7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dil_mod_sta_oil_dil
		"Oil dilution value at the dilution mode start"
		UWORD
		RB_CONV_100_65535_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_dil_mod_sta_oil_dil 
    ECU_ADDRESS 0xd000676e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fspfzxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dly_driv_pwt_sp_100
		"Vxx_dly_driv_pwt_sp_100"
		UWORD
		VA_F_0v125_p0_14
		2
		100
		0
		8191.875
    ECU_ADDRESS 0xd00010d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dly_frz_gear_sel
		"Vxx_dly_frz_gear_sel"
		UBYTE
		VA_F_1_m1_24
		2
		100
		-1
		254
    ECU_ADDRESS 0xd000235f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dly_gear_sel
		"Vxx_dly_gear_sel"
		UBYTE
		VA_F_1_p1_2
		2
		100
		1
		256
    ECU_ADDRESS 0xd0001da1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dly_pow_r
		"Vxx_dly_pow_r"
		SWORD
		VA_F_10_p0_11
		2
		100
		-327680
		327670
    ECU_ADDRESS 0xd00010ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dly_tq_dif
		"Vxx_dly_tq_dif"
		SWORD
		VA_F_1_p0_5
		2
		100
		-32768
		32767
    ECU_ADDRESS 0xd00010ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_cor_egy_drv_in_temp
		"Corrective Energy of the derivative input temperature"
		SLONG
		aEkiAhc_txCxevc_gDuupfc_JR09917
		1
		100
		-3273.8
		3273.7
    DISPLAY_IDENTIFIER Vxx_doc1_cor_egy_drv_in_temp 
    FORMAT "%12.1" 
    ECU_ADDRESS 0xd00050fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_dif_prs_cpr
		"Compressor differential pressure"
		UWORD
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_doc1_dif_prs_cpr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00075cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_egy_gaz
		"Energy in the gas"
		ULONG
		lcBkDsb_aCkdnbd_Eqnyxyd_J_R0ooa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_doc1_egy_gaz 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0005100 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_egy_loss_tbn
		"(Mechanical/Thermal) Energy loss to the turbine"
		SLONG
		aEkiAhc_txCxevc_gDuupfc_JR09917
		1
		100
		-6502.3
		51.2
    DISPLAY_IDENTIFIER Vxx_doc1_egy_loss_tbn 
    FORMAT "%12.1" 
    ECU_ADDRESS 0xd0005104 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_esti_meca_pow_cpr
		"Estimation of the mechanical power to compressor"
		SLONG
		kEDroFa_Bnfuabd_Eqnyxcc_W_R0ooa
		1
		100
		-65023.
		512.
    DISPLAY_IDENTIFIER Vxx_doc1_esti_meca_pow_cpr 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd0005108 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_esti_meca_pow_vnt
		"Estimation of the mechanical power to turbo"
		SLONG
		kEDroFa_Bnfuabd_Eqnyxcc_W_R0ooa
		1
		100
		-65023.
		512.
    DISPLAY_IDENTIFIER Vxx_doc1_esti_meca_pow_vnt 
    FORMAT "%11.0" 
    ECU_ADDRESS 0xd000510c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_fac_ext_cnvt
		"Coefficient of the external convection"
		UWORD
		lFmDDfb_EFFzjta_ysimAea_W__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_doc1_fac_ext_cnvt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00075ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_fac_itl_cnvt
		"Estimation of the mechanical power to turbo"
		UWORD
		fzxjbBd_syBEseb_ysimAia_W__000a
		1
		100
		0.
		300.
    DISPLAY_IDENTIFIER Vxx_doc1_fac_itl_cnvt 
    FORMAT "%7.3" 
    ECU_ADDRESS 0xd00075d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_gaz_temp_bfr_doc1_conv
		"Gas temperature before DOC converted in K"
		ULONG
		imCajqb_vnxgbdb_hCDvmsa_K__a00a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_doc1_gaz_temp_bfr_doc1_conv 
    FORMAT "%11.3" 
    ECU_ADDRESS 0xd0005110 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_gaz_temp_mem
		"Exhaust gas temperature pre turbine converted in Kelvin"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_doc1_gaz_temp_mem 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00075d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_in_th_egy_ex_gaz
		"Ingoing thermal energy by the exhaust gas"
		UWORD
		kscodEd_uiEnjvd_Eqvyxyd_J_R0ooa
		1
		100
		0.
		32767.5
    DISPLAY_IDENTIFIER Vxx_doc1_in_th_egy_ex_gaz 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00075d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_in_th_egy_ext_cnvt
		"Ingoing thermal energy by external convection (Air/Material Transfer)"
		UWORD
		kscodEd_uiEnjvd_Eqvyxyd_J_R0ooa
		1
		100
		0.
		32767.5
    DISPLAY_IDENTIFIER Vxx_doc1_in_th_egy_ext_cnvt 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00075d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_in_th_egy_itl_cnvt
		"Ingoing thermal energy by internal convection (Material/Gas transfer)"
		UWORD
		kscodEd_uiEnjvd_Eqvyxyd_J_R0ooa
		1
		100
		0.
		32767.5
    DISPLAY_IDENTIFIER Vxx_doc1_in_th_egy_itl_cnvt 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00075d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_inv_vnt_psn_th_loss
		"Inversed Wing Position Efficiency for thermal lose to turbo"
		SWORD
		xBBsjld_iAhBsha_ycnokja_B__000a
		1
		100
		-150.
		150.
    DISPLAY_IDENTIFIER Vxx_doc1_inv_vnt_psn_th_loss 
    FORMAT "%8.3" 
    ECU_ADDRESS 0xd00075da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_itl_cnvt_cur
		"Variable for the internal convection calcul"
		UWORD
		ykmzBoa_nqupBma_Ffvbarc_m_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_doc1_itl_cnvt_cur 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00075dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_mdl_utp
		"Model of gas temperature before doc1"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_doc1_mdl_utp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00075c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_nr_itl_cnvt
		"Number of Nusselt for the internal convection"
		UWORD
		nsFDDzd_bbvtgna_EqfAxwb_m_R0ooa
		1
		100
		0.
		8191.
    DISPLAY_IDENTIFIER Vxx_doc1_nr_itl_cnvt 
    FORMAT "%8.3" 
    ECU_ADDRESS 0xd00075de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_out_th_egy_ex_gaz
		"Outgoing Thermal Energy by the exhaust gas"
		UWORD
		zkjfeib_dzryiya_cCDvqxb_J__000a
		1
		100
		0.
		32.
    DISPLAY_IDENTIFIER Vxx_doc1_out_th_egy_ex_gaz 
    FORMAT "%7.4" 
    ECU_ADDRESS 0xd00075e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_out_th_egy_ext_cnvt
		"Outgoing Thermal Energy by external convection (Material/Air Transfer)"
		UWORD
		wmkdrfc_obthmla_Efhawmc_JCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_doc1_out_th_egy_ext_cnvt 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00075e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_out_th_egy_itl_cnvt
		"Outgoing thermal energy by internal convection (gasl/Materiel transfer)"
		UWORD
		kscodEd_uiEnjvd_Eqvyxyd_J_R0ooa
		1
		100
		0.
		32767.5
    DISPLAY_IDENTIFIER Vxx_doc1_out_th_egy_itl_cnvt 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00075e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_out_th_egy_rd_tbn
		"Outgoing Thermal Energy by radiation of the turbine (turbine + tube)"
		UWORD
		ceahcwa_qAokznd_oCDvqxb_J__000a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_doc1_out_th_egy_rd_tbn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00075e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_temp_esti
		"Temperature material estimated in Kelvin"
		ULONG
		imCajqb_vnxgbdb_hCDvmsa_K__a00a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_doc1_temp_esti 
    FORMAT "%11.3" 
    ECU_ADDRESS 0xd0005114 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_temp_esti_dly
		"Temperature material estimated in Kelvin delay"
		ULONG
		imCajqb_vnxgbdb_hCDvmsa_K__a00a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_doc1_temp_esti_dly 
    FORMAT "%11.3" 
    ECU_ADDRESS 0xd0005118 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_th_egy_bfr_doc1
		"Thermal Energy in the material of the turbine (turbine + tube)"
		ULONG
		lcBkDsb_aCkdnbd_Eqnyxyd_J_R0ooa
		1
		100
		0.
		6553500.
    DISPLAY_IDENTIFIER Vxx_doc1_th_egy_bfr_doc1 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd000511c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_th_egy_gaz
		"Thermal Energy in the gas"
		UWORD
		glDzsCb_yhkjvsa_ysimoha_J__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_doc1_th_egy_gaz 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00075e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_th_egy_itl_cnvt
		"Ingoing/Outgoing Thermal Energy by internal convection"
		UWORD
		ceahcwa_qAokznd_oCDvqxb_J__000a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_doc1_th_egy_itl_cnvt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00075ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_th_egy_tbn
		"Thermal Energy in the material of the turbine (turbine + tube)"
		UWORD
		bbBdoca_FBdtmBd_tFElbrc_J___00a
		1
		100
		0.
		3276.75
    DISPLAY_IDENTIFIER Vxx_doc1_th_egy_tbn 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00075ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1cs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_utp
		"DOC upstream temperature sensor measure"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_doc1_utp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00075c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc1_vol_air_flow
		"Volumetric Air Flow"
		UWORD
		cDliaod_tCvFBmd_ozEgwlc_m__00a0
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_doc1_vol_air_flow 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00075ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc2cs_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc2_utp
		"DOC2 upstream temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_doc2_utp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00075f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_doc_dtp
		"Local Variable for DOC downstream temperature sensor measure"
		UWORD
		RB_CONV_AtCatDgn_DegC
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_doc_dtp 
    ECU_ADDRESS 0xd00063b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_down_air_fil_prs
		"Downstream air filter pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_down_air_fil_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_down_air_fil_prs_sat
		"Downstream air filter pressure saturated"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_down_air_fil_prs_sat 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_down_cpr_prs
		"Downstream compressor pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_down_cpr_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_down_cpr_prs_bfr
		"Previous downstream compressor pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_down_cpr_prs_bfr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_down_cpr_temp
		"Downstream compressor temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_down_cpr_temp 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000d9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_down_cpr_temp_bfr
		"Previous downstream compressor temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_down_cpr_temp_bfr 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000d9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_down_egr_cool_temp_dif_mv
		"mean value of the delta temperature downstream the EGR cooler"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_down_egr_cool_temp_dif_mv 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_down_egr_cool_temp_fil
		"Filtered temperature downstream the EGR cooler"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_down_egr_cool_temp_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_down_egr_cool_temp_max
		"Maximum temperature downstream the EGR cooler during diagnosis"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_down_egr_cool_temp_max 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_down_rat_gear_bkp_tgt
		"Down limit of true range for the current anticipated ratio gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_down_rat_gear_bkp_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001912 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_ptqxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dp
		"Difference pressure between inlet manifold and in front of the turbine"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_dp 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000636e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_ptqxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dp_fil
		"Filtered difference pressure (between inlet manifold and in front of the turbine)"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_dp_fil 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006370 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_driv_pwt_sp
		"Powertrain setpoint (%) requested by real (pedal) and virtual (ACC/CC/SL) drivers"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_driv_pwt_sp 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd000093e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fspfzxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_driv_pwt_sp_100
		"Vxx_driv_pwt_sp_100"
		UWORD
		VA_F_0v125_p0_14
		2
		100
		0
		8191.875
    ECU_ADDRESS 0xd00010d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_driv_sp
		"Normalised instant driver setpoint. IMPORTANT: range is over 100%!"
		UBYTE
		xpgjDwb_wDebpEb_ulakuqa_roA_00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_driv_sp 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd000234f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_driv_sp_grd
		"Normalised instant driver activity. IMPORTANT: range is far over 100%!"
		UWORD
		zjDDbid_AAaguja_ulakuCa_roA_00a
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_driv_sp_grd 
    FORMAT "%7.3" 
    ECU_ADDRESS 0xd0007728 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_driv_sp_grd_mv
		"Normalised mean driver activity for driver sportivity detection"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_driv_sp_grd_mv 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002350 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_driv_sp_mv
		"Normalised mean driver setpoint for driver sportivity detection"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_driv_sp_mv 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002351 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_driv_sp_vs_pow
		"Simple model of aerodynamic drag power"
		UBYTE
		drbdAab_snynrtd_cpBhbcd_W__500a
		1
		100
		0.
		500000.
    DISPLAY_IDENTIFIER Vxx_driv_sp_vs_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0002352 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_dynmoxx_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_driv_spt_fac
		"Driver sportivity factor, including 'slow' and 'fast' adaptation algorithms"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_driv_spt_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000254b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drtqexx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_driv_tqe_sp
		"Effective engine torque requested by real (pedal) and virtual (ACC/CC/SL) drivers"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_driv_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00010fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_dsplvcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dspl_vs
		"Displayed vehicle speed"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_dspl_vs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000e6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dt1_exp
		""
		UWORD
		kybEEsb_fcjzqub_saFowBd_n_ao66a
		1
		100
		0.
		9.
    DISPLAY_IDENTIFIER Vxx_dt1_exp 
    FORMAT "%5.4" 
    ECU_ADDRESS 0xd0000a18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_dt1_maf_reg_damp_fac
		"Damping factor for the dt1 filter"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_dt1_maf_reg_damp_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0001628 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dt_tq_rat
		"Gear rotary speed ratio : wheel_speed/engine_speed (tuned with gear state)"
		UWORD
		vtyvFka_akFtnud_rnCproc_n__1a0a
		1
		100
		-10.
		200.
    DISPLAY_IDENTIFIER Vxx_dt_tq_rat 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001284 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dtc_hmb_cf_redg_edic
		"Diagnosis trouble code (device or function identifier) corresponding to the last confirmed failure raising edge event for EDIC"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dtc_hmb_cf_redg_edic 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dtc_lb_cf_redg_edic
		"Diagnosis trouble code (faulttype identifier) corresponding to the last confirmed failure rising edge event for EDIC"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_lb_cf_redg_edic 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000227e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dyn_forc
		"Resistive force (function of the vehicle speed)"
		UBYTE
		llaAkia_mlcicDa_bdBfbsd_N__400a
		1
		100
		0.
		6375.
    DISPLAY_IDENTIFIER Vxx_dyn_forc 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000195b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_dyn_is_n_sp
		"Dynamic idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_dyn_is_n_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001234 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_dly
		"Opening delay"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_efi_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001006 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_dly_vb_cor
		"Opening delay correction (depending on measured voltage battery)"
		UWORD
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_efi_dly_vb_cor 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0001008 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_ext_sph
		"Exhaust fuel injector external specific enthalpy"
		UWORD
		CpAjotd_qajwitb_dexwBid_W2CR1a0
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_efi_ext_sph 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00075fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_int_sph
		"Exhaust fuel injector internal specific enthalpy"
		UWORD
		CpAjotd_qajwitb_dexwBid_W2CR1a0
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_efi_int_sph 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00075fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_itl_ar_temp
		"Exhaust fuel injector internal surface temperature"
		UWORD
		dFjxvqb_bnBujga_oeusmlb_K__an3a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_efi_itl_ar_temp 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0007600 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_itl_ar_temp_fil
		"Exhaust fuel injector filtered internal surface temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_efi_itl_ar_temp_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00075fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_itl_cp
		"Material calorific capacity"
		UWORD
		AdDehAb_CvnCEyd_wAFgpib_Jp__10a
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_efi_itl_cp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007602 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_max_pr
		"Maximum Final quantity of exhaust fuel injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_efi_max_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00063f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_min_pr
		"Minimum Final quantity of exhaust fuel injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_efi_min_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00063f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_purg_ff
		"Fuel mass flow injected in exhaust line during purge"
		UWORD
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_efi_purg_ff 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007694 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_purg_fwe_clc
		"Calculated fuel wear estimation"
		ULONG
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_efi_purg_fwe_clc 
    FORMAT "%9.3" 
    ECU_ADDRESS 0xd0005174 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_purg_t
		"Time elapsed since purge start"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_efi_purg_t 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007696 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_purg_t_clc
		"Calculated time elapsed since purge start"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_efi_purg_t_clc 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007698 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_purg_wht
		"Fuel purged weight"
		UWORD
		kfEbEnc_fogmuta_Bagagzb_g__100a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_efi_purg_wht 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000769a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efi_purg_wht_clc
		"Fuel purged weight calculated"
		UWORD
		kfEbEnc_fogmuta_Bagagzb_g__100a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_efi_purg_wht_clc 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000769c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efv_ff_mg_strk
		"Effective fuel mass flow desired into exhaust line in mg/strk"
		ULONG
		ndajtgd_xAaAgAa_fzzApva_mt__0a0
		1
		100
		0.
		50.
    DISPLAY_IDENTIFIER Vxx_efv_ff_mg_strk 
    FORMAT "%7.4" 
    ECU_ADDRESS 0xd0004acc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efv_ff_mg_strk_acum
		"Effective fuel mass flow desired into exhaust line in mg/strk acumulation"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_efv_ff_mg_strk_acum 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001026 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efy_spg_cool
		"Supercharger cooler efficiency"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_efy_spg_cool 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0000d9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_efy_spg_cool_sat
		"Supercharger cooler efficiency"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_efy_spg_cool_sat 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0000da0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_byp_blk_max
		"Value of the maximum threshold for OBD service 06 purpose"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_egr_byp_blk_max 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_byp_blk_min
		"Value of the minimum threshold for OBD service 06 purpose"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_egr_byp_blk_min 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_byp_blk_val_mem
		"memorized value of the delta temperature downstream the EGR cooler (OBD service 06 purpose)"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_egr_byp_blk_val_mem 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbscmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_byp_pwm
		"Pwm command of the EGR cooler bypass"
		SWORD
		bcEalnd_AvmCroa_pdqnwqa_fR06012
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_byp_pwm 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001538 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_byp_tco_hys_low
		"First threshold of the component hysteresis (map output)"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_byp_tco_hys_low 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001542 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_byp_veh_dist
		"Value of the distance since the last anti-jamming activation"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_egr_byp_veh_dist 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0004db4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_amp_h_thd
		"High threshold value for air pressure hysteresis cut-off"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_egr_cut_amp_h_thd 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001562 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_amp_l_thd
		"Low threshold value for air pressure hysteresis cut-off"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_egr_cut_amp_l_thd 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001564 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_n_ovs_h_thd
		"High threshold value for engine overspeed hysteresis cut-off"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_egr_cut_n_ovs_h_thd 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001566 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_n_ovs_l_thd
		"Low threshold value for engine overspeed hysteresis cut-off"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_egr_cut_n_ovs_l_thd 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001568 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_n_thd_is
		"Engine speed threshold for idle speed cut off"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_egr_cut_n_thd_is 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000156a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_n_uds_h_thd
		"High threshold value for engine underspeed hysteresis cut-off"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_egr_cut_n_uds_h_thd 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000156c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_n_uds_l_thd
		"Low threshold value for engine underspeed hysteresis cut-off"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_egr_cut_n_uds_l_thd 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000156e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_t_thd_is
		"Threshold time for the cut off condition in idle speed mode"
		UBYTE
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_egr_cut_t_thd_is 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001e6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tco_h_thd
		"High threshold value for coolant temperature hysteresis cut-off"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_cut_tco_h_thd 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001570 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tco_l_thd
		"Low threshold value for coolant temperature hysteresis cut-off"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_cut_tco_l_thd 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001572 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tco_thd_is
		"Value of the tco threshold for egr cut off in idle speed mode"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_cut_tco_thd_is 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001574 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tia_h_thd
		"High threshold value for intake air temperature hysteresis cut-off"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_cut_tia_h_thd 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001576 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tia_l_thd
		"Low threshold value for intake air temperature hysteresis cut-off"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_cut_tia_l_thd 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001578 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tqi_hys_wid
		"Hysteresis width value for fast accel determination"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_egr_cut_tqi_hys_wid 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000157a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tqi_t
		"Value of the time delay at the end of the fast acceleration shut-off"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_egr_cut_tqi_t 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000157c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tqi_tco_cor
		"Torque value correction based on tco for fast accel determination"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_egr_cut_tqi_tco_cor 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000157e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tqi_tco_pr
		"Torque value correction based on tco for fast accel determination in pr mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_egr_cut_tqi_tco_pr 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000155e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tqi_tco_rij_pp
		"Torque value correction based on tco for fast accel determination in rij and pp modes"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_egr_cut_tqi_tco_rij_pp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001560 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_tqi_thd
		"Torque value for the threshold of fast accel determination"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_egr_cut_tqi_thd 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001580 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_cut_vs_thd_is
		"Value of vehicle speed threshold for egr cut off in idle speed mode"
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_egr_cut_vs_thd_is 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001e6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_pwm_rep_decl
		"Replacement position value in case of overrun shut-off condition after combustion mode choice"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_pwm_rep_decl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001588 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_pwm_rep_decl_pp
		"Replacement position value in case of overrun shut-off condition in Pp mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_pwm_rep_decl_pp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001590 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_pwm_rep_decl_pr
		"Replacement position value in case of overrun shut-off condition in Pr mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_pwm_rep_decl_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001598 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_pwm_rep_decl_rij
		"Replacement position value in case of overrun shut-off condition in rij mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_egr_pwm_rep_decl_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafstqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_egr_tqi
		"Final indicated torque for EGR setpoint"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_egr_tqi 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000783e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_lbtpmdl_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ehr_clc_raw_dtp
		"Elementary homogeneous reactor estimated raw temperature"
		ULONG
		gsxEdxb_mgAbFdd_ntalEla_K_a999a
		1
		100
		0.
		4294.967295
    DISPLAY_IDENTIFIER Vxx_ehr_clc_raw_dtp 
    FORMAT "%11.6" 
    ECU_ADDRESS 0xd00054d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_el_bk_wind_min_is_n
		"Electric backlite idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_el_bk_wind_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007754 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_el_csm_mdl_pow
		"Electrical consumer modelised power"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_el_csm_mdl_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001940 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_el_wind_min_is_n
		"Electric balance counter"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_el_wind_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007756 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_abs_psn
		"Absolute position in percent of the sensor supply voltage."
		UWORD
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_abs_psn 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0000d46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_abs_psn_1
		"Absolute position in percent of the sensor supply voltage."
		UWORD
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_abs_psn_1 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0000d4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_clos_ctr
		"Time counter to ensure the closing of the valve or to apply the high neg. torque."
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1024.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_ctr 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000ee8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_clos_rat
		"OBD ratio indicating the number of measured postions under  the turbo threshold"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001cf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_clos_rat_1
		"Ratio of closed position, during full closing diag. Value refreshed by the full clos. strategy"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_1 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001cfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_clos_rat_2
		"Ratio of closed position, during full closing diag. Value refreshed by the full closing strategy."
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_2 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001cff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_clos_rat_thd
		"Variable corresponding to the ratio threshold used to consider the component as closed."
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_thd 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001d00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_clos_rat_thd_1
		"Variable corresponding to the ratio threshold used to consider the component as closed."
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_thd_1 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001d01 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_esocoxx_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_cmd_cut_npu
		"Variable for EGR valve command after shut-off in npu mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_cmd_cut_npu 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000194c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_cmd_val
		"Output of the S controller."
		SLONG
		uwmooFc_Fyanpma_qwqkdEc_n_39540
		1
		100
		-25.
		24.9999999883585
    DISPLAY_IDENTIFIER Vxx_emtv_cmd_val 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_cmd_val_1
		"Output of the S1 component of the S controller."
		SLONG
		uwmooFc_Fyanpma_qwqkdEc_n_39540
		1
		100
		-25.
		24.9999999883585
    DISPLAY_IDENTIFIER Vxx_emtv_cmd_val_1 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_cmd_val_2
		"Output of the S2 component of the S controller."
		SLONG
		uwmooFc_Fyanpma_qwqkdEc_n_39540
		1
		100
		-25.
		24.9999999883585
    DISPLAY_IDENTIFIER Vxx_emtv_cmd_val_2 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_cmd_val_3
		"Output of the S3 component of the S controller."
		SLONG
		uwmooFc_Fyanpma_qwqkdEc_n_39540
		1
		100
		-25.
		24.9999999883585
    DISPLAY_IDENTIFIER Vxx_emtv_cmd_val_3 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_cmd_val_lim
		"Voltage setpoint given by the RST Controller."
		SWORD
		qtjmexb_FBfzDca_xekCpbb_n_79580
		1
		100
		-25.
		24.9992370605469
    DISPLAY_IDENTIFIER Vxx_emtv_cmd_val_lim 
    FORMAT "%9.5" 
    ECU_ADDRESS 0xd0000f1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_ctl_err
		"Difference between the outputs of the T and R controller. Similar to a position error."
		SLONG
		fBnckhb_ozrejBa_yFBnwba_n_90540
		1
		100
		-50.
		49.9999999767169
    DISPLAY_IDENTIFIER Vxx_emtv_ctl_err 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_ctl_err_lim
		"Saturated value of Vxx_it_ctl_err. Input of the S controller."
		SWORD
		qtjmexb_FBfzDca_xekCpbb_n_79580
		1
		100
		-25.
		24.9992370605469
    DISPLAY_IDENTIFIER Vxx_emtv_ctl_err_lim 
    FORMAT "%9.5" 
    ECU_ADDRESS 0xd0000f20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_fail_ctr_in
		"In counter value for number of EMTV failure mode tries"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_emtv_fail_ctr_in 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002038 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_fail_ctr_out
		"Out counter value for number of EMTV failure mode tries"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_emtv_fail_ctr_out 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002039 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_frn_cps_v
		"Friction Compensation Voltage added to Vxx_emtv_cmd_val_lim."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_emtv_frn_cps_v 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000f22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_it_sp
		"Value of the Emtv or inlet throttle position setpoint after shut-off conditions"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_it_sp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_ofs_ctr_1
		"Number of iterations to calculate the medium value of the position during Offset Learning."
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1000.
    DISPLAY_IDENTIFIER Vxx_emtv_ofs_ctr_1 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000eea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_chr
		"Absolute position given by the sensor, in percent of the sensor supply voltage."
		UWORD
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_chr 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0000d4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_clos_neg_slop
		"Value of the negative slope used for closing or opening of the EGR valve (fast or slow closing)"
		ULONG
		pbxrrcb_uxwdEfd_uEzojfd_Bs__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_clos_neg_slop 
    FORMAT "%8.1" 
    ECU_ADDRESS 0xd0004dc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_clos_ovr_neg_slop
		"Value of the negative slope used for closing or opening of the EGR valve (fast or slow closing)"
		ULONG
		pbxrrcb_uxwdEfd_uEzojfd_Bs__n0a
		1
		100
		-65535.
		-0.5
    DISPLAY_IDENTIFIER Vxx_emtv_psn_clos_ovr_neg_slop 
    FORMAT "%8.1" 
    ECU_ADDRESS 0xd0004dcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_clos_ovr_pos_slop
		"Value of the positive slope used for closing or opening of the EGR valve (fast or slow closing)"
		ULONG
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		1
		100
		0.5
		65535.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_clos_ovr_pos_slop 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0004dd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_clos_pos_slop
		"Value of the positive slope used for closing or opening of the EGR valve (fast or slow closing)"
		ULONG
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		1
		100
		0.
		65535.
