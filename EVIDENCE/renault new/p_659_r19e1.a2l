    "Desired current upper limit for MeUn Actr test"
    VALUE
    0x8006F06E
    Val_Ws16
    2000.000
    Curr
    0.00
    2000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iSetMax_C
    "maximum current for metering unit"
    VALUE
    0x8006F178
    Val_Ws16
    4500.000
    Curr
    0.00
    4500.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iSetMinActrTst_C
    "Desired current lower limit for MeUn Actr test"
    VALUE
    0x8006F070
    Val_Ws16
    2000.000
    Curr
    0.00
    2000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iSetMin_C
    "Setpoint current for electrical shut-off of the metering unit"
    VALUE
    0x8006F1DC
    Val_Ws16
    65535.00
    Curr
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iSet_C
    "remote control value of setpoint current for the metering unit"
    VALUE
    0x8006F1DE
    Val_Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iWinActrTst_C
    "Tolerance window for MeUn current"
    VALUE
    0x8006F072
    Val_Ws16
    1000.000
    Curr
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_nDiffMaxActrTst_C
    "Maximum deviation from the low idle setpoint for MeUn Actr test"
    VALUE
    0x8006F074
    Val_Ws16
    4000.000
    EngN
    0.00
    4000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_nDiffMax_C
    "Maximum difference between filtered engine speed for a curve and current engine speed for applying new speed value"
    VALUE
    0x8006F0AE
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_nSetActrTst_CA
    "Desired speed for MeUn Actr test"
    VAL_BLK
    0x8006F076
    ValA_Ws16
    4000.000
    EngN
    0.00
    4000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_pActrPrt_C
    "Rail pressure threshold for release of actuator protection function"
    VALUE
    0x8006F1E0
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_pFlowOfFl_C
    "Rail pressure threshold for switching back to default actuator value for high pressure control"
    VALUE
    0x8006F1E2
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_pMinMeUn_C
    "Lower rail pressure limit for fuel supply fault"
    VALUE
    0x8006F07E
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_pSetActrTst_CA
    "Desired pressure for MeUn Actr test"
    VAL_BLK
    0x8006F080
    ValA_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_PwmOut.rMin_C
    "Class for output duty cycle parameter / Minimum threshold for the duty cycle"
    VALUE
    0x8006F0B0
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_PwmOut.rMax_C
    "Class for output duty cycle parameter / Maximum threshold for the duty cycle"
    VALUE
    0x8006F0B2
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_PwmOut.tiBtwTstSCB_C
    "Class for output duty cycle parameter / Time between tests for SCB error"
    VALUE
    0x8006F0B4
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_PwmOut.tiBtwTstOT_C
    "Class for output duty cycle parameter / Time between tests for OT error"
    VALUE
    0x8006F0B6
    Kw_Ws16
    327.6700
    Time_s
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_PwmOut.numTstMax_C
    "Class for output duty cycle parameter / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006F0B8
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_PwmOut.swtBattCor_C
    "Class for output duty cycle parameter / Switch to enable battery correction"
    VALUE
    0x8006F0BA
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_PwmOut.swtPsInv_C
    "Class for output duty cycle parameter / Power stage output inversion status"
    VALUE
    0x8006F0BB
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_qDiffMaxActrTst_C
    "Maximum quantity deviation for MeUn Actr test."
    VALUE
    0x8006F088
    Val_Ws16
    80.00000
    InjMassCyc
    0.00
    80.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_rAccPedActrTst_C
    "Maximum accelerator pedal position for MeUn Actr test"
    VALUE
    0x8006F08A
    Val_Wu16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 799.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_resCoil_C
    "Resistance value of the coil for the metering unit"
    VALUE
    0x8006F0BC
    Val_Ws16
    5000.000
    Resist_1
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_rLim_CUR
    "PWM signal limitation based on the temperature"
    CURVE
    0x8006F162
    Cur_Xs16Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_tFlSys
        Temp_Cels
        2
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_rMaxDty_C
    "Maximum value, output duty cycle"
    VALUE
    0x8006F0BE
    Val_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_rPerUn_C
    "Status word for specifying the shut-off behaviour of the metering unit power stage error diagnosis"
    VALUE
    0x8006F0C0
    Val_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_rPs_C
    "remote control value of PWM signal output from the metering unit"
    VALUE
    0x8006F0C2
    Val_Ws16
    1.000000
    DtyCyc
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_rRotEnd_C
    "Final value of duty cycle during rotation"
    VALUE
    0x8006F16C
    Val_Ws16
    427.6800
    DtyCyc
    -327.6800
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_rRotStrt_C
    "Starting value of duty cycle during rotation"
    VALUE
    0x8006F16E
    Val_Ws16
    427.6800
    DtyCyc
    -327.6800
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_rSetLin_CUR
    "Linearisation curve of metering unit duty cycle"
    CURVE
    0x8006F0C4
    Cur_Xs16Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        MeUn_rSet_mp
        DtyCyc
        4
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_SRC.uMin_C
    "Class for default values for signal range check analog input / Threshold for SRC -Min detection"
    VALUE
    0x8006F0D6
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_SRC.uMax_C
    "Class for default values for signal range check analog input / Threshold for SRC -Max detection"
    VALUE
    0x8006F0D8
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_stLvl_C
    "Inversion parameter of the PWM power stage of metering unit"
    VALUE
    0x8006F0DA
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_stPwrStgActv_C
    "Inversion parameter of the PWM power stage."
    VALUE
    0x8006F0DB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_stPwrStgDia_C
    "Status word for specifying the shut-off behaviour of the metering unit power stage error diagnosis"
    VALUE
    0x8006F0DC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_stRotActv_C
    "Rotation activation switch"
    VALUE
    0x8006F170
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_swtActvSetPTst_C
    "Switch for activation of test by application"
    VALUE
    0x8006F17A
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_swtDvolSet_C
    "Switch for remote control of the flow quantity through the metering unit"
    VALUE
    0x800713AA
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_swtISet_C
    "Switch for the remote control value of setpoint current for the metering unit"
    VALUE
    0x8006F1E4
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_swtNoChkRefActrTst_C
    "switch to disable some parts of monitoring of running conditions during meun actuator test"
    VALUE
    0x8006F08C
    Val_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_swtRPs_C
    "Switch for the remote control value of PWM signal output from the metering unit"
    VALUE
    0x8006F0DD
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_swtZeroVolActrTst_C
    "Switch to perform zero delivery test"
    VALUE
    0x8006F08D
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tClntMinActrTst_C
    "Minimum engine temperature for MeUn Actr test."
    VALUE
    0x8006F08E
    Val_Ws16
    160.0000
    Temp_Cels
    -40.04000
    119.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiActrTstMax_C
    "Maximum test time for MeUn Actr test"
    VALUE
    0x8006F090
    Val_Ws32
    600.000000000
    Time_s
    0.00
    600.000000000

    FORMAT "%13.9"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiCrntCtlInit_C
    "Maximum duration of initialization phase"
    VALUE
    0x8006F1E6
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiDetActrTst_C
    "Time duration for current threshold recognition."
    VALUE
    0x8006F094
    Val_Ws16
    20000.00
    Time_ms
    0.00
    20000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiFlt1PT1_C
    "PT1 filter time constant for actual current value"
    VALUE
    0x8006F1E8
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiFlt2PT1_C
    "PT1 filter time constant for current setpoint value"
    VALUE
    0x8006F1EC
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiFltPT1Init_C
    "PT1 filter time constant during the initialization phase of the current governor"
    VALUE
    0x8006F1F0
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiMaxSetPTst_C
    "application label for total test time"
    VALUE
    0x8006F17C
    Val_Ws16
    327.6700
    Time_s
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiPerUBattHi_C
    "cycle time of MeUn-pwm-powerstage in case of high battery voltage"
    VALUE
    0x8006F0DE
    Val_Ws16
    2.000000
    Period
    1.000000
    3.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiPer_CUR
    "Curve for period duration of the PWM power stage"
    CURVE
    0x8006F0E0
    Cur_Xs16Ws16
    6.400000
    Period
    0.1000000
    6.500000

    FORMAT "%8.6"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        MeUn_nDiffRef_mp
        EngN
        30
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiPh_C
    "Curve for period duration of the PWM power stage"
    VALUE
    0x8006F15A
    Val_Ws16
    3276.700
    Period
    0.00
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiRmpDurActrTst_C
    "Ramp time for desired current for MeUn Actr test"
    VALUE
    0x8006F096
    Val_Ws16
    30000.00
    Time_ms
    0.00
    30000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiRotDel_C
    "Energizing time during the rotation"
    VALUE
    0x8006F172
    Val_Wu16
    65540.00
    Time_ms
    0.00
    65540.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiRotExt_C
    "time to freeze current governor of MeUn after rotation"
    VALUE
    0x8006F174
    Val_Wu16
    65540.00
    Time_ms
    0.00
    65540.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiRotWait_C
    "Pause time during the rotation"
    VALUE
    0x8006F176
    Val_Wu16
    65540.00
    Time_ms
    0.00
    65540.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_tiWaitActrTst_C
    "Waiting time for MeUn Actr test"
    VALUE
    0x8006F098
    Val_Ws16
    327.6700
    Time_s
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_uBattHi_C
    "upper voltage limit to switch to another frequency of the MeUn pwm-powerstage"
    VALUE
    0x8006F15C
    Val_Ws16
    1015360.
    Volt_Batt
    -655360.0
    360000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_uBattLo_C
    "lower voltage limit to switch to normal frequency of the MeUn pwm-powerstage"
    VALUE
    0x8006F15E
    Val_Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_ctDebNTP_C
    "Error counter end value for testing with null load test pulse procedure"
    VALUE
    0x8006B3D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_ctDebTst_C
    "Error counter end value of test voltage verification"
    VALUE
    0x8006B3D9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_ctDebVltgRatio_C
    "Error counter end value of ratiometric correction factor plausibility check"
    VALUE
    0x8006B3DA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_ctDiagNTP_C
    "Counter end value for MoCADC_ctDiagNTP in the diagnosis"
    VALUE
    0x8006F1F4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_ctRst_C
    "Resetcounter threshold for PreICO-Reset in MoCADC"
    VALUE
    0x8006B3DB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_facVltgRatioMax_C
    "Maximum permissible value for the ratiometric correction factor"
    VALUE
    0x8006B3DC
    Val_Wu16
    63.99902
    Mo_fac_q0p00098
    0.00
    63.99902

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 63.99902
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_facVltgRatioMin_C
    "Minimum permissible value for the ratiometric correction factor"
    VALUE
    0x8006B3DE
    Val_Wu16
    63.99902
    Mo_fac_q0p00098
    0.00
    63.99902

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 63.99902
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_uNTPMax_C
    "Maximum ADC value in case of ADC channel moved to low during the ADC verification"
    VALUE
    0x8006B3E0
    Val_Ws16
    319995.1
    Mo_u_mV_q4p88
    -160000.0
    159995.1

    FORMAT "%8.1"
    EXTENDED_LIMITS -160000.0 159995.1
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_uTstMax_C
    "Maximum test voltage in ADC test"
    VALUE
    0x8006B3E2
    Val_Ws16
    319995.1
    Mo_u_mV_q4p88
    -160000.0
    159995.1

    FORMAT "%8.1"
    EXTENDED_LIMITS -160000.0 159995.1
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCADC_uTstMin_C
    "Minimum test voltage in ADC test"
    VALUE
    0x8006B3E4
    Val_Ws16
    319995.1
    Mo_u_mV_q4p88
    -160000.0
    159995.1

    FORMAT "%8.1"
    EXTENDED_LIMITS -160000.0 159995.1
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCCom_ctDebErrCnt_C
    "Threshold value of the counter for reporting the not plausible FC or MM"
    VALUE
    0x8006B3E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCCom_ctDebErrSPI_C
    "Threshold value of the counter for reporting the SPI-communication error"
    VALUE
    0x8006B3E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCCPU_IpoTst_CUR
    "Interpolation-Testcurve for instruction test"
    CURVE
    0x8006B4F4
    Cur_Xs16Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        MoCCPU_IpoIn
        OneToOne
        20
        -32768.00
        32767.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGPTA_numErr_C
    "counter end value for debouncing of the SW-reset"
    VALUE
    0x8006B3E8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGPTA_tiDvtMax_C
    "limit of deviation between time base of GPTA and CPU"
    VALUE
    0x8006B3EA
    Val_Wu16
    65535.00
    Mo_ti_us_q1p0
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebErrChkRAM_C
    "Fehlertoleranzschwelle für Doppelablage und zyklischen RAM-Test"
    VALUE
    0x8006B3EC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebErrChkROM_C
    "Fehlertoleranzschwelle für zyklischen ROM-Test"
    VALUE
    0x8006B3ED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkRAMCpl_C
    ""
    VALUE
    0x8006B3EE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkRAM_C
    "Toleranzschwelle für Heilungszähler bei Doppelablage und zyklischem RAM-Test"
    VALUE
    0x8006B3EF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkROMCpl_C
    ""
    VALUE
    0x8006B3F0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkROM_C
    "Toleranzschwelle für Heilungszähler bei zyklischem ROM-Test"
    VALUE
    0x8006B3F1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCPCP_numErr_C
    "Error tolerance threshold for CRC checksum error in PCP code"
    VALUE
    0x8006B3F2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCPCP_stEnaMFTst_CW
    "Activation of monitoring function test for the PCP monitoring (PCP command test)"
    VALUE
    0x8006B3F3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCPCP_tiHeal_C
    "Tolerance threshold for erasing counter at CRC checksum error in PCP code"
    VALUE
    0x8006B3F4
    Val_Wu8
    10200.
    Mo_ti40ms_ms_q40p0
    0.00
    10200.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 10200.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCRam_ChkRAMIFA9SyncTst_CW
    "codeword for request of reaction-test of parts in shutdown and recheck in ECU boot up"
    VALUE
    0x8006B3F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCRam_ChkRAMIFA9Tst_CW
    "codeword for request of reaction-test of parts in ECU boot up"
    VALUE
    0x8006B3F7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCRam_noRAMChkSD_CW
    "CW for deactivation of complete RAM-check of code"
    VALUE
    0x8006B3F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCRom_BgSwOffTst_CW
    "codeword for request of reaction test in ECU post-drive"
    VALUE
    0x8006B3FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCRom_noROMChkIni_CW
    "CW for deactivation of complete ROM-Check in Ini"
    VALUE
    0x8006B3FB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCRom_noROMCodeChkRst_CW
    "CW for deactivation of complete ROM-check of code"
    VALUE
    0x8006B3FC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCRom_noROMDataChkRst_CW
    "CW for deactivation of complete ROM-check of data"
    VALUE
    0x8006B3FD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCRom_RepExTst_CW
    "codeword for request of reaction test in ECU boot up"
    VALUE
    0x8006B3FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctDebHwNoRdy_C
    "Maximum number of retries to wait for the hardware until it is ready, before beginning with the diagnose of the performed injection"
    VALUE
    0x8006B400
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctDebPSDia_C
    "Maximum number of powerstage test"
    VALUE
    0x8006B402
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctDebPSIni_C
    ""
    VALUE
    0x8006B403
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctDebSOPTst_C
    "Maximum number of repetitions of shut-off path test (time monitoring of shut-off path test)"
    VALUE
    0x8006B404
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctWaitInjTstRdy_C
    ""
    VALUE
    0x8006B406
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_nMinOVLth_C
    "Engine speed theshold to avoid the activation of the CJ945 latch function during starting"
    VALUE
    0x8006B408
    Val_Wu8
    10200.
    Mo_n_rpm_q40p0
    0.00
    10200.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 10200.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stCANErrReac_CW
    "codeword for activating the error reaction CAN-driver-disabling"
    VALUE
    0x8006B409
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stICOMsgReport_C
    ""
    VALUE
    0x8006B40A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stMMErrReac_CW
    "Status-Bit to enable error reaction (MM-Reset) in monitoring module depending on error counter"
    VALUE
    0x8006B40C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stSOPTstActv_CW
    "Status-Bits for selection of a particular shut-off path test"
    VALUE
    0x8006B40D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stSWResetDem_CW
    "Status-Bit for Software-Reset demand in case of shut-off path test error"
    VALUE
    0x8006B40E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_swtPsvTst_C
    "Permit to switch on/off the SOP-positive (good) test. The SOP positive test is succesful if an injection can be programmed."
    VALUE
    0x8006B40F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFAPP_uFL_C
    "Full throttle- set value- threshold"
    VALUE
    0x8006B410
    Val_Wu8
    4980.
    Mo_u_mV_q19p53
    0.00
    4980.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 4980.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFAPP_uLoLim_C
    "Lower threshold of the APP voltages for plausibility test"
    VALUE
    0x8006B411
    Val_Wu8
    4980.
    Mo_u_mV_q19p53
    0.00
    4980.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 4980.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFAPP_uMaxDiffFL_C
    "Maximum permitted difference between the accelerator pedal signals above the full throttle threshold"
    VALUE
    0x8006B412
    Val_Wu8
    4980.
    Mo_u_mV_q19p53
    0.00
    4980.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 4980.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFAPP_uMaxDiffPL_C
    "Maximum permitted difference between the accelerator pedal signals beneath full throttle threshold"
    VALUE
    0x8006B413
    Val_Wu8
    4980.
    Mo_u_mV_q19p53
    0.00
    4980.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 4980.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFESpd_ctDeb_C
    "Error counter value for engine speed comparison during function monitoring"
    VALUE
    0x8006B414
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFESpd_ctRst_C
    "Number of permissible resets in case of error in engine speed comparison"
    VALUE
    0x8006B415
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFESpd_nDiffMax_C
    "Permitted difference between calculated engine speeds in level 1 and level 2"
    VALUE
    0x8006B416
    Val_Ws16
    2621400.
    Mo_n_rpm_q40p0
    -1310720.
    1310680.

    FORMAT "%8.0"
    EXTENDED_LIMITS -1310720. 1310680.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFESpd_nMin_C
    "Minimum engine speed during engine speed monitoring"
    VALUE
    0x8006B418
    Val_Wu8
    10200.
    Mo_n_rpm_q40p0
    0.00
    10200.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 10200.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_ctTst_C
    "Maximal duration of engine test in function monitoring"
    VALUE
    0x8006B41C
    Val_Wu32
    42949672.9500
    Mo_ti_s_q0p01
    0.00
    42949672.9500

    FORMAT "%13.4"
    EXTENDED_LIMITS 0.00 42949672.9500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_stBrkNotPressed_C
    ""
    VALUE
    0x8006B420
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_stRSABrkNotPressed_C
    ""
    VALUE
    0x8006B421
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_swtEnaRSAAPPCond_C
    ""
    VALUE
    0x8006B422
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_swtEnaRSABrkCond_C
    ""
    VALUE
    0x8006B423
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_swtEnaRSAVehSpdCond_C
    ""
    VALUE
    0x8006B424
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_swtInactvDiagTO_C
    ""
    VALUE
    0x8006B425
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_swtInactvTO_C
    "Deactivationlabel for timeout check"
    VALUE
    0x8006B426
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_uRawIdlAPP_C
    ""
    VALUE
    0x8006B427
    Val_Wu8
    4980.
    Mo_u_mV_q19p53
    0.00
    4980.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 4980.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_uRSARawIdlAPP_C
    ""
    VALUE
    0x8006B428
    Val_Wu8
    4980.
    Mo_u_mV_q19p53
    0.00
    4980.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 4980.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_vMax_C
    "Maximum vehicle speed for which an engine test is allowed"
    VALUE
    0x8006B42A
    Val_Wu16
    655.3500
    Mo_v_kmh_q0p01
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFETC_vRSAMax_C
    ""
    VALUE
    0x8006B42C
    Val_Wu16
    655.3500
    Mo_v_kmh_q0p01
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFICO_swtTst_C
    ""
    VALUE
    0x8006B430
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFInjDat_facInjEff_MAP
    "Torque effectivity factor map of overrun monitoring"
    MAP
    0x8006F1F6
    Map_Xs16Ys16Ws16
    7.999878
    Mo_fac_q0p000122
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        6
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        MoFInjDat_phiInjAct_mp
        Mo_phi_degCrS_q0p02197
        4
        -720.0439
        720.0220

        FORMAT "%8.4"
        EXTENDED_LIMITS -720.0439 720.0220
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFInjDat_numCyl_C
    "Number of cylinders during function monitoring"
    VALUE
    0x8006B432
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFInjDat_pLin_CUR
    "linearisation curve for rail pressure sensor in monitoring"
    CURVE
    0x8006B434
    Cur_Xs16Ws16
    524280000.
    Mo_p_hPa_q8000p0
    -262144000.
    262136000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -262144000. 262136000.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        MoFInjDat_uRaw_mp
        Mo_u_mV_q4p88
        2
        -160000.0
        159995.1

        FORMAT "%8.1"
        EXTENDED_LIMITS -160000.0 159995.1
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFInjDat_uSRCMax_C
    "upper limit for Signal Range Check of MoFInjDat_uRaw_mp"
    VALUE
    0x8006B43E
    Val_Wu16
    319995.1
    Mo_u_mV_q4p88
    0.00
    319995.1

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 319995.1
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFInjDat_uSRCMin_C
    "lower limit for Signal Range Check of MoFInjDat_uRaw_mp"
    VALUE
    0x8006B440
    Val_Wu16
    319995.1
    Mo_u_mV_q4p88
    0.00
    319995.1

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 319995.1
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFOvR_swtTst_C
    ""
    VALUE
    0x8006B442
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFOvR_tiLimET_MAP
    "Permissible energising time dependant on engine speed and time after activation of overrun monitoring"
    MAP
    0x8006B444
    Map_Xs16Ys16Ws16
    26214.00
    Mo_ti_us_q0p4
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        MoFESpd_nEng
        Mo_n_rpm_q40p0
        6
        0.00
        6000.

        FORMAT "%5.0"
        EXTENDED_LIMITS -1310720. 1310680.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        MoFOvR_tiOvRMonActive_mp
        Mo_ti_s_q0p04
        6
        0.00
        20.00000

        FORMAT "%8.5"
        EXTENDED_LIMITS -1310.720 1310.680
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFRailP_ctDebErr_C
    "Error counter threshold value in MoFRailP during function monitoring"
    VALUE
    0x8006B4AA
    Val_Wu8
    2550.
    Mo_ti10ms_ms_q10p0
    0.00
    2550.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 2550.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFRailP_ctDebGradMax_C
    "Maximum Debounce count for the rail pressure gradient error detection"
    VALUE
    0x8006B4AB
    Val_Wu8
    2550.
    Mo_ti10ms_ms_q10p0
    0.00
    2550.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 2550.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFRailP_ctRst_C
    "Number of permissible resets in case of error in rail pressure"
    VALUE
    0x8006B4AC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFRailP_pDefMax_C
    "The upper threshold for rail pressure in case of an SRC error detected in level 2"
    VALUE
    0x8006B4AD
    Val_Wu8
    2040000.
    Mo_p_hPa_q8000p0
    0.00
    2040000.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 2040000.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFRailP_pDefMin_C
    "The lower threshold for rail pressure in case of an SRC error detected in level 2"
    VALUE
    0x8006B4AE
    Val_Wu8
    2040000.
    Mo_p_hPa_q8000p0
    0.00
    2040000.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 2040000.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFRST_swtTst_C
    ""
    VALUE
    0x8006B4A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_swtClrEEPCtrs_C
    ""
    VALUE
    0x8006F23E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MRly_ctErlyOpng_C
    "Threshold to detect the early opening"
    VALUE
    0x8006F04C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MRly_tiBattVltgFlt_C
    "Filter time constant"
    VALUE
    0x8006F050
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MRly_tiStkRlyDiaDel_C
    "Time to perform the MRly diagnosis"
    VALUE
    0x8006F054
    Val_Ws16
    3000.000
    Time_ms
    0.00
    3000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MRly_uStblThr_C
    "Battery voltage threshold to detect the closure of main relay"
    VALUE
    0x8006F056
    Val_Ws16
    30000.00
    Volt_Batt
    0.00
    30000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MRly_uStkRlyBattThr_C
    "Battery voltage threshold to detect the sticky main relay"
    VALUE
    0x8006F058
    Val_Ws16
    30000.00
    Volt_Batt
    0.00
    30000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_CrntCtlDT1.T1_C
    "Parameters of the DT1 element / Reciprocal of time delay T1 ( 2^32 / T1; T1 in same quantisation as Dt)"
    VALUE
    0x8006F408
    Kw_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_CrntCtlDT1.Kd_C
    "Parameters of the DT1 element / Differential factor Kd = Td/T1"
    VALUE
    0x8006F40C
    Kw_Ws32
    65535.9999847
    Kd
    -32768.0000000
    32767.9999847

    FORMAT "%13.7"
    EXTENDED_LIMITS -32768.0000000 32767.9999847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_CrntCtlI.Ki_C
    "Class for I element parameter / Ki_C factor within the window"
    VALUE
    0x8006F454
    Kw_Ws32
    244.140624943
    Ki_curr2fact
    -122.070312500
    122.070312443

    FORMAT "%13.9"
    EXTENDED_LIMITS -122.070312500 122.070312443
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_CrntCtlI.KiPos_C
    "Class for I element parameter / Ki_C factor above the window"
    VALUE
    0x8006F458
    Kw_Ws32
    244.140624943
    Ki_curr2fact
    -122.070312500
    122.070312443

    FORMAT "%13.9"
    EXTENDED_LIMITS -122.070312500 122.070312443
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_CrntCtlI.KiNeg_C
    "Class for I element parameter / Ki_C factor below the window"
    VALUE
    0x8006F45C
    Kw_Ws32
    244.140624943
    Ki_curr2fact
    -122.070312500
    122.070312443

    FORMAT "%13.9"
    EXTENDED_LIMITS -122.070312500 122.070312443
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_CrntCtlI.WinPos_C
    "Class for I element parameter / Upper border of the window"
    VALUE
    0x8006F460
    Kw_Ws32
    4294967295.00
    Curr
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_CrntCtlI.WinNeg_C
    "Class for I element parameter / Lower border of the window"
    VALUE
    0x8006F464
    Kw_Ws32
    4294967295.00
    Curr
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_diNoStrtRmpSlp_C
    "Slope of the ramp to increase PCV setpoint current"
    VALUE
    0x8006F468
    Val_Ws8
    10000.
    RmpCurr
    0.00
    10000.

    FORMAT "%5.0"
    EXTENDED_LIMITS -12800. 12700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_dvolLeak_CUR
    "Leakage in the pressure control valve"
    CURVE
    0x8006F4FC
    Cur_Xs16Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Rail_pSetPoint
        Pres_Rail
        6
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_dvolPreCtlBasNom_MAP
    "actual injected quantity without pre control quantities"
    MAP
    0x8006F2C4
    Map_Xs16Ys16Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        8
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjCtl_qSetUnBal
        InjMass
        8
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_dvolUpLim_CUR
    "Maximum pump flow as a function of the engine speed"
    CURVE
    0x8006F368
    Cur_Xs16Ws16
    655350.0
    Qp_mm3_sec
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        10
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facAdaptDiffI_C
    "Factor of the maximum deviation between setpoint and actual current through the PCV from which the adaptation is carried out"
    VALUE
    0x8006F392
    Val_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facAdaptDiff_C
    "Factor of the maximum deviation between the setpoint and actual rail pressure from which the adaptation is carried out"
    VALUE
    0x8006F394
    Val_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facAdaptFlowMin_C
    "Minimum value for the PCV flow correction factor"
    VALUE
    0x8006F396
    Val_Ws16
    3.900024
    Fact
    0.00
    3.900024

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facAdaptFlow_MAP
    "Flow correction factor for the PCV curve as a function of the flow through the PCV and the rail pressure"
    MAP
    0x8006F398
    Map_Xs16Ys16Ws16
    7.999878
    Fact
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        6
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        PCV_dvolFlow_mp
        Qp_mm3_sec
        4
        -10000.00
        50000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -327680.0 327670.0
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facAdaptMax_C
    "Maximum value of the PCV adaptation factor"
    VALUE
    0x8006F3E0
    Val_Ws16
    2.000000
    Fact
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facAdaptMin_C
    "Minimum value of the PCV adaptation factor"
    VALUE
    0x8006F3E2
    Val_Ws16
    2.000000
    Fact
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facAdaptWgh_C
    "Weighting factor for calculating the PDC adaptation factor"
    VALUE
    0x8006F3E4
    Val_Ws16
    20.00000
    Fact4
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -1638.400 1638.350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facCrntCtlInit_CUR
    "Setpoint current at pressure control valve shut-off"
    CURVE
    0x8006F46A
    Cur_Xs16Ws16
    2.000000
    Fact
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_tFlSys
        Temp_Cels
        6
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facCrntCtlMax_C
    "Current for closing the PCV"
    VALUE
    0x8006F484
    Val_Ws16
    1.000000
    Fact
    1.000000
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facCrntCtlMin_C
    "Minimum I component"
    VALUE
    0x8006F486
    Val_Ws16
    0.5000000
    Fact
    0.5000000
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_facWinActrTst_CUR
    "curve for determianting the factor to caculate the allowed pressure range dependant on drv-current"
    CURVE
    0x8006F268
    Cur_Xs16Ws16
    1.000000
    Fact1
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        PCV_iActVal
        Curr
        10
        200.0000
        2000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_iCnvPres_CUR
    "Curve for converting pressure to current"
    CURVE
    0x8006F488
    Cur_Xs16Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        PCV_pSet
        Pres_Rail
        10
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_iLin_CUR
    "Analog input, linearisation curve"
    CURVE
    0x8006F410
    Cur_Xs16Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        PCV_uRaw_mp
        Volt
        2
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_iSetClose_CUR
    "Setpoint current at pressure control valve shut-off"
    CURVE
    0x8006F4B2
    Cur_Xs16Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_tFlSys
        Temp_Cels
        8
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_iSetMaxBattHi_C
    "Reduced maximum current for the pressure control valve when the battery voltage is increased"
    VALUE
    0x8006F4D4
    Val_Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_iSetMax_C
    "Maximum current for closing the PCV"
    VALUE
    0x8006F4D6
    Val_Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_iSetMinNoStrt_C
    "minimum limit of pressure control valve in case of interrupted of start"
    VALUE
    0x8006F4D8
    Val_Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_iSetMin_C
    "Setpoint current at pressure control valve shut-off"
    VALUE
    0x8006F4DA
    Val_Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_nDiffMaxActrTst_C
    "maximum allowed deviation of engine speed"
    VALUE
    0x8006F292
    Val_Ws16
    300.0000
    EngN
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_nSetActrTst_C
    "set value for low idle speed"
    VALUE
    0x8006F294
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_nSetClose_C
    "Engine speed threshold for leaving the PCV_stActrCtl == PCV_CLOSE_MODE (0x20) mode"
    VALUE
    0x8006F4DC
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numAdaptMaxCycl_C
    "Value of the driving cycle counter for successful adaption"
    VALUE
    0x8006F3E6
    Val_Wu16
    1000.000
    OneToOne
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numAdaptMin_C
    "Minimum counter threshold for number of adaptations"
    VALUE
    0x8006F3E8
    Val_Wu16
    1000.000
    OneToOne
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numAdaptSum_C
    "Number of PCV adaptation function calls in the PCV_ADAPT_SUM_UP state"
    VALUE
    0x8006F3EA
    Val_Wu16
    20.00000
    OneToOne
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numAdaptThres_C
    "Number of adaptations that are executed for a given rail pressure"
    VALUE
    0x8006F3EC
    Val_Wu16
    100.0000
    OneToOne
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numAdapt_C
    "Number of PCV adaptation function calls in the PCV_ADAPT_STABLE state"
    VALUE
    0x8006F3EE
    Val_Wu16
    100.0000
    OneToOne
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numCalcAvrgActrTst_C
    "number of considered values to get start value"
    VALUE
    0x8006F296
    Val_Ws16
    30.00000
    OneToOne
    0.00
    30.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numCycOffActrTst_C
    "number of cycles to hold duty cycle (trigger is ""low"")"
    VALUE
    0x8006F298
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numMaxErrActrTst_C
    "threshold for defect pcv"
    VALUE
    0x8006F299
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numNoStrt_C
    "Threshold for the number of PCV current ramp-ups after which the error path is set"
    VALUE
    0x8006F4DE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_numRepActrTst_C
    "number of test iterations"
    VALUE
    0x8006F29A
    Val_Wu8
    4.000
    OneToOne
    0.00
    4.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_pAdaptThresMax_C
    "Maximum rail pressure for releasing the adaptation"
    VALUE
    0x8006F3F0
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_pAdaptThresMin_C
    "Minimum rail pressure for releasing the adaptation"
    VALUE
    0x8006F3F2
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_pAdaptThres_C
    "Maximum value for the pressure threshold from which the adaptation is carried out"
    VALUE
    0x8006F3F4
    Val_Ws16
    4876800.
    Pres_Rail
    -3276800.
    1600000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_pMaxActrTst_C
    "maximum pressure value to change hysteresis direction"
    VALUE
    0x8006F29C
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_pMinActrTst_C
    "minimum pressure value to change hysteresis direction"
    VALUE
    0x8006F29E
    Val_Ws16
    300000.0
    Pres_Rail
    200000.0
    500000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_pSet_C
    "Remote control value of the pressure of the PCV"
    VALUE
    0x800713AC
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_pWinLoActrTst_C
    "window for minimum pressure change"
    VALUE
    0x8006F2A0
    Val_Ws16
    50000.00
    Pres_Rail
    0.00
    50000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_Pwm.tiPer_C
    "Class for output duty cycle parameter / Reference value for period duration (small type to limit dynamic range)"
    VALUE
    0x8006F41A
    Kw_Ws16
    9.900000
    Period
    0.1000000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_Pwm.stLvl_C
    "Class for output duty cycle parameter / Reference value for phase relationship in period units"
    VALUE
    0x8006F41C
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_Pwm.rMaxDty_C
    "Class for output duty cycle parameter / Reference value for maximum duty cycle"
    VALUE
    0x8006F41E
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_Pwm.rPerUn_C
    "Class for output duty cycle parameter / us per Pwmout_tiPeriod unit (1==us, 1000=ms)"
    VALUE
    0x8006F420
    Kw_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_Pwm.tiPh_C
    "Class for output duty cycle parameter / Active level (0 or 1)"
    VALUE
    0x8006F422
    Kw_Ws16
    3276.700
    Period
    0.00
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_PwmOut.rMin_C
    "Class for output duty cycle parameter / Minimum threshold for the duty cycle"
    VALUE
    0x8006F424
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_PwmOut.rMax_C
    "Class for output duty cycle parameter / Maximum threshold for the duty cycle"
    VALUE
    0x8006F426
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_PwmOut.tiBtwTstSCB_C
    "Class for output duty cycle parameter / Time between tests for SCB error"
    VALUE
    0x8006F428
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_PwmOut.tiBtwTstOT_C
    "Class for output duty cycle parameter / Time between tests for OT error"
    VALUE
    0x8006F42A
    Kw_Ws16
    327.6700
    Time_s
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_PwmOut.numTstMax_C
    "Class for output duty cycle parameter / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006F42C
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_PwmOut.swtBattCor_C
    "Class for output duty cycle parameter / Switch to enable battery correction"
    VALUE
    0x8006F42E
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_PwmOut.swtPsInv_C
    "Class for output duty cycle parameter / Power stage output inversion status"
    VALUE
    0x8006F42F
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_qDiffMaxActrTst_C
    "maximum allowed deviation of injection quantity"
    VALUE
    0x8006F2A2
    Val_Ws16
    20.00000
    InjMass
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_rAccPedActrTst_C
    "maximum allowed position of accelerator pedal"
    VALUE
    0x8006F2A4
    Val_Ws16
    9.997559
    Prc
    0.00
    9.997559

    FORMAT "%8.5"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_rDstHiActrTst_C
    "delta duty cyle while ramp up"
    VALUE
    0x8006F2A6
    Val_Ws16
    80.00000
    DtyCyc
    0.00
    80.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_rDstLoActrTst_C
    "delta duty cyle for ramp down"
    VALUE
    0x8006F2A8
    Val_Ws16
    80.00000
    DtyCyc
    0.00
    80.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_resCoil_C
    "PCV coil resistance value"
    VALUE
    0x8006F430
    Val_Ws16
    5000.000
    Resist_1
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_rMax_C
    "maximum value for output duty cycle"
    VALUE
    0x8006F2AA
    Val_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_rMin_C
    "minimum value for output duty cycle"
    VALUE
    0x8006F2AC
    Val_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_rSetLin_CUR
    "Linearisation curve of the PCV duty cycle"
    CURVE
    0x8006F432
    Cur_Xs16Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        PCV_rSet
        DtyCyc
        4
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_rStpActrTst_C
    "step size to change duty cyle"
    VALUE
    0x8006F2AE
    Val_Ws16
    30.00000
    DtyCyc
    0.00
    30.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_rTst_C
    "Duty cycle which is output cyclically in the event of an error"
    VALUE
    0x8006F444
    Val_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_SRC.uMin_C
    "Class for parameter for signal range check analog input / Threshold for SRC -Min detection"
    VALUE
    0x8006F446
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_SRC.uMax_C
    "Class for parameter for signal range check analog input / Threshold for SRC -Max detection"
    VALUE
    0x8006F448
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_stMskCoEOMOpModeActrTst_C
    "mask of allowed operation modes during pcv test"
    VALUE
    0x8006F2B0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_stPwrStgActv_C
    "Maximum value of signal range check"
    VALUE
    0x8006F44A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_stPwrStgDia_C
    "Status word for specifying the shut-off behaviour of the PCV power stage error diagnosis"
    VALUE
    0x8006F44B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_swtActvSetPTst_C
    "Switch for activation of test by application"
    VALUE
    0x8006F450
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_swtAdaptCPC_C
    "Switch for releasing the adaptation in the CPC operation"
    VALUE
    0x8006F3F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_swtAdaptFlow_C
    "Switch for releasing the calculation of the flow value"
    VALUE
    0x8006F3F7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_swtAdaptRst_C
    "Switch for resetting the adaptation values"
    VALUE
    0x8006F3F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_swtAdapt_C
    "Switch for releasing the calculation of the adaptation value"
    VALUE
    0x8006F3F9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_swtClose_C
    "Switch for selecting the engine start detection"
    VALUE
    0x8006F4DF
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_swtNoChkRefActrTst_C
    "switch to deactivate checks of certain operation conditions"
    VALUE
    0x8006F2B2
    Val_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_swtPSet_C
    "Switch for the remote control of the pressure of the PCV"
    VALUE
    0x800713AE
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tFuelAdaptMax_C
    "Maximum fuel temperature at which the adaptation is carried out"
    VALUE
    0x8006F3FA
    Val_Ws16
    140.0000
    Temp_Cels
    -40.04000
    99.96000

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tFuelAdaptMin_C
    "Minimum fuel temperature after which the adaptation is carried out"
    VALUE
    0x8006F3FC
    Val_Ws16
    140.0000
    Temp_Cels
    -40.04000
    99.96000

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiCrntCtlInit_C
    "Maximum duration of the initialization phase for the current regulator"
    VALUE
    0x8006F4E0
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiDelMeasActrTst_C
    "delay time for evaluation"
    VALUE
    0x8006F2B4
    Val_Ws32
    2000.00000000
    Time_ms
    0.00
    2000.00000000

    FORMAT "%13.8"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiDurClose_C
    "Time duration for safely closing the PCV"
    VALUE
    0x8006F4E2
    Val_Wu16
    100.0000
    Time_ms
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiFlt1PT1_C
    "PT1 filter time constant for the actual current value"
    VALUE
    0x8006F4E4
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiFlt2PT1_C
    "PT1 filter time constant for the setpoint current value"
    VALUE
    0x8006F4E8
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiFltPT1Init_C
    "Maximum current for closing the PCV"
    VALUE
    0x8006F4EC
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiMaxActrTst_C
    "maximum allowed test duration"
    VALUE
    0x8006F2B8
    Val_Ws32
    1000.00000000
    Time_s
    0.00
    1000.00000000

    FORMAT "%13.8"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiMaxSetPTst_C
    "application label for total test time"
    VALUE
    0x8006F452
    Val_Ws16
    327.6000
    Time_s
    0.00
    327.6000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiNoClose_C
    "Time after which a switch is made to the maximum PCV current"
    VALUE
    0x8006F4F0
    Val_Wu16
    655350.0
    Time_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiNoStrt_C
    "time for which minimum value for PCV_iSet is switched to PCV_iSetMinNoStart_C"
    VALUE
    0x8006F4F2
    Val_Wu16
    80000.00
    Time_ms
    0.00
    80000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiSetCloseMax_C
    "Maximum dwell time in the PCV_stActrCtl == PCV_CLOSE_MODE (0x20) state"
    VALUE
    0x8006F4F4
    Val_Wu16
    100.0000
    Time_ms
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiSwtMeUn_C
    "maximum dwell time in PCV mode of rail control loop"
    VALUE
    0x8006F400
    Val_Ws32
    21478436.4800
    Time_s
    -21474836.4800
    3600.00000000

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiTst_C
    "Duration of the active power stage test"
    VALUE
    0x8006F44C
    Val_Wu16
    30000.00
    Time_ms
    0.00
    30000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tiWaitActrTst_C
    "waiting time in several states of the state machine"
    VALUE
    0x8006F2BC
    Val_Ws32
    60000.0000000
    Time_ms
    0.00
    60000.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tMinActrTst_C
    "minimum coolant temperature (operation temperature of engine)"
    VALUE
    0x8006F2C0
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_tSwtMeUn_C
    "Temperature threshold for releasing the message PCV_stAdaptMeUn"
    VALUE
    0x8006F404
    Val_Ws16
    140.0000
    Temp_Cels
    -40.04000
    99.96000

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_uBattHi_C
    "Upper shut-off threshold for the reduced maximum current"
    VALUE
    0x8006F4F6
    Val_Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_uBattLo_C
    "Lower shut-off threshold for the reduced maximum current"
    VALUE
    0x8006F4F8
    Val_Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCV_uDiffMaxActrTst_C
    "maximal allowed deviation of battery voltage"
    VALUE
    0x8006F2C2
    Val_Ws16
    3000.000
    Volt_Batt
    0.00
    3000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PthSet_tiOvrRunCoordDebPos_C
    ""
    VALUE
    0x8006F24C
    Val_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PthSet_trqInrSet_C
    ""
    VALUE
    0x80072F02
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PT_rTrqDfl_C
    ""
    VALUE
    0x8006F24A
    Val_Ws16
    655.3500
    TransR
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_facCor1_MAP
    "Map 1 for pressure wave correction weighting factor"
    MAP
    0x8006F8E6
    Map_Xs16Ys16Ws16
    10.00000
    Fact1
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        InjCrv_qMI1Des
        InjMass
        12
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pCurr_mp
        Pres_Rail
        10
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_facCor2_MAP
    "Map 2 for pressure wave correction weighting factor"
    MAP
    0x8006FA06
    Map_Xs16Ys16Ws16
    10.00000
    Fact1
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        InjCrv_qPoI2Des_mp
        InjMass
        8
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pCurr_mp
        Pres_Rail
        16
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_facFTS_MAP
    "Map for calculating the pressure wave correction factor based on the fuel temperature"
    MAP
    0x8006F516
    Map_Xs16Ys16Ws16
    2.000000
    Fact
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        16
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        QWC_tCor
        Temp_Cels
        8
        -40.04000
        139.9600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_facPiI2PiI1_C
    "weighting facor of PiI1 dependent on PiI2"
    VALUE
    0x8006FB3A
    Val_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_facPiI2_C
    "MI1 pressure wave correction quantity weighting factor based on PiI2"
    VALUE
    0x8006FB3C
    Val_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_qCor1_MAP
    "Base value map 1 of the pressure wave correction quantity"
    MAP
    0x8006FB3E
    Map_Xs16Ys16Ws16
    655.3400
    InjMass
    -327.6700
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        QWC_tiPiI1MI1Cor_mp
        InjTime_us
        80
        0.00
        13000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -13107.20 13106.80
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjCrv_qPiI1Des_mp
        InjMass
        16
        0.00
        24.00000

        FORMAT "%8.5"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_qCor2_MAP
    "Base value map 2 of the pressure wave correction quantity"
    MAP
    0x80070602
    Map_Xs16Ys16Ws16
    655.3400
    InjMass
    -327.6700
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        QWC_tiMI1PoI2Cor_mp
        InjTime_us
        80
        0.00
        13000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -13107.20 13106.80
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        QWC_rMI1Norm_mp
        QntR
        16
        0.0009765625
        24.00000

        FORMAT "%8.5"
        EXTENDED_LIMITS -32.00000 31.99902
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_qMax_C
    "Maximum limiting quantity for pressure wave correction"
    VALUE
    0x800710C6
    Val_Ws16
    20.00000
    InjMass
    -10.00000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_qMin_C
    "Minimum limiting quantity for pressure wave correction"
    VALUE
    0x800710C8
    Val_Ws16
    20.00000
    InjMass
    -10.00000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_qNorm_CUR
    "Curve for the injection normalisation quantity based on the rail pressure"
    CURVE
    0x8006F64A
    Cur_Xs16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        20
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_stActv_C
    "Release of the pressure wave correction"
    VALUE
    0x8006F69C
    Val_Wu8
    1.00000000000
    QWC_st_VERB
    0.00
    1.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 1.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_swtDiffHydInSel_C
    "Selection for expressing the operating point in the map QWC_tiDiffHyd_MAP (1,2,3 = expression, other, no expression)"
    VALUE
    0x800710CA
    Val_Wu8
    2.000
    OneToOne
    0.00
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_tCor_MAP
    "Map for the input temperature of the pressure wave correction"
    MAP
    0x8006F69E
    Map_Xs16Ys16Ws16
    180.0000
    Temp_Cels
    -40.04000
    139.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        QWC_FuelT_mp
        Temp_Cels
        16
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        QWC_CEngDsT_mp
        Temp_Cels
        16
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_tDflCEngDsT_C
    "default temperature for sensor defect"
    VALUE
    0x8006F8E2
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_tDflFuelT_C
    "default temperature for sensor defect"
    VALUE
    0x8006F8E4
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    QWC_tiDiffHyd_MAP
    "Map with differential times between the end of the hydraulic needle closing and the end of the electrical energizing"
    MAP
    0x800710CC
    Map_Xs16Ys16Ws16
    10000.00
    InjTime_us
    -5000.000
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        QWC_pCurrInDiffHyd_mp
        Pres_Rail
        16
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        QWC_qDesInDiffHyd_mp
        InjMass
        16
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    R2S2_xUsedDev_CW
    ""
    VALUE
    0x80071310
    Val_Wu8
    255.0
    default
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_AdcMaxVal_C
    "threshold to switch to replace Railpressure value with max possible value"
    VALUE
    0x80071312
    Val_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_dpMaxHyd_C
    "Largest allowed hydraulic pressure gradient before an error is detected."
    VALUE
    0x80071364
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_numGradExcdMax_C
    "Number of pressure jumps detected that trigger a diagnotic fault check."
    VALUE
    0x80071366
    Val_Wu16
    1000.000
    OneToOne
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_pFltWinNeg_CUR
    "Rail pressure decrease from which the system switches to the large signal parameter"
    CURVE
    0x8007132C
    Cur_Xs16Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        InjCtl_qSetUnBal
        InjMass
        10
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_pLin_CUR
    "Linearisation curve for fuel pressure sensor"
    CURVE
    0x80071314
    Cur_Xs16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_uRaw
        Volt
        4
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_SRC.uMin_C
    "Class for default values for signal range check analog input / Threshold for SRC -Min detection"
    VALUE
    0x80071326
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_SRC.uMax_C
    "Class for default values for signal range check analog input / Threshold for SRC -Max detection"
    VALUE
    0x80071328
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_swtFlt_C
    "Functioning of the peak rail pressure value determination in 20 ms rasters"
    VALUE
    0x80071356
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_swtOfsTst_C
    "Switch for releasing offset test for the rail pressure sensor during start-up or after-run (0 = start, 1 = after-run, 2 = use engine stop timer)"
    VALUE
    0x8007136C
    Val_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_swtSSpMon_C
    "Switch for Power Supply of RDS"
    VALUE
    0x8007136D
    Val_Wu8
    2.000
    OneToOne
    1.000
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tidPresRst_C
    "Recovery time that resets the pressure jump counter."
    VALUE
    0x80071368
    Val_Ws32
    3600000.00000
    Time_ms
    0.00
    3600000.00000

    FORMAT "%13.5"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tiEngOff_C
    "Minimal engine stop time necessary to run the test during start"
    VALUE
    0x80071370
    Val_Ws32
    21474836.4700
    Time_s
    0.00
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tiEvalDel_C
    "Delay time for evaluating the monitoring results for offset testing for the rail pressure sensor"
    VALUE
    0x80071374
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tiFlt1PT1_C
    "PT1 filter parameter for increasing rail pressure"
    VALUE
    0x80071358
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tiFlt2PT1_C
    "PT1 filter parameter for decreasing rail pressure (small signal behaviour)"
    VALUE
    0x8007135C
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tiFlt3PT1_C
    "PT1 filter parameter for severely decreasing rail pressure (large signal behaviour)"
    VALUE
    0x80071360
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tiOfsTstAftRun_C
    "Monitoring time of offset test for the rail pressure sensor during after-run"
    VALUE
    0x80071376
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tiOfsTstDel_CUR
    "Delay time for offset monitoring of the rail pressure sensor"
    CURVE
    0x80071378
    Cur_Xs16Ws16
    5242.720
    TimeRed
    0.00
    5242.720

    FORMAT "%8.3"
    EXTENDED_LIMITS -5242.880 5242.720
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        6
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tiOfsTstStrt_C
    "Monitoring time of offset test for the rail pressure sensor during startup"
    VALUE
    0x80071392
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tiStrErrDel_C
    "Timeout for saving the monitoring results for offset testing for the rail pressure sensor"
    VALUE
    0x80071394
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tOfsTstAftRun_C
    "System temperature threshold for releasing the offset monitoring of the rail pressure sensor during after-run"
    VALUE
    0x80071396
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tOfsTstDec_C
    "Cooling off water temperature differential for releasing the offset monitoring of the rail pressure sensor during startup"
    VALUE
    0x80071398
    Val_Ws16
    100.0000
    TempDiff_Kelv
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tOfsTstInc_C
    "Warming up water temperature differential for releasing the offset monitoring of the rail pressure sensor during startup"
    VALUE
    0x8007139A
    Val_Ws16
    100.0000
    TempDiff_Kelv
    -100.0000
    0.00

    FORMAT "%8.4"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_tOfsTstStrt_C
    "System temperature threshold for releasing the offset monitoring of the rail pressure sensor during startup"
    VALUE
    0x8007139C
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_uOfsAftRunMax_C
    "Upper offset threshold of the rail pressure sensor offset monitoring during after-run"
    VALUE
    0x8007139E
    Val_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_uOfsAftRunMin_C
    "Lower offset threshold of the rail pressure sensor offset monitoring during after-run"
    VALUE
    0x800713A0
    Val_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_uOfsStrtMax_C
    "Upper offset threshold of the rail pressure sensor offset monitoring during startup"
    VALUE
    0x800713A2
    Val_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RailP_uOfsStrtMin_C
    "Lower offset threshold of the rail pressure sensor offset monitoring during startup"
    VALUE
    0x800713A4
    Val_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dpPCVSetShOffDec_C
    "demounting gradient of PCV set in case of shut off system"
    VALUE
    0x800713B0
    Val_Ws16
    13000000.
    PresRail_sec
    0.00
    13000000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -13107200. 13106800.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dpSetPointDec_CUR
    "curve for Maximum rail pressure setpoint decrease per second"
    CURVE
    0x8007292C
    Cur_Xs16Ws16
    13000000.
    PresRail_sec
    0.00
    13000000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -13107200. 13106800.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Rail_pSetPoint
        Pres_Rail
        8
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dpSetPointIncLim_MAP
    ""
    MAP
    0x8007294E
    Map_Xs16Ys16Ws16
    13000000.
    PresRail_sec
    0.00
    13000000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -13107200. 13106800.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        5
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        Tra_numGear
        OneToOne
        4
        -1.000
        7.000

        FORMAT "%5.3"
        EXTENDED_LIMITS -32768. 32767.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dpSetPointInc_MAP
    "Maximum rail pressure setpoint increase per second based upon the engine speed and injected fuel quantity"
    MAP
    0x8007298C
    Map_Xs16Ys16Ws16
    13000000.
    PresRail_sec
    0.00
    13000000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -13107200. 13106800.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        Rail_qSetPointInc_mp
        InjMass
        8
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dqLimRmp.Pos_C
    " / Slope if the ramp has to be increased"
    VALUE
    0x80072BF4
    Kw_Ws32
    327679.999847
    RmpInjMass
    0.00
    327679.999847

    FORMAT "%13.6"
    EXTENDED_LIMITS -327680.000000 327679.999847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dqLimRmp.Neg_C
    " / negative ramp slope"
    VALUE
    0x80072BF8
    Kw_Ws32
    327679.999847
    RmpInjMass
    0.00
    327679.999847

    FORMAT "%13.6"
    EXTENDED_LIMITS -327680.000000 327679.999847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolDvtLim_C
    "Volume flow deviation for a switchover from the Rail_stCPC == CPC_MEUN_CLOSE state"
    VALUE
    0x800713B2
    Val_Ws16
    655350.0
    Qp_mm3_sec
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolLeak_MAP
    "Leakage map for pressure governing by metering unit"
    MAP
    0x8007222A
    Map_Xs16Ys16Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Rail_pSetPoint
        Pres_Rail
        10
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_tFlSys
        Temp_Cels
        10
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnClose_CUR
    "Governor deviation for closing the MeUn"
    CURVE
    0x800713B4
    Cur_Xs16Ws16
    60000.00
    Qp_mm3_sec
    -50000.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnCtlInitI_CUR
    "Curve for initializing I component as a function of the system temperature"
    CURVE
    0x800713E6
    Cur_Xs16Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_tFlSys
        Temp_Cels
        6
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnCtlLoLim_C
    "Lower set value limitation"
    VALUE
    0x80071904
    Val_Ws16
    655350.0
    Qp_mm3_sec
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnCtlType_CUR
    "curve to detect overrun to switch faster in CPC mode"
    CURVE
    0x80071E78
    Cur_Xs16Ws16
    60000.00
    Qp_mm3_sec
    -50000.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        6
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnCtlUpLim_C
    "Upper set value limitation in case of error"
    VALUE
    0x80071906
    Val_Ws16
    100000.0
    Qp_mm3_sec
    0.00
    100000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnCtlUpLim_CUR
    "Upper set value limitation"
    CURVE
    0x80071908
    Cur_Xs16Ws16
    655350.0
    Qp_mm3_sec
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnLimFst_CUR
    "maximum admissible set value MeUn for rail pressure monitoring as a function of set value of metering unit"
    CURVE
    0x80071FEC
    Cur_Xs16Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnOpn_CUR
    "Governor deviation for opening the MeUn"
    CURVE
    0x80071400
    Cur_Xs16Ws16
    60000.00
    Qp_mm3_sec
    -10000.00
    50000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnShutOffErr_C
    "MeUn set point value for zero flow rate"
    VALUE
    0x80071432
    Val_Ws16
    60000.00
    Qp_mm3_sec
    -10000.00
    50000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolMeUnShutOff_C
    "MeUn set point value while switching off the system"
    VALUE
    0x80071434
    Val_Ws16
    60000.00
    Qp_mm3_sec
    -10000.00
    50000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolOff_C
    "Volume flow at system shut-off (zero delivery)"
    VALUE
    0x80071436
    Val_Ws16
    655350.0
    Qp_mm3_sec
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolPCVClose_CUR
    "Governor deviation for closing the PCV"
    CURVE
    0x80071438
    Cur_Xs16Ws16
    50000.00
    Qp_mm3_sec
    -50000.00
    0.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolPCVOpn_CUR
    "Governor deviation for opening the PCV"
    CURVE
    0x8007146A
    Cur_Xs16Ws16
    50000.00
    Qp_mm3_sec
    0.00
    50000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolPreCtlBas_MAP
    "Basic precontrol map for pressure governing by metering unit"
    MAP
    0x8007231E
    Map_Xs16Ys16Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        Rail_qPreCtlBas_mp
        InjMass
        16
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolPreCtlOfs_MAP
    "Offset curve of the precontrol value (control by metering unit)"
    MAP
    0x80072562
    Map_Xs16Ys16Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        8
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjCtl_qSetUnBal
        InjMass
        8
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolPreCtlPoI1_MAP
    "Precontrol map based on post injection quantity 1 for pressure control by metering unit"
    MAP
    0x80072606
    Map_Xs16Ys16Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        4
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjCrv_qPoI1Des_mp
        InjMass
        4
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolPreCtlPoI2_MAP
    "Precontrol map based on post injection quantity 2 for pressure control by metering unit"
    MAP
    0x8007263A
    Map_Xs16Ys16Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        4
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjCrv_qPoI2Des_mp
        InjMass
        4
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolPreCtl_C
    "Remote control value for the precontrol value for pressure control by metering unit"
    VALUE
    0x8007266E
    Val_Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolRedOfsLimHi_C
    "upper volume flow rate hysteresis threshold for rail pressure offset reduction"
    VALUE
    0x80072678
    Val_Ws16
    655350.0
    Qp_mm3_sec
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolRedOfsLimLo_C
    "lower volume flow rate hysteresis threshold for rail pressure offset reduction"
    VALUE
    0x8007267A
    Val_Ws16
    655350.0
    Qp_mm3_sec
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_dvolStrt_C
    "Volume flow during starting phase (2-actuator concept)"
    VALUE
    0x8007149C
    Val_Ws16
    655350.0
    Qp_mm3_sec
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facFlPLimFTSCor_CUR
    ""
    CURVE
    0x80072BFC
    Cur_Xs16Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_t
        Temp_Cels
        4
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facLeakAged_C
    "Factor for determining the maximum possible volume flow for an aged system"
    VALUE
    0x80072670
    Val_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facMeUnCtlICor_CUR
    "Correction factor for I amplification"
    CURVE
    0x80071952
    Cur_Xs16Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_tFlSys
        Temp_Cels
        4
        -50.04000
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facMeUnCtlPCor_CUR
    "Correction factor for P amplification"
    CURVE
    0x80071964
    Cur_Xs16Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_tFlSys
        Temp_Cels
        4
        -50.04000
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facMeUnDvt_CUR
    "Weighting factor for the governor deviation of the MeUn"
    CURVE
    0x8007149E
    Cur_Xs16Ws16
    100.0000
    Fact100
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facMeUnSetPoint_MAP
    "Factor for determining the minimum delivery quantity of the high pressure pump"
    MAP
    0x800714D0
    Map_Xs16Ys16Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjCtl_qSetUnBal
        InjMass
        12
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facOvrMeUnNegIncr_C
    "Multiplication factor for increasing I amplification for negative large signals when there is overpressure (pressure control by metering unit)"
    VALUE
    0x80071976
    Val_Ws16
    255.9922
    Fact1
    0.00
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facOvrPCVNegIncr_C
    "Multiplication factor for increasing I amplification for negative large signals when there is overpressure (pressure control by PCV)"
    VALUE
    0x80071C5A
    Val_Ws16
    255.9922
    Fact1
    0.00
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facPCVDvt_CUR
    "Weighting factor for the governor deviation of the PCV"
    CURVE
    0x80071624
    Cur_Xs16Ws16
    100.0000
    Fact100
    -100.0000
    0.00

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_facPCVFast_C
    "Factor for accelerating the positioning response of the pressure control valve via the governor deviation"
    VALUE
    0x80071656
    Val_Ws16
    655.3500
    Fact100
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_iMeUnClsHpTst_C
    "Dataset value for current to close the metering unit during HpTst"
    VALUE
    0x80071F18
    Val_Wu16
    2500.000
    Curr
    0.00
    2500.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnCtlDKd_CUR
    "D amplification for pressure control by metering unit"
    CURVE
    0x80071978
    Cur_Xs16Ws16
    0.5000000
    Kd_pRail2Q_1
    0.00
    0.5000000

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.8000000 0.7999756
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnCtlIKiHpTst_CUR
    "I-Amplification for pressure governing via metering unit during HpTst"
    CURVE
    0x800719BA
    Cur_Xs16Ws16
    2.000015
    Ki_pRail2Q_1
    0.00
    2.000015

    FORMAT "%8.6"
    EXTENDED_LIMITS -3.051758 3.051665
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnCtlIKiNeg_CUR
    "I amplification for negative large signals for pressure control by metering unit"
    CURVE
    0x800719FC
    Cur_Xs16Ws16
    2.000015
    Ki_pRail2Q_1
    0.00
    2.000015

    FORMAT "%8.6"
    EXTENDED_LIMITS -3.051758 3.051665
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnCtlIKiPos_CUR
    "I amplification for positive large signals for pressure control by metering unit"
    CURVE
    0x80071A3E
    Cur_Xs16Ws16
    2.000015
    Ki_pRail2Q_1
    0.00
    2.000015

    FORMAT "%8.6"
    EXTENDED_LIMITS -3.051758 3.051665
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnCtlIKi_CUR
    "I amplification for small signals for pressure control by metering unit"
    CURVE
    0x80071A80
    Cur_Xs16Ws16
    2.000015
    Ki_pRail2Q_1
    0.00
    2.000015

    FORMAT "%8.6"
    EXTENDED_LIMITS -3.051758 3.051665
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnCtlPKpHpTst_CUR
    "P-Amplification for pressure governing via metering unit during HpTst"
    CURVE
    0x80071AC2
    Cur_Xs16Ws16
    0.2000000
    Kp_pRail2Q_1
    0.00
    0.2000000

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.4000000 0.3999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnCtlPKpNeg_CUR
    "P amplification for negative large signals for pressure control by metering unit"
    CURVE
    0x80071B04
    Cur_Xs16Ws16
    0.2000000
    Kp_pRail2Q_1
    0.00
    0.2000000

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.4000000 0.3999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnCtlPKpPos_CUR
    "P amplification for positive large signals for pressure control by metering unit"
    CURVE
    0x80071B46
    Cur_Xs16Ws16
    0.2000000
    Kp_pRail2Q_1
    0.00
    0.2000000

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.4000000 0.3999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnCtlPKp_CUR
    "P amplification for small signals for pressure control by metering unit"
    CURVE
    0x80071B88
    Cur_Xs16Ws16
    0.2000000
    Kp_pRail2Q_1
    0.00
    0.2000000

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.4000000 0.3999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnMon.dvolSetMin_C
    "Class for MeUn monitoring threshold value / minimum admissible flow of fuel through metering unit for rail pressure monitoring"
    VALUE
    0x8007202E
    Val_Ws16
    50000.00
    Qp_mm3_sec
    0.00
    50000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnMon.pFltMax_C
    "Class for MeUn monitoring threshold value / maximum admissbile rail pressure"
    VALUE
    0x80072030
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnMon.pFltMax2_C
    "Class for MeUn monitoring threshold value / maximum admissbile rail pressure for the second monitoring stage"
    VALUE
    0x80072032
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnMon.pDvtMax_C
    "Class for MeUn monitoring threshold value / maximum admissible governor deviation for rail pressure monitoring"
    VALUE
    0x80072034
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnMon.qLoIdl_C
    "Class for MeUn monitoring threshold value / quantity threshold for rail pressure monitoring to recognize the overrun condition"
    VALUE
    0x80072036
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnMon.tLoIdl_C
    "Class for MeUn monitoring threshold value / system temperature threshold of rail pressure monitoring"
    VALUE
    0x80072038
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_MeUnMon.stRls_C
    "Class for MeUn monitoring threshold value / general release mask for monitoring pressure governing via metering unit"
    VALUE
    0x8007203A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_nCloseCtl_C
    "Engine speed threshold for transition between open loop and closed loop control"
    VALUE
    0x80071658
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_nCPCMin_C
    "engine thresold to dectect rail pressure error in CPC mode"
    VALUE
    0x80071F94
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_nDiffMaxHpTst_C
    "Maximum allowed engine speed deviation during HpTst"
    VALUE
    0x80071F1A
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_nEngSpdLim_C
    "maximum engine speed for rail pressure substitution"
    VALUE
    0x80072BD2
    Val_Wu16
    32767.50
    EngN
    0.00
    32767.50

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 32767.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_nHpTst_CA
    "Dataset value for engine speed levels for HpTst"
    VAL_BLK
    0x80071F1C
    ValA_Wu16
    32767.00
    EngN
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 32767.50
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_nMeUnFrzI_C
    "Engine speed threshold for freezing the I component for the pressure governor by the metering unit"
    VALUE
    0x8007165A
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_nRedOfsLimHi_C
    "upper engine speed hysteresis threshold for rail pressure offset reduction"
    VALUE
    0x8007267C
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_nRedOfsLimLo_C
    "lower engine speed hysteresis threshold for rail pressure offset reduction"
    VALUE
    0x8007267E
    Val_Ws16
    3000.000
    EngN
    0.00
    3000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_nThresStrt_C
    "Engine speed threshold for exiting the startup state of state control"
    VALUE
    0x8007165C
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_numRevDel_C
    "Number of engine rotations required to change from open loop to closed loop control"
    VALUE
    0x8007165E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_numRevPlaus_C
    "Number of camshaft rotations required to change from precontrol to control."
    VALUE
    0x80071660
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pCloseCtl_C
    "Absolute pressure threshold from switching over to closed loop control"
    VALUE
    0x80071662
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pCPCFltMax_C
    "Maximum rail pressure allowed for CPC monitoring"
    VALUE
    0x80071F96
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pCPCFltMin_CUR
    "Minimum admissible rail pressure as a function of the engine speed while CPC governing is active"
    CURVE
    0x80071F98
    Cur_Xs16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pCPCSetMax_CUR
    "threshold for PCV set value to detect rail pressure error in CPC mode"
    CURVE
    0x80071FDA
    Cur_Xs16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Rail_pSetPoint
        Pres_Rail
        4
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVCtlDKd_CUR
    "D amplification for pressure control by PCV"
    CURVE
    0x80071C5C
    Cur_Xs16Ws16
    50.00000
    Kd_1
    0.00
    50.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -64.00000 63.99805
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVCtlIKiNeg_CUR
    "I amplification for negative large signals for pressure control by PCV"
    CURVE
    0x80071C9E
    Cur_Xs16Ws16
    249.9968
    Ki_1
    0.00
    249.9968

    FORMAT "%8.4"
    EXTENDED_LIMITS -488.2813 488.2663
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVCtlIKiPos_CUR
    "I amplification for positive large signals for pressure control by PCV"
    CURVE
    0x80071CE0
    Cur_Xs16Ws16
    249.9968
    Ki_1
    0.00
    249.9968

    FORMAT "%8.4"
    EXTENDED_LIMITS -488.2813 488.2663
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVCtlIKi_CUR
    "I amplification for small signals for pressure control by PCV"
    CURVE
    0x80071D22
    Cur_Xs16Ws16
    249.9968
    Ki_1
    0.00
    249.9968

    FORMAT "%8.4"
    EXTENDED_LIMITS -488.2813 488.2663
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVCtlPKpNeg_CUR
    "P amplification for negative large signals for pressure control by PCV"
    CURVE
    0x80071D64
    Cur_Xs16Ws16
    300.0000
    Kp_1
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -512.0000 511.9844
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVCtlPKpPos_CUR
    "P amplification for positive large signals for pressure control by PCV"
    CURVE
    0x80071DA6
    Cur_Xs16Ws16
    300.0000
    Kp_1
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -512.0000 511.9844
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVCtlPKp_CUR
    "P amplification for small signals for pressure control by PCV"
    CURVE
    0x80071DE8
    Cur_Xs16Ws16
    300.0000
    Kp_1
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -512.0000 511.9844
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVMon.pDvtMax_C
    "Class for PCV monitoring threshold value / maximum admissible governor deviation for rail pressure monitoring"
    VALUE
    0x80072186
    Val_Ws16
    3600000.
    Pres_Rail
    -1800000.
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVMon.pDvtMin_C
    "Class for PCV monitoring threshold value / maximum negative rail pressure deviation for rail monitoring"
    VALUE
    0x80072188
    Val_Ws16
    3600000.
    Pres_Rail
    -1800000.
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVMon.pDvtMin2_C
    "Class for PCV monitoring threshold value / maximum negative rail pressure deviation for rail monitoring for the second monitoring stage"
    VALUE
    0x8007218A
    Val_Ws16
    3600000.
    Pres_Rail
    -1800000.
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVMon.pSetMin_C
    "Class for PCV monitoring threshold value / minimum tolerated set value of rail monitoring"
    VALUE
    0x8007218C
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVMon.pFltMax_C
    "Class for PCV monitoring threshold value / maximum allowed rail pressure"
    VALUE
    0x8007218E
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVMon.pFltMax2_C
    "Class for PCV monitoring threshold value / maximum allowed rail pressure for the second monitoring stage"
    VALUE
    0x80072190
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_PCVMon.stRls_C
    "Class for PCV monitoring threshold value / general release mask for monitoring based on pressure control valve regulating"
    VALUE
    0x80072192
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pDiffCloseCtl_C
    "Differential pressure threshold for switching to closed loop control"
    VALUE
    0x80071664
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pDiffMaxHpTst_C
    "Maximum allowed rail pressure deviation for HpTst"
    VALUE
    0x80071F24
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pDlt5StpHpTst_C
    "Pressure interval for calculation of additional measurement points during pressure drop down phase of high pressure test"
    VALUE
    0x80071F26
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pDltHiHpTst_C
    "delta pressure value during buildup phase of high pressure test"
    VALUE
    0x80071F28
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pDltTmrUpHpTst_C
    "Dataset value for pressure threshold for build up time meassurement"
    VALUE
    0x80071F2A
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pDvtFltMin_C
    "Minimum absolute governor deviation as input signal of DT1 element"
    VALUE
    0x80071666
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pDvtRedOfsLimHi_C
    "upper deviation rate hysteresis threshold for rail pressure offset reduction"
    VALUE
    0x80072680
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pDvtRedOfsLimLo_C
    "lower deviation value hysteresis threshold for rail pressure offset reduction"
    VALUE
    0x80072682
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pFltMinZFC_C
    "Minimum rail pressure for monitoring when ZFC is active"
    VALUE
    0x80072E70
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMaxSetSubst_CUR
    "upper limit of substituded railpressure-setpoint"
    CURVE
    0x80072BD4
    Cur_Xs16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        5
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnCtlIWinNeg_C
    "Lower small signal limit for I component of pressure control by metering unit"
    VALUE
    0x80071BCA
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnCtlIWinPos_C
    "Upper small signal limit for I component of pressure control by metering unit"
    VALUE
    0x80071BCC
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnCtlPWinNeg_C
    "Lower small signal limit for P component of pressure control by metering unit"
    VALUE
    0x80071BCE
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnCtlPWinPos_C
    "Upper small signal limit for P component of pressure control by metering unit"
    VALUE
    0x80071BD0
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnCtlTypeHi_C
    "Upper setpoint pressure hysteresis threshold for inhibiting the PCV governing"
    VALUE
    0x80071E92
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnCtlTypeLo_C
    "Lower setpoint pressure hysteresis threshold for inhibiting the PCV governing"
    VALUE
    0x80071E94
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnDvtFst_CUR
    "Maximum governor deviation allowed for rail pressure monitoring as a function of engine speed for fast monitoring"
    CURVE
    0x8007203C
    Cur_Xs16Ws16
    3600000.
    Pres_Rail
    -1800000.
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnDvtMax_CUR
    "Maximum governor deviation allowed for rail pressure monitoring as a function of engine speed"
    CURVE
    0x8007207E
    Cur_Xs16Ws16
    3600000.
    Pres_Rail
    -1800000.
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnDvtMin2_CUR
    "Minimum governor deviation allowed for rail pressure monitoring as a function of engine speed for second monitoring stage"
    CURVE
    0x800720C0
    Cur_Xs16Ws16
    3600000.
    Pres_Rail
    -1800000.
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnDvtMin_CUR
    "Minimum governor deviation allowed for rail pressure monitoring as a function of engine speed"
    CURVE
    0x80072102
    Cur_Xs16Ws16
    3600000.
    Pres_Rail
    -1800000.
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnFltMin_CUR
    "Minimum rail pressure allowed as a function of the engine speed"
    CURVE
    0x80072144
    Cur_Xs16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnPreCtlOff_C
    "Pressure threshold for a switchover from the Rail_stCPC == CPC_MEUN_CLOSE state"
    VALUE
    0x80071668
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMeUnPreCtlOn_C
    "Pressure threshold for a switchover from the Rail_stCPC == CPC_MEUN_CLOSE state"
    VALUE
    0x8007166A
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pMinSetSubst_C
    "lower limit of substituted railpressure-setpoint"
    VALUE
    0x80072BEA
    Val_Wu16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS 0.00 6553500.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pOpnCtl_C
    "Absolute pressure threshold from switching over to open loop control"
    VALUE
    0x8007166C
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pOvrMeUnThresHigh_C
    "Upper hysteresis threshold for MeUn overpressure detection"
    VALUE
    0x80071BD2
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pOvrMeUnThresLow_C
    "Lower hysteresis threshold for MeUn overpressure detection"
    VALUE
    0x80071BD4
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pOvrPCVThresHigh_C
    "Upper hysteresis threshold for PCV overpressure detection"
    VALUE
    0x80071E2A
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pOvrPCVThresLow_C
    "Lower hysteresis threshold for PCV overpressure detection"
    VALUE
    0x80071E2C
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVCloseOfs_CUR
    "Precontrol offset for holding the PCV closed"
    CURVE
    0x80072684
    Cur_Xs16Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Rail_pSetPoint
        Pres_Rail
        4
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVCtlIWinNeg_C
    "Lower small signal limit for I component of pressure governor by PCV"
    VALUE
    0x80071E2E
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVCtlIWinPos_C
    "Upper small signal limit for I component of pressure governor by PCV"
    VALUE
    0x80071E30
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVCtlLoLimStrt_C
    "Lower set value limitation of rail pressure governor by PCV during the starting phase"
    VALUE
    0x8007194A
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVCtlLoLim_C
    "Lower set value limitation of rail pressure governor by PCV"
    VALUE
    0x8007194C
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVCtlPWinNeg_C
    "Lower small signal limit for P component of pressure governor by PCV"
    VALUE
    0x80071E32
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVCtlPWinPos_C
    "Upper small signal limit for P component of pressure governor by PCV"
    VALUE
    0x80071E34
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVCtlUpLimStrt_C
    "Upper set value limitation of rail pressure governor by PCV during the starting phase"
    VALUE
    0x8007194E
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVCtlUpLim_C
    "Upper set value limitation of rail pressure governor by PCV"
    VALUE
    0x80071950
    Val_Ws16
    2500000.
    Pres_Rail
    0.00
    2500000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVDvtMax_CUR
    "Maximum governor deviation as function of the engine speed for rail pressure monitoring"
    CURVE
    0x80072194
    Cur_Xs16Ws16
    3600000.
    Pres_Rail
    -1800000.
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVFltMin_CUR
    "Minimum rail pressure allowed as a function of the engine speed"
    CURVE
    0x800721D6
    Cur_Xs16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVInitI_MAP
    "Map for the initialization value of the I component of the PCV pressure governor when switching from metering unit to pressure control valve"
    MAP
    0x8007166E
    Map_Xs16Ys16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        Rail_pSetPoint
        Pres_Rail
        16
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVRedOfs_CUR
    "Precontrol reduction for quicker pressure reduction by the pressure control valve"
    CURVE
    0x80072696
    Cur_Xs16Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Rail_pSetPoint
        Pres_Rail
        4
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPCVSetMax_CUR
    "Maximum admissible setpoint pressure for rail pressure monitoring"
    CURVE
    0x80072218
    Cur_Xs16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Rail_pSetPoint
        Pres_Rail
        4
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPreCtl_C
    "Remote control value for the precontrol value for pressure control by PCV"
    VALUE
    0x800726A8
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pPreCtl_MAP
    "Precontrol map for pressure control by the pressure control valve"
    MAP
    0x800726AA
    Map_Xs16Ys16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        Rail_pSetPoint
        Pres_Rail
        16
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pRedOfsLim_C
    "Rail pressure threshold for reducing the PCV precontrol offset"
    VALUE
    0x800728EE
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetMaxHpTst_C
    "Dataset value for maximum fuel pressure setpoint requested by HpTst"
    VALUE
    0x80071F2C
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetMinHpTst_C
    "Dataset value for minimum fuel pressure setpoint requested by HpTst"
    VALUE
    0x80071F2E
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetMin_CUR
    "Curve for the minimum rail pressure as set value default for PCV"
    CURVE
    0x800718B2
    Cur_Xs16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        4
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetPointInit_C
    "Initial value of the rail pressure setpoint"
    VALUE
    0x80072A78
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetPointMaxDef_C
    "Maximum rail pressure setpoint in the event of an error"
    VALUE
    0x80072A80
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetPointMax_MAP
    "Maximum rail pressure setpoint depending on engine speed and fuel injection quantity"
    MAP
    0x80072A82
    Map_Xs16Ys16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjSys_qTot
        InjMass
        8
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetPointMinDef_C
    "Minimum rail pressure setpoint in the event of an error"
    VALUE
    0x80072BB6
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetPointMin_MAP
    "Minimum rail pressure setpoint based on the engine speed and the injection quantity"
    MAP
    0x80072BB8
    Map_Xs16Ys16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        2
        0.00
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjSys_qTot
        InjMass
        2
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetPointZFCMax_C
    "Maximum rail pressure setpoint when ZFC is active"
    VALUE
    0x80072E72
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetPointZFCMin_C
    "Minimum rail pressure setpoint when ZFC is active"
    VALUE
    0x80072E74
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetPoint_C
    "Remote control value of the rail pressure setpoint"
    VALUE
    0x80072A7A
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSetZLHpTst_C
    "Dataset value for zero load fuel pressure setpoint requested by HpTst"
    VALUE
    0x80071F30
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pStepHpTst_C
    "Dataset value for fuel pressure setpoint steps for HpTst"
    VALUE
    0x80071F32
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSwtCPCHi_C
    ""
    VALUE
    0x80071E96
    Val_Ws16
    10000.00
    Pres_hPa
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pSwtCPCLo_C
    ""
    VALUE
    0x80071E98
    Val_Ws16
    10000.00
    Pres_hPa
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pTmrDwn1HpTst_C
    "Dataset value for pressure threshold for first drop down time measurement"
    VALUE
    0x80071F34
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_pTmrDwn2HpTst_C
    "Dataset value for pressure threshold for second drop down time measurement"
    VALUE
    0x80071F36
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qCPCtlTypeHys_C
    "Hysteresis for switching to CPC governing"
    VALUE
    0x80071E9A
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qCPCtlTypeRgnHys_C
    "Hysteresis for switching to PCV governing in Regeneration at low load"
    VALUE
    0x80071E9C
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qCPCtlTypeRgn_CUR
    "quantity to switch to PCV Mode in regeneration"
    CURVE
    0x80071E9E
    Cur_Xs16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        8
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qCPCtlType_CUR
    "Fuel quantity limit for switching to CPC governing"
    CURVE
    0x80071EC0
    Cur_Xs16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        8
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qDiffMaxHpTst_C
    "Maximum allowed fuel quantity deviation for HpTst"
    VALUE
    0x80071F38
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qFlPLim_MAP
    ""
    MAP
    0x80072C0E
    Map_Xs16Ys16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        10
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        FlSys_p
        Pres_hPa
        5
        0.00
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qFlTempLimMeUn_MAP
    ""
    MAP
    0x80072C94
    Map_Xs16Ys16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_t
        Temp_Cels
        8
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qFlTempLimPCV_MAP
    ""
    MAP
    0x80072D80
    Map_Xs16Ys16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        12
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_t
        Temp_Cels
        8
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qMeUnCtlTypeHys_C
    "Hysteresis for switching to MeUn governing"
    VALUE
    0x80071EE2
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qMeUnCtlType_CUR
    "Fuel quantity limit for switching to MeUn governing"
    CURVE
    0x80071EE4
    Cur_Xs16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        8
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qRedOfsLimHi_C
    "upper injection mass hysteresis threshold for rail pressure offset reduction"
    VALUE
    0x800728F0
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qRedOfsLimLo_C
    "lower injection mass hysteresis threshold for rail pressure offset reduction"
    VALUE
    0x800728F2
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_qSetSubstLim_C
    "maximum quantity for diagnosis intervention"
    VALUE
    0x80072BEC
    Val_Wu16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_rAccPedHpTst_C
    "Maximum accelerator pedal position for HpTst"
    VALUE
    0x80071F3A
    Val_Wu16
    799.9878
    Prc
    0.00
    799.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 799.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_rAccPedSetPointTst_C
    "maximum output value of acceleration pedal"
    VALUE
    0x80072BCC
    Val_Ws16
    9.997559
    Prc
    0.00
    9.997559

    FORMAT "%8.5"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_rFltMinSlpZFC_C
    "Ramp slope at minimum rail pressure after ZFC"
    VALUE
    0x80072E76
    Val_Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_rZFCInitDwn_CUR
    "Factor for the beginning rail pressure setpoint of the PT1 filter (downward)"
    CURVE
    0x80072E78
    Cur_Xs16Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ZFC_pRailSetPoint_mp
        Pres_Rail
        6
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_rZFCInitUp_CUR
    "Factor for the beginning rail pressure setpoint of the PT1 filter (upward)"
    CURVE
    0x80072E92
    Cur_Xs16Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ZFC_pRailSetPoint_mp
        Pres_Rail
        6
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_stCtlLoopSel_C
    "Switch selection for rail pressure control"
    VALUE
    0x800718C4
    Val_Wu8
    7.000
    OneToOne
    0.00
    7.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_stMskCoEOMOpModeHpTst_C
    "Mask of allowed operation modes during high pressure test"
    VALUE
    0x80071F3C
    Val_Wu32
    65535.0000000
    OneToOne
    0.00
    65535.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_stOpModeRgn_C
    "label to detect regeneration mode"
    VALUE
    0x80071F08
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_stPreCtlMeUnSel_C
    "Switch selection for metering unit precontrol"
    VALUE
    0x80072672
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_stQLimFlSysActv_C
    ""
    VALUE
    0x80072E6C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_stSetPointSel_C
    "Switch selection for the rail pressure setpoint calculation"
    VALUE
    0x80072A7C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swt5StepHpTst_C
    "Dataset value for switch to enable fifth step without injections"
    VALUE
    0x80071F40
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtCtlParHpTst_C
    "Dataset value for switch to enable separate governor parameters during HpTst"
    VALUE
    0x80071F41
    Val_Wu8
    2.000
    OneToOne
    0.00
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtCtlType_C
    "Switch for the manual default of the governing mode"
    VALUE
    0x80071F0C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtDvolPreCtl_C
    "Switch for the remote control of the precontrol value for the metering unit"
    VALUE
    0x80072673
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtMeUnCtlIInit_C
    "release of initialisation of Rail_dvolMeUnCtlI dependence on state in change Rail_stCPC"
    VALUE
    0x800718C6
    Val_Ws16
    3.000000
    OneToOne
    0.00
    3.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtNoChkPSetPoint_C
    "switch to disable some parts of monitoring of running conditions during engine test"
    VALUE
    0x80072A7D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtNoChkRefHpTst_C
    "switch to disable some parts of monitoring of running conditions during high pressure test"
    VALUE
    0x80071F42
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtPCVInitI_C
    "Selection of PCV governor initialization with precontrol value or with setpoint"
    VALUE
    0x800718C8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtPPreCtl_C
    "Switch for the remote control of the precontrol value for the pressure control valve"
    VALUE
    0x800728F4
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtPSetPoint_C
    "Switch for the remote control of the rail pressure setpoint"
    VALUE
    0x80072A7E
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_swtqIncSel_C
    "Switch for quantity that has to be used for rail pressure increment limitation"
    VALUE
    0x80072A7F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tClntMinHpTst_C
    "Minimum coolant temperature for HpTst"
    VALUE
    0x80071F44
    Val_Ws16
    3053.600
    Temp_Cels
    -50.04000
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiBuildUpMaxHpTst_CA
    "Array of maximum times for each pressure build up phase"
    VAL_BLK
    0x80071F48
    ValA_Ws32
    5000.00000000
    Time_ms
    0.00
    5000.00000000

    FORMAT "%13.8"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiDropMaxHpTst_CA
    "Array of maximum times for each pressure drop down phase"
    VAL_BLK
    0x80071F58
    ValA_Ws32
    20000.0000000
    Time_ms
    0.00
    20000.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    
    NUMBER 5

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiDropMinHpTst_CA
    "Array of minimum times for each pressure drop down phase"
    VAL_BLK
    0x80071F6C
    ValA_Ws32
    20000.0000000
    Time_ms
    0.00
    20000.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    
    NUMBER 5

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiDvtPressRedOfsPT1_C
    "PT1-Filterkonstante für die Umschaltung auf den reduzierten Offsetwert abhängig von der Regelabweichung"
    VALUE
    0x800728F8
    Val_Ws32
    69.999327293
    TimeDelay_ms
    29.999911264
    99.999238556

    FORMAT "%12.8"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiFrzIDel_C
    "Delay time for freezing the I component for the pressure governor by the metering unit"
    VALUE
    0x800718CA
    Val_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiMaxSetPointTst_C
    "application label for total test time"
    VALUE
    0x80072BCE
    Val_Ws16
    327.6700
    Time_s
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiMaxSetSubst_C
    "max. time substitution of railpressure setpoint"
    VALUE
    0x80072BEE
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiMeUnCtlDT1_CUR
    "Time constant of the DT1 element (pressure control by metering unit)"
    CURVE
    0x80071BD6
    Cur_Xs16Ws16
    16.776216
    TimeDelay_s_2
    0.0010000129
    16.777216

    FORMAT "%9.6"
    EXTENDED_LIMITS 0.00051201563 16.777216
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiMeUnCtlPT1_CUR
    "Time constant of the PT1 filter (pressure control by metering unit)"
    CURVE
    0x80071C18
    Cur_Xs16Ws16
    16.776216
    TimeDelay_s_2
    0.0010000129
    16.777216

    FORMAT "%9.6"
    EXTENDED_LIMITS 0.00051201563 16.777216
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiMeUnRmpDur_CUR
    "Runtime of the ramp to ramp the delivery volume of the metering unit from the current setpoint to the maximum delivery"
    CURVE
    0x800718CC
    Cur_Xs16Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        10
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiPCVCtlDT1_CUR
    "Time constant of the DT1 element for pressure control by PCV"
    CURVE
    0x80071E36
    Cur_Xs16Ws16
    16.776216
    TimeDelay_s_2
    0.0010000129
    16.777216

    FORMAT "%9.6"
    EXTENDED_LIMITS 0.00051201563 16.777216
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiPCVRmpDur_CUR
    "Runtime of the ramp to ramp from the current setpoint to the new PCV closing value"
    CURVE
    0x800728FC
    Cur_Xs16Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        10
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiPCVRmpToOfs_C
    "Runtime of the ramp to ramp from the reduced offset value to the offset value"
    VALUE
    0x80072926
    Val_Ws16
    300.0000
    Time_ms
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiPCVRmpToRedOfs_C
    "Runtime of the ramp to ramp from the offset value to the reduced offset value"
    VALUE
    0x80072928
    Val_Ws16
    300.0000
    Time_ms
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiPT1CPCDvt_C
    "Delay time constant for the volume flow governor deviation"
    VALUE
    0x800718F8
    Val_Ws32
    1073.7408240
    TimeDelay_s
    0.0010000000689
    1073.7418240

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiShutOffDblCtl_C
    "time to switch to 2nd faultpath for delayed shutoff"
    VALUE
    0x800718FC
    Val_Ws16
    100.0000
    Time_s
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiStepHpTst_C
    "Time constant for pressure build up ramp"
    VALUE
    0x80071F80
    Val_Ws16
    32770.00
    Time_ms
    0.00
    32770.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiStrtHpTst_C
    "Waiting time before start of HpTst"
    VALUE
    0x80071F84
    Val_Ws32
    32770.0000000
    Time_ms
    0.00
    32770.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiSwtCPCMax_C
    "Maximum dwell time for a state for CPC governing"
    VALUE
    0x800718FE
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiSwtCtlTypeDel_C
    "Delay time until release of switchover of the governor principle"
    VALUE
    0x80071F0E
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiSwtToMeUnCtl_C
    "Delay time until switching over to pressure control by metering unit"
    VALUE
    0x80071900
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiWaitAftDropHpTst_C
    "Waiting time after pressure drop in HpTst"
    VALUE
    0x80071F88
    Val_Ws32
    20000.0000000
    Time_ms
    0.00
    20000.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiWaitHiHpTst_C
    "Waiting time after pressure build up in HpTst"
    VALUE
    0x80071F8C
    Val_Ws32
    20000.0000000
    Time_ms
    0.00
    20000.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiWaitLoHpTst_C
    "Waiting time before pressure build up in HpTst"
    VALUE
    0x80071F90
    Val_Ws32
    20000.0000000
    Time_ms
    0.00
    20000.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiZFCDemDel_C
    "Delay time for switchover to closed PCV when ZFC learning phase is active"
    VALUE
    0x80072EAC
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tiZFCPT1_C
    "Parameter for ZFC rail pressure setpoint PT1 filter"
    VALUE
    0x80072EB0
    Val_Ws32
    4294.9630010
    TimeDelay_s
    0.0042949672960
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tMeUnCtlTypeHi_C
    "Upper temperature hysteresis threshold for inhibiting the PCV governing"
    VALUE
    0x80071F10
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tMeUnCtlTypeLo_C
    "Lower temperature hysteresis threshold for inhibiting the PCV governing"
    VALUE
    0x80071F12
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tMinSetPointTst_C
    "application label for minimum temperature"
    VALUE
    0x80072BD0
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tSwtCPCHi_C
    "Upper temperature hysteresis threshold for inhibiting the PCV governing"
    VALUE
    0x80071F14
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_tSwtCPCLo_C
    "Lower temperature hysteresis threshold for inhibiting the PCV governing"
    VALUE
    0x80071F16
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_vMeUnThresShutOff_C
    "vehicle speed threshold while switching over to MeUn"
    VALUE
    0x80071902
    Val_Ws16
    40.00000
    Vel
    0.00
    40.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_volInjVlvCtl_C
    "Control volume of the injectors"
    VALUE
    0x80072674
    Val_Ws16
    10.00000
    InjQntInj
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rail_vVehSpdLim_C
    "max. vehicle speed for rail pressure substitution"
    VALUE
    0x80072BF0
    Val_Wu16
    300.0000
    Vel
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Reset_rstFlMRErrBuf_C
    "Label for reseting the Reset_FlMRErrBuf"
    VALUE
    0x80072EB4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Reset_rstTrapErrIntrBuf_C
    "Label for reseting the Reset_TrapErrIntrBuf"
    VALUE
    0x80072EB5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Reset_xGrpId_C
    "Reset-group-ID with which a SoftwareReset should be executed"
    VALUE
    0x80072EB6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Reset_xTrgId_C
    "Reset-ID with which a SoftwareReset should be executed"
    VALUE
    0x80072EB8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rtmo_adCalling_u32
    "Address of calling element"
    VALUE
    0x80072EBC
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rtmo_adData_u32
    "Address of measur-element"
    VALUE
    0x80072EC0
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rtmo_stSampleTime_u8
    "Sampling time"
    VALUE
    0x80072EC4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rtmo_swLoadMode_u8
    "LoadMode"
    VALUE
    0x80072EC5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rtmo_swMode_u8
    "Mode"
    VALUE
    0x80072EC6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rtmo_tiIntOverhead_Tick
    "Overhead of interrupt measure function"
    VALUE
    0x80072EC8
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Rtmo_tiOverhead_Tick
    "Overhead of measure function"
    VALUE
    0x80072ECC
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Signals_Mode1Pid_CA
    "Signals- structure for storing aplicable linear conversion formulae"
    VAL_BLK
    0x80072EDC
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Signals_Mode1SigNum_CA
    "Signals- structure for storing aplicable linear conversion formulae"
    VAL_BLK
    0x80072EDE
    ValA_Wu16
    100.000000000
    Signals_IntSigNumVerb
    0.00
    100.000000000

    FORMAT "%13.9"
    EXTENDED_LIMITS 0.00 100.000000000
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SigTst_stShOff_ATS.LimitTypeMsk_C
    "Actuator test SigTst_stShOff_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BDD8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SigTst_stShOff_ATS.CnvNorm_C
    "Actuator test SigTst_stShOff_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BDD9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SigTst_stShOff_ATS.LowLim_C
    "Actuator test SigTst_stShOff_ATS / Lower limit for monitoring"
    VALUE
    0x8006BDDA
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SigTst_stShOff_ATS.UpLim_C
    "Actuator test SigTst_stShOff_ATS / Upper limit for monitoring"
    VALUE
    0x8006BDDC
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SigTst_stShOff_ATS.CnvFac_C
    "Actuator test SigTst_stShOff_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BDE0
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SigTst_stShOff_ATS.CnvOfs_C
    "Actuator test SigTst_stShOff_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BDE4
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SigTst_stShOff_ATS.DfltVal_C
    "Actuator test SigTst_stShOff_ATS / Default value for standbytest"
    VALUE
    0x8006BDE6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SpdGov_nSetPLo_C
    ""
    VALUE
    0x80072F04
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_swtGlbTyp_C
    "Global switch type : 1 = value from Eep, 2 = value from application"
    VALUE
    0x80072ED0
    Val_Wu8
    1.000
    OneToOne
    1.000
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.AFS_swtVal_C
    "Structure of values for software switches / Value of the switch AFS_swtVal_C"
    VALUE
    0x80072ED2
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.ETClb_swtCorActvVal_C
    "Structure of values for software switches / Value of the switch ETClb_swtCorActvVal_C"
    VALUE
    0x80072ED3
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.GlwCtl_swtPreGlw_C
    "Structure of values for software switches / Value of the switch GlwCtl_swtPreGlw_C"
    VALUE
    0x80072ED4
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.GlwCtl_swtGlwPlgMode_C
    "Structure of values for software switches / Value of the switch GlwCtl_swtGlwPlgMode_C"
    VALUE
    0x80072ED5
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.PCV_swtCtlStateVal_C
    "Structure of values for software switches / Value of the switch PCV_swtCtlStateVal_C"
    VALUE
    0x80072ED6
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.Rail_swtPreCtlVal_C
    "Structure of values for software switches / Value of the switch Rail_swtPreCtlVal_C"
    VALUE
    0x80072ED7
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.Rail_swtWindUpVal_C
    "Structure of values for software switches / Value of the switch Rail_swtWindUpVal_C"
    VALUE
    0x80072ED8
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.Rail_swtCtlSelVal_C
    "Structure of values for software switches / Value of the switch Rail_swtCtlSelVal_C"
    VALUE
    0x80072ED9
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.Rail_swtPressVal_C
    "Structure of values for software switches / Value of the switch Rail_swtPressVal_C"
    VALUE
    0x80072EDA
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSwtS_Val.ZFC_swtClbActvVal_C
    "Structure of values for software switches / Value of the switch ZFC_swtClbActvVal_C"
    VALUE
    0x80072EDB
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Strt_stPs_C
    ""
    VALUE
    0x80072F06
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Strt_st_C
    ""
    VALUE
    0x80072F07
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SWA_CANHS_RNr_01_CA
    "SWA_CANHS_RNr_01_Msg data calibration"
    VAL_BLK
    0x8006CEB2
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SyC_stTest_C
    "Control of the test mode of system control"
    VALUE
    0x80072F20
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SyC_swtPreDrv_C
    "Switch/code word for PreDrive control"
    VALUE
    0x80072F26
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SyC_swtTestEna_C
    "Switch/codeword to activate the test mode of system control"
    VALUE
    0x80072F21
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SyC_tiDiaStopCnt_C
    "Diagnosis time for stop counter"
    VALUE
    0x80072F2A
    Val_Wu8
    128.0
    Time_sec_q1_COMPU
    0.00
    128.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SyC_tiPostDrvMax_C
    "Maximum time in PostDrive state with rpm equal zero"
    VALUE
    0x80072F22
    Val_Wu16
    3997.000
    SyC_Time_100ms
    3.000000
    4000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 6553.500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SyC_tiPostDrvMin_C
    "Minimum time in PostDrive state"
    VALUE
    0x80072F24
    Val_Wu16
    59.80000
    SyC_Time_100ms
    0.2000000
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 6553.500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SyC_tiPreDrvMax_C
    "Maximum time to prolong the PreDrive"
    VALUE
    0x80072F28
    Val_Wu16
    65534.00
    SyC_Time_1s
    1.000000
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SyC_tiStopCntMax_C
    "Maximum acquirable ECU off time"
    VALUE
    0x80072F2C
    Val_Wu16
    544.0000
    Time_min_q2_COMPU
    2.000000
    546.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 131070.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_Deb.tiHiLo_C
    "Debounce parameter structure for T15 / Time for a High to Low transition"
    VALUE
    0x8006C18A
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_Deb.tiLoHi_C
    "Debounce parameter structure for T15 / Time for a Low to High transition"
    VALUE
    0x8006C18C
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_DebRB.tiHiLo_C
    " / Time for a High to Low transition"
    VALUE
    0x80072F2E
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_DebRB.tiLoHi_C
    " / Time for a Low to High transition"
    VALUE
    0x80072F30
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_I_D_ATS_ATS.LimitTypeMsk_C
    " / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BDE8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_I_D_ATS_ATS.CnvNorm_C
    " / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BDE9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_I_D_ATS_ATS.LowLim_C
    " / Lower limit for monitoring"
    VALUE
    0x8006BDEA
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_I_D_ATS_ATS.UpLim_C
    " / Upper limit for monitoring"
    VALUE
    0x8006BDEC
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_I_D_ATS_ATS.CnvFac_C
    " / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BDF0
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_I_D_ATS_ATS.CnvOfs_C
    " / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BDF4
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    T15_I_D_ATS_ATS.DfltVal_C
    " / Default value for standbytest"
    VALUE
    0x8006BDF6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_facDynMax_C
    "maximum engine speed dynamics for tooth angle adaption"
    VALUE
    0x80072F34
    Val_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_facSinTab_CA
    "filter coefficients for tooth angle adaption"
    VAL_BLK
    0x80072F36
    ValA_Ws16
    2.000000
    FacTrigoFunc
    -1.000000
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -8.000000 7.999756
    
    NUMBER 30

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_nAdapMid_CA
    "center of engine speed intervals for tooth angle adaption"
    VAL_BLK
    0x80072F72
    ValA_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_nAdapRng_CA
    "bandwidth of engine speed intervals for tooth angle adaption"
    VAL_BLK
    0x80072F78
    ValA_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_nMax_C
    "maximum engine speed for tooth angle adaption"
    VALUE
    0x80072F98
    Val_Wu16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 32767.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_nMin_C
    "minimum engine speed for tooth angle adaption"
    VALUE
    0x80072F9A
    Val_Wu16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 32767.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_numActv_CA
    "number of increments evaluated per task activation in tooth angle adaption"
    VAL_BLK
    0x80072F9C
    ValA_Wu8
    125.0
    OneToOne
    0.00
    125.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_numGapIpoInc_C
    "number of increments used for gap interpolation in increment angle adaption"
    VALUE
    0x80072F7E
    Val_Wu8
    9.000
    OneToOne
    1.000
    10.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_numIncGap_CA
    "gap configuration of sensor wheel for tooth angle adaption"
    VAL_BLK
    0x80072FA4
    ValA_Wu8
    10.00
    OneToOne
    0.00
    10.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_numRevCor_C
    "number of crankshaft revolutions to update correction values of tooth angle adaption"
    VALUE
    0x80072FA6
    Val_Wu8
    19.00
    OneToOne
    1.000
    20.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_numSinTab_C
    "number of filter coefficients in TAA_facSinTab_CA for tooth angle adaption"
    VALUE
    0x80072F7F
    Val_Wu8
    30.00
    OneToOne
    0.00
    30.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_phiDiffMaxFst_CA
    "thresholds for settlement state of the engine speed ranges during fast learning"
    VAL_BLK
    0x80072F80
    ValA_Ws16
    0.2499390
    AgCrSHiReso
    0.00
    0.2499390

    FORMAT "%9.7"
    EXTENDED_LIMITS -5.625000 5.624828
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_phiDiffMax_CA
    "thresholds for settlement state of the engine speed ranges in tooth angle adaption"
    VAL_BLK
    0x80072F86
    ValA_Ws16
    0.2499390
    AgCrSHiReso
    0.00
    0.2499390

    FORMAT "%9.7"
    EXTENDED_LIMITS -5.625000 5.624828
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_rTrqMax_C
    "maximum torque transition ratio for activation of tooth angle adaption"
    VALUE
    0x80072FA8
    Val_Wu16
    100.0000
    TransR
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_stAdapMode_C
    "calculation mode for correction of increment angles"
    VALUE
    0x80072FAA
    Val_Wu8
    4.000
    OneToOne
    0.00
    4.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_stEvalFin_C
    "last partial algorithm to be executed in tooth angle adaption"
    VALUE
    0x80072FAC
    Val_Wu16
    128.0000
    OneToOne
    0.00
    128.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_stExtp_C
    "enable extrapolation of increment angle correction values"
    VALUE
    0x80072FAE
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_stFstLrnMsk_C
    "required settlement state of correction values for deactivation of fast learning"
    VALUE
    0x80072FAF
    Val_Wu8
    7.000
    OneToOne
    0.00
    7.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_stMainSpdRng_C
    "main speed range for tooth angle adaption"
    VALUE
    0x80072F8C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_stReqRstVal_C
    "request for reset of adaption values of tooth angle adaption"
    VALUE
    0x80072F8D
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_stTstMode_C
    "test mode enable for tooth angle adaption"
    VALUE
    0x80072FB0
    Val_Wu8
    31.00
    OneToOne
    0.00
    31.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_tiEnaDel_C
    "turn on delay from overrun to activation of tooth angle adaption"
    VALUE
    0x80072FB2
    Val_Wu16
    100.0000
    Time_s
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_tiIncDvtFltFst_C
    "filter time constant for tooth angle deviations during fast learning"
    VALUE
    0x80072F90
    Val_Ws32
    99.782961134
    TimeDelay_s
    0.099999238556
    99.882960372

    FORMAT "%12.8"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_tiIncDvtFlt_C
    "filter time constant for tooth angle deviations"
    VALUE
    0x80072F94
    Val_Ws32
    99.782961134
    TimeDelay_s
    0.099999238556
    99.882960372

    FORMAT "%12.8"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TAA_vMin_C
    "minimum vehicle velocity for activation of tooth angle adaption"
    VALUE
    0x80072FB4
    Val_Wu16
    300.0000
    Vel
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_tini_io_xx
    " / "
    VALUE
    0x8006C48C
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_ton_io_xx
    " / "
    VALUE
    0x8006C48E
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_toff_io_xx
    " / "
    VALUE
    0x8006C490
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_tini_stac_xx
    " / "
    VALUE
    0x8006C492
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_ton_stac_xx
    " / "
    VALUE
    0x8006C494
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_toff_stac_xx
    " / "
    VALUE
    0x8006C496
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_dcycon_io_xx
    " / "
    VALUE
    0x8006C498
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_dcycoff_io_xx
    " / "
    VALUE
    0x8006C49A
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_dcycon_stac_xx
    " / "
    VALUE
    0x8006C49C
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_dcycoff_stac_xx
    " / "
    VALUE
    0x8006C49E
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_22.Cxx_tac_nc_io_xx
    " / "
    VALUE
    0x8006C4A0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_tini_io_xx
    " / "
    VALUE
    0x8006C4A2
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_ton_io_xx
    " / "
    VALUE
    0x8006C4A4
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_toff_io_xx
    " / "
    VALUE
    0x8006C4A6
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_tini_stac_xx
    " / "
    VALUE
    0x8006C4A8
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_ton_stac_xx
    " / "
    VALUE
    0x8006C4AA
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_toff_stac_xx
    " / "
    VALUE
    0x8006C4AC
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_dcycon_io_xx
    " / "
    VALUE
    0x8006C4AE
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_dcycoff_io_xx
    " / "
    VALUE
    0x8006C4B0
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_dcycon_stac_xx
    " / "
    VALUE
    0x8006C4B2
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_dcycoff_stac_xx
    " / "
    VALUE
    0x8006C4B4
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Tac_cal_set_rb_23.Cxx_tac_nc_io_xx
    " / "
    VALUE
    0x8006C4B6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_ATS.LimitTypeMsk_C
    "Actuator test ThrVlv_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BDF8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_ATS.CnvNorm_C
    "Actuator test ThrVlv_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BDF9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_ATS.LowLim_C
    "Actuator test ThrVlv_ATS / Lower limit for monitoring"
    VALUE
    0x8006BDFA
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_ATS.UpLim_C
    "Actuator test ThrVlv_ATS / Upper limit for monitoring"
    VALUE
    0x8006BDFC
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_ATS.CnvFac_C
    "Actuator test ThrVlv_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BE00
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_ATS.CnvOfs_C
    "Actuator test ThrVlv_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BE04
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_ATS.DfltVal_C
    "Actuator test ThrVlv_ATS / Default value for standbytest"
    VALUE
    0x8006BE06
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_facCorStrt_C
    "compensation correction factor during engine START state"
    VALUE
    0x80073000
    Val_Ws16
    2.999878
    Fact
    1.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_HBrgPar.rTstDtyCyc_C
    " / Test Duty cycle in case of ShCirBatt1 / ShCirBatt2 / ShCirGnd1 / ShCirGnd2 / ShCirOvrLd errors."
    VALUE
    0x80073002
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_HBrgPar.tiDisblDiaTmpDef_C
    " / Diagnosis disable time in case of temporary error /heal of ShCirBatt1 / ShCirBatt2 / ShCirGnd1 / ShCirGnd2 / ShCirOvrLd / OvrTemp error."
    VALUE
    0x80073004
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_HBrgPar.tiDisblDiaPermDef_C
    " / Diagnosis disable time in case of permanent ShCirBatt1 / ShCirBatt2 / ShCirGnd1 / ShCirGnd2 / ShCirOvrLd / OvrTemp errors."
    VALUE
    0x80073006
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_HBrgPar.tiOpnLdDiaEna_C
    " / Open load diagnosis enable time"
    VALUE
    0x80073008
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_HBrgPar.tiMaxOpnLdDiaEna_C
    " / Maximum open load diagnosis enable time"
    VALUE
    0x8007300A
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_HBrgPar.rDtyCycPlausShCirGnd_C
    " / Duty cycle during plausibility test due to permanent ShCirGnd1/ShCirGnd2 error."
    VALUE
    0x8007300C
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_HBrgPar.rDtyCycPlausShCirBatt_C
    " / Duty cycle during plausibility test due to permanent ShCirBatt1/ShCirBatt2 error"
    VALUE
    0x8007300E
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_Pwm.tiPer_C
    "PWM out parameter structure / Reference value for period duration (small type to limit dynamic range)"
    VALUE
    0x80073010
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_Pwm.stLvl_C
    "PWM out parameter structure / Reference value for phase relationship in period units"
    VALUE
    0x80073012
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_Pwm.rMaxDty_C
    "PWM out parameter structure / Reference value for maximum duty cycle"
    VALUE
    0x80073014
    Kw_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_Pwm.rPerUn_C
    "PWM out parameter structure / us per Pwmout_tiPeriod unit (1==us, 1000=ms)"
    VALUE
    0x80073016
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_Pwm.tiPh_C
    "PWM out parameter structure / Active level (0 or 1)"
    VALUE
    0x80073018
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_PwmOut.rMin_C
    "Devlib diagnosis parameter structure / Minimum threshold for the duty cycle"
    VALUE
    0x8007301A
    Kw_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_PwmOut.rMax_C
    "Devlib diagnosis parameter structure / Maximum threshold for the duty cycle"
    VALUE
    0x8007301C
    Kw_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_PwmOut.tiBtwTstSCB_C
    "Devlib diagnosis parameter structure / Time between tests for SCB error"
    VALUE
    0x8007301E
    Kw_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_PwmOut.tiBtwTstOT_C
    "Devlib diagnosis parameter structure / Time between tests for OT error"
    VALUE
    0x80073020
    Kw_Ws16
    655.3500
    Time_s
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_PwmOut.numTstMax_C
    "Devlib diagnosis parameter structure / Maximum number of tests allowed on permanent defect"
    VALUE
    0x80073022
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_PwmOut.swtBattCor_C
    "Devlib diagnosis parameter structure / Switch to enable battery correction"
    VALUE
    0x80073024
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_PwmOut.swtPsInv_C
    "Devlib diagnosis parameter structure / Power stage output inversion status"
    VALUE
    0x80073025
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_rActOpnLim_C
    "Actual position limit to be checked after ECU init to keep the chip enabled."
    VALUE
    0x80073026
    Val_Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_rAct_C
    ""
    VALUE
    0x80072F08
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_rCnv_CUR
    "Curve for set point to dutycycle conversion for single flow implementation"
    CURVE
    0x80073028
    Cur_Xs16Ws16
    200.0000
    DtyCyc
    -100.0000
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ThrVlv_rTVA
        Prc
        25
        -100.0000
        100.0000

        FORMAT "%8.4"
        EXTENDED_LIMITS -400.0000 399.9878
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_rPwrStgDis_C
    "Actuator shut-off duty cycle"
    VALUE
    0x8007308E
    Val_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_stChpEnaIniReq_C
    ""
    VALUE
    0x80073090
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_stPwrStgDiaDis_C
    "Mask to disable powerstage diagnosis"
    VALUE
    0x80073091
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_stPwrStgDis_C
    "Mask to disable powerstage actuation under different conditions"
    VALUE
    0x80073092
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_swtChpSel_C
    "Number of chip select signal for H-bridge IC E"
    VALUE
    0x80073093
    Val_Wu8
    3.00000000000
    DevLib_HBrgChpSel
    0.00
    3.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 3.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_swtHwSel_C
    ""
    VALUE
    0x80073094
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_swtOpnLdDiaStrt_C
    "Enable Open Load diagnostics at ECU start up"
    VALUE
    0x80073095
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_swtSelOvrCurrErr_C
    "Switch to select over-current error detection"
    VALUE
    0x80073096
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_tiBattCorFacFlt_C
    ""
    VALUE
    0x80073098
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_tiChpEnaIni_C
    ""
    VALUE
    0x8007309C
    Val_Ws16
    20000.00
    Time_ms
    0.00
    20000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ThrVlv_tiVlvOpn_C
    ""
    VALUE
    0x8007309E
    Val_Ws16
    20000.00
    Time_ms
    0.00
    20000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TORQUE_AT_CANHS_RNr_01_CA
    "TORQUE_AT_CANHS_RNr_01_Msg data calibration"
    VAL_BLK
    0x8006CEBA
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TORQUE_AT_CANHS_RNr_02_CA
    "TORQUE_AT_CANHS_RNr_02_Msg data calibration"
    VAL_BLK
    0x8006CEC2
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbChPmp_frqInactvThres_C
    ""
    VALUE
    0x800730A0
    Kw_Wu16
    655.3500
    TRBCHPMP_FRQ
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbChPmp_frqSCGHiThres_C
    ""
    VALUE
    0x800730A2
    Kw_Wu16
    655.3500
    TRBCHPMP_FRQ
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbChPmp_frqSCGLoThres_C
    ""
    VALUE
    0x800730A4
    Kw_Wu16
    655.3500
    TRBCHPMP_FRQ
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbChPmp_stPsDiaDisbl_C
    ""
    VALUE
    0x800730A6
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbChPmp_stPsDisbl_C
    ""
    VALUE
    0x800730A7
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbChPmp_tiTurnOffDly_C
    ""
    VALUE
    0x800730A8
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbChPmp_tiTurnOnDly_C
    ""
    VALUE
    0x800730AA
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_ATS.LimitTypeMsk_C
    "Actuator test TrbCh_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BE08
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_ATS.CnvNorm_C
    "Actuator test TrbCh_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BE09
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_ATS.LowLim_C
    "Actuator test TrbCh_ATS / Lower limit for monitoring"
    VALUE
    0x8006BE0A
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_ATS.UpLim_C
    "Actuator test TrbCh_ATS / Upper limit for monitoring"
    VALUE
    0x8006BE0C
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_ATS.CnvFac_C
    "Actuator test TrbCh_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BE10
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_ATS.CnvOfs_C
    "Actuator test TrbCh_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BE14
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_ATS.DfltVal_C
    "Actuator test TrbCh_ATS / Default value for standbytest"
    VALUE
    0x8006BE16
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_Pwm.tiPer_C
    "Structure containing calibration and conversion data types for turbocharger actuator / Reference value for period duration (small type to limit dynamic range)"
    VALUE
    0x800730AC
    Kw_Ws16
    9.900000
    Period
    0.1000000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_Pwm.stLvl_C
    "Structure containing calibration and conversion data types for turbocharger actuator / Reference value for phase relationship in period units"
    VALUE
    0x800730AE
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_Pwm.rMaxDty_C
    "Structure containing calibration and conversion data types for turbocharger actuator / Reference value for maximum duty cycle"
    VALUE
    0x800730B0
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_Pwm.rPerUn_C
    "Structure containing calibration and conversion data types for turbocharger actuator / us per Pwmout_tiPeriod unit (1==us, 1000=ms)"
    VALUE
    0x800730B2
    Kw_Ws16
    3276.700
    Period
    0.00
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_Pwm.tiPh_C
    "Structure containing calibration and conversion data types for turbocharger actuator / Active level (0 or 1)"
    VALUE
    0x800730B4
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_PwmOut.rMin_C
    "Structure containing parameters for PWM output power stage error handling for turbocharger actuator / Minimum threshold for the duty cycle"
    VALUE
    0x800730B6
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_PwmOut.rMax_C
    "Structure containing parameters for PWM output power stage error handling for turbocharger actuator / Maximum threshold for the duty cycle"
    VALUE
    0x800730B8
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_PwmOut.tiBtwTstSCB_C
    "Structure containing parameters for PWM output power stage error handling for turbocharger actuator / Time between tests for SCB error"
    VALUE
    0x800730BA
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_PwmOut.tiBtwTstOT_C
    "Structure containing parameters for PWM output power stage error handling for turbocharger actuator / Time between tests for OT error"
    VALUE
    0x800730BC
    Kw_Ws16
    1000.000
    Time_s
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_PwmOut.numTstMax_C
    "Structure containing parameters for PWM output power stage error handling for turbocharger actuator / Maximum number of tests allowed on permanent defect"
    VALUE
    0x800730BE
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_PwmOut.swtBattCor_C
    "Structure containing parameters for PWM output power stage error handling for turbocharger actuator / Switch to enable battery correction"
    VALUE
    0x800730C0
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_PwmOut.swtPsInv_C
    "Structure containing parameters for PWM output power stage error handling for turbocharger actuator / Power stage output inversion status"
    VALUE
    0x800730C1
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_rCnv_CUR
    "Transformation curve to convert the input set-point to duty cycle"
    CURVE
    0x800730C2
    Cur_Xs16Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        TrbCh_r
        Prc
        25
        -400.0000
        399.9878

        FORMAT "%8.4"
        EXTENDED_LIMITS -400.0000 399.9878
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_stPsDiaDisbl_C
    "Application parameter to disable diagnosis of power stage for turbocharger actuator under certain battery and engine conditions"
    VALUE
    0x80073128
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrbCh_stPsDisbl_C
    "Application parameter to disable power stage for turbocharger actuator under certain battery and engine conditions"
    VALUE
    0x80073129
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TrqInrCtl_r_C
    ""
    VALUE
    0x80072F0A
    Val_Ws16
    655.5000
    Prc_Fact100
    -327.8000
    327.7000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    USM_CANHS_RNr_01_CA
    "USM_CANHS_RNr_01_Msg data calibration"
    VAL_BLK
    0x8006CEC9
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 5

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl0_ATS.LimitTypeMsk_C
    "Actuator test WaHtEl0_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BE18
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl0_ATS.CnvNorm_C
    "Actuator test WaHtEl0_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BE19
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl0_ATS.LowLim_C
    "Actuator test WaHtEl0_ATS / Lower limit for monitoring"
    VALUE
    0x8006BE1A
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl0_ATS.UpLim_C
    "Actuator test WaHtEl0_ATS / Upper limit for monitoring"
    VALUE
    0x8006BE1C
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl0_ATS.CnvFac_C
    "Actuator test WaHtEl0_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BE20
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl0_ATS.CnvOfs_C
    "Actuator test WaHtEl0_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BE24
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl0_ATS.DfltVal_C
    "Actuator test WaHtEl0_ATS / Default value for standbytest"
    VALUE
    0x8006BE26
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl1_ATS.LimitTypeMsk_C
    "Actuator test WaHtEl1_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BE28
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl1_ATS.CnvNorm_C
    "Actuator test WaHtEl1_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BE29
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl1_ATS.LowLim_C
    "Actuator test WaHtEl1_ATS / Lower limit for monitoring"
    VALUE
    0x8006BE2A
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl1_ATS.UpLim_C
    "Actuator test WaHtEl1_ATS / Upper limit for monitoring"
    VALUE
    0x8006BE2C
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl1_ATS.CnvFac_C
    "Actuator test WaHtEl1_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BE30
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl1_ATS.CnvOfs_C
    "Actuator test WaHtEl1_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BE34
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl1_ATS.DfltVal_C
    "Actuator test WaHtEl1_ATS / Default value for standbytest"
    VALUE
    0x8006BE36
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl2_ATS.LimitTypeMsk_C
    " / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BE38
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl2_ATS.CnvNorm_C
    " / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BE39
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl2_ATS.LowLim_C
    " / Lower limit for monitoring"
    VALUE
    0x8006BE3A
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl2_ATS.UpLim_C
    " / Upper limit for monitoring"
    VALUE
    0x8006BE3C
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl2_ATS.CnvFac_C
    " / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BE40
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl2_ATS.CnvOfs_C
    " / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BE44
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl2_ATS.DfltVal_C
    " / Default value for standbytest"
    VALUE
    0x8006BE46
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl_DigOut.tiBtwTstSCB_C
    "Structure containing parameters for Digital output power stage error handling of electrical water heater actuator / Time between tests for SCB error"
    VALUE
    0x8006BE78
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl_DigOut.tiBtwTstOT_C
    "Structure containing parameters for Digital output power stage error handling of electrical water heater actuator / Time between tests for OT error"
    VALUE
    0x8006BE7A
    Kw_Ws16
    20.00000
    Time_s
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl_DigOut.numTstMax_C
    "Structure containing parameters for Digital output power stage error handling of electrical water heater actuator / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006BE7C
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl_stPsDiaDisbl_CA
    "Application parameter to Enable diagnosis of Water Heater power stage"
    VAL_BLK
    0x8006BE7E
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaHtEl_stPsDisbl_CA
    "Application parameter to check if all conditions are met for enabling Water Heater"
    VAL_BLK
    0x8006BE81
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dBPFacFBCG3_GMAP
    "FBC bandpass parameter for ZFC in 3rd gear"
    MAP
    0x80073170
    MapG_Ws16
    60.00000
    ZFC_BPfac
    0.00
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -60.00183 60.00000
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dBPFacFBCG4_GMAP
    "FBC bandpass parameter for ZFC in 4th gear"
    MAP
    0x8007319A
    MapG_Ws16
    60.00000
    ZFC_BPfac
    0.00
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -60.00183 60.00000
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dBPFacFBCG5_GMAP
    "FBC bandpass parameter for ZFC in 5th gear"
    MAP
    0x800731C4
    MapG_Ws16
    60.00000
    ZFC_BPfac
    0.00
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -60.00183 60.00000
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dBPFacFBCG6_GMAP
    "FBC bandpass parameter for ZFC in 6th gear"
    MAP
    0x800731EE
    MapG_Ws16
    60.00000
    ZFC_BPfac
    0.00
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -60.00183 60.00000
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dBPFacFBCG7_GMAP
    "FBC bandpass parameter for ZFC in 7th gear"
    MAP
    0x80073218
    MapG_Ws16
    60.00000
    ZFC_BPfac
    0.00
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -60.00183 60.00000
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dSegFBCCaSG3_GMAP
    "FBC segment choice parameter for ZFC in 3rd gear"
    MAP
    0x80073242
    MapG_Ws16
    255.9922
    ZFC_PerHalfRatio
    0.00
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dSegFBCCaSG4_GMAP
    "FBC segment choice parameter for ZFC in 4th gear"
    MAP
    0x8007326C
    MapG_Ws16
    255.9922
    ZFC_PerHalfRatio
    0.00
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dSegFBCCaSG5_GMAP
    "FBC segment choice parameter for ZFC in 5th gear"
    MAP
    0x80073296
    MapG_Ws16
    255.9922
    ZFC_PerHalfRatio
    0.00
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dSegFBCCaSG6_GMAP
    "FBC segment choice parameter for ZFC in 6th gear"
    MAP
    0x800732C0
    MapG_Ws16
    255.9922
    ZFC_PerHalfRatio
    0.00
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_dSegFBCCaSG7_GMAP
    "FBC segment choice parameter for ZFC in 7th gear"
    MAP
    0x800732EA
    MapG_Ws16
    255.9922
    ZFC_PerHalfRatio
    0.00
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        7
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF ZFC_nFBCVal_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        ZFC_idxFBCElm_mp
        OneToOne
        3
        0.00
        4.000

        FORMAT "%5.3"
        EXTENDED_LIMITS 0.00 255.0

        AXIS_PTS_REF ZFC_idxFBCVal_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_idxFBCElm_C
    "Index of FBC parameter for operation point in map"
    VALUE
    0x80073314
    Val_Wu8
    4.000
    OneToOne
    0.00
    4.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin AXIS_PTS

    ZFC_idxFBCVal_AXIS
    ""
    0x80073315
    ZFC_idxFBCElm_mp
    Axis_Xu8
    4.000
    OneToOne
    3
    0.00
    4.000

    
    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin CHARACTERISTIC

    ZFC_nAvrgMax_C
    "Maximum engine speed for zero fuel calibration"
    VALUE
    0x8007331A
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_nAvrgMin_C
    "Minimum engine speed for zero fuel calibration"
    VALUE
    0x8007331C
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_nChngPRailMax_C
    "Maximum engine speed at which a rail pressure request is made for zero quantity calibration"
    VALUE
    0x8007331E
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_nFBCThresMax_C
    "Maximal engine speed for FBC if ZFC activ"
    VALUE
    0x80073320
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin AXIS_PTS

    ZFC_nFBCVal_AXIS
    ""
    0x80073322
    Epm_nEng
    Axis_Xs16
    9980.000
    EngN
    7
    20.00000
    10000.00

    
    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin CHARACTERISTIC

    ZFC_nHyst_C
    "Hysteresis value of engine speed for zero fuel calibration"
    VALUE
    0x80073332
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_numPCLLSU_CA
    "Appointment LSU to cylinder for PCL"
    VAL_BLK
    0x80073334
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_pACMax_C
    "Maximal pressure of air conditioning for ZFC"
    VALUE
    0x8007333A
    Val_Ws16
    1000.000
    PresAC_hPa
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -65536.00 65534.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_pBstMin_C
    "Minimal boost pressure for ZFC calibration"
    VALUE
    0x8007333C
    Val_Ws16
    3000.000
    Pres_hPa
    0.00
    3000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_phiSet_CUR
    "Start of energizing for zero fuel calibration injection"
    CURVE
    0x8007335C
    Cur_Xs16Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        20.00000
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_rAccPedMax_C
    "Maximum accelerator position for the ZFC calibration"
    VALUE
    0x8007333E
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_rPCLBnk_C
    "Air flow factor for splitted exhaust gas systems"
    VALUE
    0x80073358
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_stACSel_C
    "Selection of air condition limitations for ZFC"
    VALUE
    0x80073340
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_stClthSel_C
    "Bit mask for releasing the clutch signal for the calibration"
    VALUE
    0x80073341
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_stGearRls_CA
    "Gear based release of ZFC"
    VAL_BLK
    0x80073342
    ValA_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_swtPCLActv_C
    "Switch to enable the PCL"
    VALUE
    0x80073349
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_swtPCLQnt_C
    "Switch to use volume instead of quantity for the PCL"
    VALUE
    0x8007335A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_tAirThres_C
    "Minimum intake air temperature for zero fuel calibration"
    VALUE
    0x8007334A
    Val_Ws16
    250.0000
    Temp_Cels
    -50.14000
    199.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_tEngThres_C
    "Minimum engine temperature for zero fuel calibration"
    VALUE
    0x8007334C
    Val_Ws16
    250.0000
    Temp_Cels
    -50.14000
    199.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_tFuelThresMax_C
    "Maximum fuel temperature for zero fuel calibration"
    VALUE
    0x8007334E
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_tFuelThresMin_C
    "Minimum fuel temperature for zero fuel calibration"
    VALUE
    0x80073350
    Val_Ws16
    200.0000
    Temp_Cels
    -50.14000
    149.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_tiCldCham_CUR
    "Time until combustion chamber has cooled off too much for ZFC"
    CURVE
    0x8007313C
    Cur_Xs16Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Air_tCACDs
        Temp_Cels
        12
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_tiDelOvrRun_C
    "Delay after introducing the overrun phase for zero fuel calibration"
    VALUE
    0x80073352
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_tiDelpRailLim_C
    "Delay for rail pressure stabilisation for zero fuel calibration"
    VALUE
    0x80073354
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_tiHotCham_C
    "Time until the combustion chamber is warm enough for ZFC"
    VALUE
    0x8007316E
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ZFC_uBattMin_C
    "Minimum battery voltage for zero fuel calibration"
    VALUE
    0x80073356
    Val_Ws16
    655340.0
    Volt_Batt
    0.00
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

  /begin MEASUREMENT DFC_AFSOffsDrftMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AFSOffsDrftMax_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AFSOffsDrftMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AFSOffsDrftMin_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AFSSRCCorMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AFSSRCCorMax_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AFSSRCCorMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AFSSRCCorMin_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AFSSRCRawMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AFSSRCRawMax_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AFSSRCRawMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AFSSRCRawMin_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AdcIADC0Cal_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AdcIADC0Cal_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AdcIADC0Conv_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AdcIADC0Conv_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AirCCmprOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AirCCmprOL_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AirCCmprRedTrqOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AirCCmprRedTrqOL_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AirCCmprRedTrqSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AirCCmprRedTrqSCB_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AirCCmprRedTrqSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AirCCmprRedTrqSCG_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AirCCmprSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AirCCmprSCB_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_AirCCmprSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_AirCCmprSCG_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_Cy320SpiCom_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_Cy320SpiCom_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_DSMDummy_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_DSMDummy_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_DevLibBattUHi_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_DevLibBattUHi_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_DevLibBattULo_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_DevLibBattULo_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ECBVlvOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ECBVlvOL_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ECBVlvOvrTemp_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ECBVlvOvrTemp_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ECBVlvSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ECBVlvSCB_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ECBVlvSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ECBVlvSCG_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EEPEraseErr_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EEPEraseErr_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EEPRdErr_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EEPRdErr_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EEPWrErr_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EEPWrErr_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRCPmpOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRCPmpOL_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRCPmpSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRCPmpSCB_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRCPmpSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRCPmpSCG_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgOpnLd_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgOpnLd_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgOvrCurr_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgOvrCurr_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgOvrTemp_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgOvrTemp_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgShCirBatt1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgShCirBatt1_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgShCirBatt2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgShCirBatt2_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgShCirGnd1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgShCirGnd1_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgShCirGnd2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgShCirGnd2_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgShCirOvrLd_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgShCirOvrLd_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgTempOvrCurr_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgTempOvrCurr_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvHBrgUndrVltg_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvHBrgUndrVltg_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvOL_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvOvrTemp_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvOvrTemp_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvSCB_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EGRVlvSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EGRVlvSCG_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMax_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMax_0_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMax_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMax_1_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMax_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMax_2_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMax_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMax_3_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMax_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMax_4_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMax_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMax_5_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMin_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMin_0_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMin_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMin_1_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMin_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMin_2_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMin_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMin_3_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMin_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMin_4_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ETClbETFltMin_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ETClbETFltMin_5_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EpmCaSI1ErrSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EpmCaSI1ErrSig_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EpmCaSI1NoSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EpmCaSI1NoSig_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EpmCaSI1OfsErr_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EpmCaSI1OfsErr_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EpmCrSErrSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EpmCrSErrSig_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_EpmCrSNoSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_EpmCrSNoSig_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_FMAErrModMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_FMAErrModMax_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_FMAErrModMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_FMAErrModMin_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_FlSysTnkLo_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_FlSysTnkLo_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_FuelTSRCMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_FuelTSRCMax_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_FuelTSRCMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_FuelTSRCMin_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgLVSOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgLVSOL_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgLVSOvrTemp_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgLVSOvrTemp_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgLVSSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgLVSSCB_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgLVSSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgLVSSCG_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgOL_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgOvrTemp_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgOvrTemp_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgPLUGErrHi_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgPLUGErrHi_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgPLUGErrLo_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgPLUGErrLo_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgPLUGErrNPL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgPLUGErrNPL_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgSCB_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_GlwPlgSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_GlwPlgSCG_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_HCInjOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_HCInjOL_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_HCInjSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_HCInjSCB_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_HCInjSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_HCInjSCG_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_HCVlvOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_HCVlvOL_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_HCVlvSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_HCVlvSCB_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_HCVlvSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_HCVlvSCG_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMax_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMax_0_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMax_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMax_1_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMax_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMax_2_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMax_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMax_3_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMax_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMax_4_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMax_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMax_5_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMax_6_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMax_6_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMax_7_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMax_7_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMin_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMin_0_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMin_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMin_1_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMin_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMin_2_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMin_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMin_3_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMin_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMin_4_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMin_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMin_5_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMin_6_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMin_6_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgMin_7_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgMin_7_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgPlaus_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgPlaus_0_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgPlaus_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgPlaus_1_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgPlaus_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgPlaus_2_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgPlaus_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgPlaus_3_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgPlaus_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgPlaus_4_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgPlaus_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgPlaus_5_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgPlaus_6_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgPlaus_6_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrEnrgPlaus_7_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrEnrgPlaus_7_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrUChSRCMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrUChSRCMax_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrUChSRCMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrUChSRCMin_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrVltgSRCMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrVltgSRCMax_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVActrVltgSRCMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVActrVltgSRCMin_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjDiaIVAdj_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjDiaIVAdj_0_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjDiaIVAdj_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjDiaIVAdj_1_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjDiaIVAdj_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjDiaIVAdj_2_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjDiaIVAdj_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjDiaIVAdj_3_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjDiaIVAdj_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjDiaIVAdj_4_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjDiaIVAdj_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjDiaIVAdj_5_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjIVA_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjIVA_0_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjIVA_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjIVA_1_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjIVA_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjIVA_2_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjIVA_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjIVA_3_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjIVA_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjIVA_4_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVAdjIVA_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVAdjIVA_5_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlTiDiff_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlTiDiff_0_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlTiDiff_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlTiDiff_1_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlTiDiff_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlTiDiff_2_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlTiDiff_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlTiDiff_3_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlTiDiff_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlTiDiff_4_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlTiDiff_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlTiDiff_5_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUDiffUp_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUDiffUp_0_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUDiffUp_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUDiffUp_1_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUDiffUp_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUDiffUp_2_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUDiffUp_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUDiffUp_3_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUDiffUp_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUDiffUp_4_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUDiffUp_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUDiffUp_5_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUUp_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUUp_0_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUUp_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUUp_1_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUUp_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUUp_2_Raw
         ECU_ADDRESS 0xD0004394
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUUp_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUUp_3_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUUp_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUUp_4_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVCtlUUp_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVCtlUUp_5_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaBnkShCir_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaBnkShCir_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaBnkShCirChSwt_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaBnkShCirChSwt_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaChp_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaChp_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoCls_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoCls_0_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoCls_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoCls_1_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoCls_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoCls_2_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoCls_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoCls_3_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoCls_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoCls_4_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoCls_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoCls_5_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoLd_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoLd_0_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoLd_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoLd_1_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoLd_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoLd_2_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoLd_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoLd_3_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoLd_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoLd_4_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylNoLd_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylNoLd_5_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirHSLS_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirHSLS_0_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirHSLS_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirHSLS_1_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirHSLS_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirHSLS_2_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirHSLS_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirHSLS_3_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirHSLS_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirHSLS_4_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirHSLS_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirHSLS_5_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirMeas_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirMeas_0_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirMeas_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirMeas_1_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirMeas_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirMeas_2_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirMeas_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirMeas_3_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirMeas_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirMeas_4_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCirMeas_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCirMeas_5_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCir_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCir_0_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCir_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCir_1_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCir_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCir_2_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCir_3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCir_3_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCir_4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCir_4_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVDiaCylShCir_5_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVDiaCylShCir_5_Raw
         ECU_ADDRESS 0xD0004398
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVPSplyDCDCOff_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVPSplyDCDCOff_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_IVPSplyStopDCDC_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_IVPSplyStopDCDC_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_InjVlvPresMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_InjVlvPresMin_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUCircNernstSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUCircNernstSig_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUCircPmpCurSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUCircPmpCurSig_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUCircVirtGndSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUCircVirtGndSig_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUDynChk_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUDynChk_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUDynChkDIUMPR_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUDynChkDIUMPR_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUHtCoupSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUHtCoupSig_Raw
         ECU_ADDRESS 0xD0004384
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUHtrMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUHtrMax_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUHtrMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUHtrMin_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUHtrNpl_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUHtrNpl_Raw
         ECU_ADDRESS 0xD0004388
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUHtrSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUHtrSig_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2ClbMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2ClbMax_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2ClbMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2ClbMin_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2Max_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2Max_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2Min_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2Min_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2PlausMaxFLd_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2PlausMaxFLd_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2PlausMaxOvrRun_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2PlausMaxOvrRun_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2PlausMaxPartLd_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2PlausMaxPartLd_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2PlausMinFLd_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2PlausMinFLd_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2PlausMinOvrRun_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2PlausMinOvrRun_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUO2PlausMinPartLd_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUO2PlausMinPartLd_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUPresCompMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUPresCompMax_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUPresCompMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUPresCompMin_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSURiClbMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSURiClbMax_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSURiClbMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSURiClbMin_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUSPIBattLowMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUSPIBattLowMin_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUSPISig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUSPISig_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUTempCompMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUTempCompMax_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUTempCompMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUTempCompMin_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUWireIPSig_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUWireIPSig_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUWireSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUWireSCB_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUWireSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUWireSCG_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUtExcMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUtExcMax_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_LSUtExcMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_LSUtExcMin_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MRlyErlyOpng_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MRlyErlyOpng_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MRlyStk_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MRlyStk_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MeUnOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MeUnOL_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MeUnOT_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MeUnOT_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MeUnSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MeUnSCB_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MeUnSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MeUnSCG_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MeUnSRCMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MeUnSRCMax_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MeUnSRCMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MeUnSRCMin_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCADCNTP_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCADCNTP_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCADCTst_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCADCTst_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCADCVltgRatio_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCADCVltgRatio_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCComErrCnt_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCComErrCnt_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCComSPI_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCComSPI_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCROMErrXPg_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCROMErrXPg_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPErrMMRespByte_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPErrMMRespByte_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPErrNoChk_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPErrNoChk_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPErrRespTime_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPErrRespTime_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPErrSPI_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPErrSPI_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPHwNoRdy_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPHwNoRdy_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPLoLi_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPLoLi_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPMM_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPMM_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPOSTimeOut_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPOSTimeOut_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPPSIniTimeOut_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPPSIniTimeOut_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPTimeOut_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPTimeOut_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoCSOPUpLi_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoCSOPUpLi_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoFESpd_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoFESpd_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MoFRailP_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MoFRailP_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MonUMaxSupply1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MonUMaxSupply1_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_MonUMinSupply1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_MonUMinSupply1_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_PCVNoStrt_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_PCVNoStrt_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_PCVOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_PCVOL_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_PCVOT_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_PCVOT_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_PCVSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_PCVSCB_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_PCVSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_PCVSCG_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_PCVSRCMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_PCVSRCMax_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_PCVSRCMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_PCVSRCMin_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_PCVfacAdaptMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_PCVfacAdaptMax_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_PCVfacAdaptMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_PCVfacAdaptMin_Raw
         ECU_ADDRESS 0xD00043A0
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_R2S2_MscComm1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_R2S2_MscComm1_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailCPC1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailCPC1_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailCPC3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailCPC3_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailCPC4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailCPC4_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailMeUn0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailMeUn0_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailMeUn1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailMeUn1_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailMeUn2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailMeUn2_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailMeUn3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailMeUn3_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailMeUn4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailMeUn4_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPCV0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPCV0_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPCV1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPCV1_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPCV2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPCV2_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPCV3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPCV3_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPCV4_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPCV4_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPGradMon_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPGradMon_Raw
         ECU_ADDRESS 0xD000439C
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPOfsTstMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPOfsTstMax_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPOfsTstMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPOfsTstMin_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPSRCMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPSRCMax_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_RailPSRCMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_RailPSRCMin_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_SSpMon1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_SSpMon1_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_SSpMon2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_SSpMon2_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_SSpMon3_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_SSpMon3_Raw
         ECU_ADDRESS 0xD0004380
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_SWReset_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_SWReset_0_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_SWReset_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_SWReset_1_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_SWReset_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_SWReset_2_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_StopCntTmr_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_StopCntTmr_Raw
         ECU_ADDRESS 0xD00043A4
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_TEGRClrDsSRCMax_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_TEGRClrDsSRCMax_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_TEGRClrDsSRCMin_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_TEGRClrDsSRCMin_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgOpnLd_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgOpnLd_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgOvrCurr_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgOvrCurr_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgOvrTemp_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgOvrTemp_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgShCirBatt1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgShCirBatt1_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgShCirBatt2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgShCirBatt2_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgShCirGnd1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgShCirGnd1_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgShCirGnd2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgShCirGnd2_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgShCirOvrLd_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgShCirOvrLd_Raw
         ECU_ADDRESS 0xD000438C
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgTempOvrCurr_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgTempOvrCurr_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvHBrgUndrVltg_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvHBrgUndrVltg_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvOL_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvOvrTemp_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvOvrTemp_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvSCB_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_ThrVlvSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_ThrVlvSCG_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_TrbChOL_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_TrbChOL_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_TrbChSCB_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_TrbChSCB_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_TrbChSCG_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_TrbChSCG_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElOL_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElOL_0_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElOL_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElOL_1_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElOL_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElOL_2_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElOvrTemp_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElOvrTemp_0_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElOvrTemp_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElOvrTemp_1_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElOvrTemp_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElOvrTemp_2_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElSCB_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElSCB_0_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElSCB_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElSCB_1_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElSCB_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElSCB_2_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElSCG_0_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElSCG_0_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElSCG_1_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElSCG_1_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT DFC_WaHtElSCG_2_Raw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER DFC_WaHtElSCG_2_Raw
         ECU_ADDRESS 0xD0004390
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ecm_inj_bus_mcut
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ecm_inj_bus_mcut
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ff_actr_blk_clos
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ff_actr_blk_clos
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ff_actr_crt_down
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ff_actr_crt_down
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ff_actr_crt_up
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ff_actr_crt_up
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ff_actr_ovh
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ff_actr_ovh
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ff_fct_chr
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ff_fct_chr
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ff_fct_h_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ff_fct_h_lvl
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ff_fct_l_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ff_fct_l_lvl
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ff_fct_neg_err
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ff_fct_neg_err
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_ff_fct_pos_err
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_ff_fct_pos_err
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fprs_actr_blk_open
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fprs_actr_blk_open
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fprs_actr_crt_down
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fprs_actr_crt_down
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fprs_actr_crt_up
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fprs_actr_crt_up
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fprs_actr_ovh
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fprs_actr_ovh
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fprs_fct_chr
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fprs_fct_chr
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fprs_fct_h_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fprs_fct_h_lvl
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fprs_fct_l_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fprs_fct_l_lvl
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fprs_fct_neg_err
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fprs_fct_neg_err
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fprs_fct_pos_err
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fprs_fct_pos_err
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fsys_apl_down
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fsys_apl_down
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fsys_apl_up
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fsys_apl_up
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fsys_h_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fsys_h_lvl
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fuel_temp_h
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fuel_temp_h
         ECU_ADDRESS 0xD0004388 
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_fuel_temp_l
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_fuel_temp_l
         ECU_ADDRESS 0xD0004388 
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_glow_cmd_oc
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_glow_cmd_oc
         ECU_ADDRESS 0xD0004388 
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_glow_cmd_scg
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_glow_cmd_scg
         ECU_ADDRESS 0xD0004388 
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_glow_cmd_scw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_glow_cmd_scw
         ECU_ADDRESS 0xD0004388 
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj1_h_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj1_h_lvl
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj1_h_puls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj1_h_puls
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj1_l_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj1_l_lvl
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj1_l_puls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj1_l_puls
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj1_nok
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj1_nok
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj1_oc
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj1_oc
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj2_h_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj2_h_lvl
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj2_h_puls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj2_h_puls
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj2_l_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj2_l_lvl
         ECU_ADDRESS 0xD000439C 
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj2_l_puls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj2_l_puls
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj2_nok
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj2_nok
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj2_oc
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj2_oc
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj3_h_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj3_h_lvl
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj3_h_puls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj3_h_puls
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj3_l_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj3_l_lvl
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj3_l_puls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj3_l_puls
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj3_nok
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj3_nok
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj3_oc
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj3_oc
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj4_h_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj4_h_lvl
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj4_h_puls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj4_h_puls
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj4_l_lvl
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj4_l_lvl
         ECU_ADDRESS 0xD000439C 
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj4_l_puls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj4_l_puls
         ECU_ADDRESS 0xD0004380 
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj4_nok
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj4_nok
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj4_oc
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj4_oc
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_inj_oor
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_inj_oor
         ECU_ADDRESS 0xD0004398 
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_rail_prs_h
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_rail_prs_h
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_rail_prs_l
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_rail_prs_l
         ECU_ADDRESS 0xD000438C 
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_rail_prs_plaus
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_rail_prs_plaus
         ECU_ADDRESS 0xD00043A4 
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT Vbx_df_rail_prs_sig_mcut
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER Vbx_df_rail_prs_sig_mcut
         ECU_ADDRESS 0xD000439C 
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_AFSPlOffsDrft
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_AFSPlOffsDrft

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_AFSSRC
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_AFSSRC

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_AFSTPer
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_AFSTPer

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_APP1SigPath
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_APP1SigPath

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_APP2SigPath
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_APP2SigPath

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ASModPipe
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ASModPipe

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ASModPipeSlw
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ASModPipeSlw

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ASModPresCalc
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ASModPresCalc

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ASModStrt
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ASModStrt

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ASModSwtOffEng
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ASModSwtOffEng

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ASModTrbn
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ASModTrbn

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_AdcIADC0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_AdcIADC0

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_Cic751Dev1
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_Cic751Dev1

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngNrml2Strt
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngNrml2Strt

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngPthClsEGR
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngPthClsEGR

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngPthClsThr
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngPthClsThr

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngPthCylOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngPthCylOff

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngPthETZr
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngPthETZr

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngPthFlQnt
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngPthFlQnt

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngPthInjVlvOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngPthInjVlvOff

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngPthLpSysOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngPthLpSysOff

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngPthRPMin
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngPthRPMin

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngPthTrqZr
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngPthTrqZr

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoEngSoftShOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoEngSoftShOff

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoordALS
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoordALS

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoordFBC
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoordFBC

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoordTAA
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoordTAA

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_CoordZFC
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_CoordZFC

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_DevLibActrPrt
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_DevLibActrPrt

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_DewDetHtgDel
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_DewDetHtgDel

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_DewDetstSrvTstDem
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_DewDetstSrvTstDem

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EGRVlvJamVlv
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EGRVlvJamVlv

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ETClbCorActv
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ETClbCorActv

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EpmBCr
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EpmBCr

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EpmCaSAdapCaSI1
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EpmCaSAdapCaSI1

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EpmCaSDiag
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EpmCaSDiag

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EpmCaSOfsDiagCaSI1
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EpmCaSOfsDiagCaSI1

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EpmCaSOfsErrCaSI1
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EpmCaSOfsErrCaSI1

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EpmCaSSegCor
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EpmCaSSegCor

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EpmCrSDiag
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EpmCrSDiag

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EpmCrSDiagVeh
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EpmCrSDiagVeh

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_EpmOpMode_InjLock
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_EpmOpMode_InjLock

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FBC
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FBC

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FMALamO2Valid
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FMALamO2Valid

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FMASwtOff1
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FMASwtOff1

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FMASwtOff3
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FMASwtOff3

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FlSysDens
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FlSysDens

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FlSysTnkLoEEP
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FlSysTnkLoEEP

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FlSysTnkLoInfo
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FlSysTnkLoInfo

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FuelTCTS
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FuelTCTS

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FuelTFlSys
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FuelTFlSys

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FuelTFrzVal
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FuelTFrzVal

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FuelTFrzValB1
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FuelTFrzValB1

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_FuelTReplVal
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_FuelTReplVal

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_GlwCtl1
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_GlwCtl1

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_GlwCtl2
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_GlwCtl2

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_GlwCtl3
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_GlwCtl3

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_GlwPlgCod
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_GlwPlgCod

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_GlwPlgGCUTDia
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_GlwPlgGCUTDia

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_IVActrTempRplVal
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_IVActrTempRplVal

         ECU_ADDRESS 0xD0009320
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_IVAdjNVCEna
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_IVAdjNVCEna

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_IVDiaCylOKTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_IVDiaCylOKTst

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_IVDiaTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_IVDiaTst

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_IVPSplyDCDCOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_IVPSplyDCDCOff

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_IVPlausComprTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_IVPlausComprTst

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_IVPlausRunUpTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_IVPlausRunUpTst

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_IVPlausRunUpTstActv
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_IVPlausRunUpTstActv

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InhibitNever
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InhibitNever

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjUnStrtPlsBlk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjUnStrtPlsBlk

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvBnk0ShutOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvBnk0ShutOff

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvCyl0ShutOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvCyl0ShutOff

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvCyl1ShutOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvCyl1ShutOff

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvCyl2ShutOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvCyl2ShutOff

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvCyl3ShutOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvCyl3ShutOff

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvCyl4ShutOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvCyl4ShutOff

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvCyl5ShutOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvCyl5ShutOff

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvPrep
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvPrep

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvPresMin
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvPresMin

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvPresMinRun
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_InjVlvPresMinRun

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_InjVlvPresMinStrt
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
