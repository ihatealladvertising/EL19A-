/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006daa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006daa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006daa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006daa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_thpl_cmd2_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006daa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_thpl_cmd2_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_thpl_cmd3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006db8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dbd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_thpl_cmd3_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_thpl_cmd3_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tqi_cor_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000707c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tqi_cor_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007081 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tqi_cor_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000707e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007080 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007080 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007080 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007080 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_tqi_cor_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007080 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl1_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl1_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl1_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl2_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl2_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl2_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl3_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl3_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl3_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl4_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl4_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006efb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl4_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ef8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006efa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006efa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006efa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006efa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006efa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ede 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ee2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ups_ecu_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_itl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_itl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_itl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ups_ecu_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_oor.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_oor.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_oor.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ups_ecu_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_oor.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_oor.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_oor.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ups_ro2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_slow_trs.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_slow_trs.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070bd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_slow_trs.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ups_ro2_slow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_tip_oor.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_tip_oor.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_tip_oor.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ups_tip_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_uo2_oor.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_uo2_oor.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_uo2_oor.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ups_uo2_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dcf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_oc_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_oc_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_oc_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_vb_rly_oc_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ddb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_vb_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f43 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_vnt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f49 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_vnt_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_vnt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_blk.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007130 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_blk.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007135 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_blk.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007132 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007134 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007134 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007134 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007134 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_wpmp_tcr_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007134 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006efc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f01 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006efe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_wpmp_tcr_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_wpmp_tcr_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f0d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_wpmp_tcr_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f0c 
/end MEASUREMENT
/* Magically created for the RSA 'AXIS_PTS'
 * Of type UBYTE */
/* Rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_Axis_UBYTE
    NO_AXIS_PTS_X 1 UBYTE 
    AXIS_PTS_X 2 UBYTE INDEX_INCR DIRECT 
/end RECORD_LAYOUT
/* Magically created for the RSA 'AXIS_PTS'
 * Of type UWORD */
/* Rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_Axis_UWORD
    NO_AXIS_PTS_X 1 UWORD 
    AXIS_PTS_X 2 UWORD INDEX_INCR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type SWORD
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_CURVE_SWORD
    FNC_VALUES 1 SWORD COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type UBYTE
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_CURVE_UBYTE
    FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type UWORD
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_CURVE_UWORD
    FNC_VALUES 1 UWORD COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type UBYTE
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_MAP_UBYTE
    FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type UWORD
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_MAP_UWORD
    FNC_VALUES 1 UWORD COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type SBYTE
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_VALUE_SBYTE
    FNC_VALUES 1 SBYTE COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type SLONG
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_VALUE_SLONG
    FNC_VALUES 1 SLONG COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type SWORD
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_VALUE_SWORD
    FNC_VALUES 1 SWORD COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type UBYTE
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_VALUE_UBYTE
    FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type ULONG
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_VALUE_ULONG
    FNC_VALUES 1 ULONG COLUMN_DIR DIRECT 
/end RECORD_LAYOUT
/* RSA::SAXHandlerMagically created for the RSA 'CHARACTERISTIC'
 * Of type UWORD
 * See rule from EMS2010_Lib_interp_spec_1-4.doc, chapter 2.3 */
/begin RECORD_LAYOUT
		RSA_RecordLayout_VALUE_UWORD
    FNC_VALUES 1 UWORD COLUMN_DIR DIRECT 
/end RECORD_LAYOUT

/*
 * Insertion of the Customer entries (End)
 *
 *****************************************************************************/

  /end MODULE
/end PROJECT