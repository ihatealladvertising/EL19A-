         DISPLAY_IDENTIFIER FId_InjVlvPresMinStrt

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUAdap0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUAdap0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUClbSched
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUClbSched

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUCmpChk0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUCmpChk0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUCtl0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUCtl0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUDewRls0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUDewRls0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUDynChk0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUDynChk0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUHtCoup0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUHtCoup0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUHtrPS0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUHtrPS0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUIPOpnLdTst0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUIPOpnLdTst0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUIsolChk0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUIsolChk0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSULoBatt0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSULoBatt0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUMon0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUMon0

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUO20
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUO20

         ECU_ADDRESS 0xD0009324
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUO2Clb0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUO2Clb0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUO2SRC0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUO2SRC0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUPlausChk0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUPlausChk0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUPresComp0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUPresComp0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUPresCompAdap0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUPresCompAdap0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSURi0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSURi0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSURiClb0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSURiClb0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUShCir0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUShCir0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUUNVGOpnLdTst0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUUNVGOpnLdTst0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_LSUlsu0
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_LSUlsu0

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_MeUnActrTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_MeUnActrTst

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_MeUnFrzI
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_MeUnFrzI

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_MeUnRot
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_MeUnRot

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_MeUnSetPTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_MeUnSetPTst

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_Name         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_Name
         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_PCVActrTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_PCVActrTst

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_PCVFrzI
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_PCVFrzI

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_PCVNoStrt
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_PCVNoStrt

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_PCVPwrStgTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_PCVPwrStgTst

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_PCVSetPTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_PCVSetPTst

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_QWCCTSDef
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_QWCCTSDef

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_QWCFTSDef
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_QWCFTSDef

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_QWCOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_QWCOff

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailCPCtlMeUnMode
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailCPCtlMeUnMode

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailCPCtlPCVMode
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailCPCtlPCVMode

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailCtlMode
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailCtlMode

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailHpTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailHpTst

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailHpTstActv
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailHpTstActv

         ECU_ADDRESS 0xD000931C
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn0Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn0Blk

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn0Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn0Rls

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn1Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn1Blk

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn1Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn1Rls

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn22Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn22Rls

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn2Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn2Blk

         ECU_ADDRESS 0xD0009328
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn2Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn2Rls

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn3Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn3Blk

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn3Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn3Rls

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn4Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn4Blk

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUn4Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUn4Rls

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000010
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUnClsdShutOff
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUnClsdShutOff

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000020
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUnCtlMode
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUnCtlMode

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000040
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailMeUnCtlUpLim
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailMeUnCtlUpLim

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000080
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV0Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV0Blk

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000100
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV0Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV0Rls

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000200
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV1Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV1Blk

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000400
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV1Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV1Rls

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00000800
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV2Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV2Blk

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00001000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV2Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV2Rls

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00002000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV3Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV3Blk

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00004000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV3Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV3Rls

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00008000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV4Blk
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV4Blk

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00010000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCV4Rls
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCV4Rls

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00020000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCVCtlMode
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCVCtlMode

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00040000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPCVCtlUpLim
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPCVCtlUpLim

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00080000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPSS
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPSS

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00100000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailPSubsVal
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailPSubsVal

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00200000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailSetPointLim
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailSetPointLim

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00400000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailSetPointRed
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailSetPointRed

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x00800000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailSetPointTst
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailSetPointTst

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x01000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_RailTnkLo
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_RailTnkLo

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x02000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_SSTEGRClrDs
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_SSTEGRClrDs

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x04000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_TAA
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_TAA

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x08000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_TEGRClrDsFrzVal
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_TEGRClrDsFrzVal

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x10000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_TEGRClrDsRplVal
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_TEGRClrDsRplVal

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x20000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ThrVlvOpnLd
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ThrVlvOpnLd

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x40000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_TrbChPmp
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_TrbChPmp

         ECU_ADDRESS 0xD000932C
         BIT_MASK 0x80000000
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ZFCClbActv
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ZFCClbActv

         ECU_ADDRESS 0xD0009330
         BIT_MASK 0x00000001
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ZFCCldCmbCham
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ZFCCldCmbCham

         ECU_ADDRESS 0xD0009330
         BIT_MASK 0x00000002
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_ZFCPCLClbActv
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_ZFCPCLClbActv

         ECU_ADDRESS 0xD0009330
         BIT_MASK 0x00000004
         FORMAT "%6.3"
  /end MEASUREMENT

  /begin MEASUREMENT FId_stAVSCoESLSU
         ""
         ULONG
         OneToOne
         1
         2
         0.
         255.
         DISPLAY_IDENTIFIER FId_stAVSCoESLSU

         ECU_ADDRESS 0xD0009330
         BIT_MASK 0x00000008
         FORMAT "%6.3"
  /end MEASUREMENT



/begin MEASUREMENT

    ACCtl_stOut
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000745

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AC_trqMaxAC
    ""
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000034

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_dm
    "The total HFM air mass flow"
    SWORD
    AirMassPerTime
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000036

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_dmSens
    "Sensed air flow signal value"
    SWORD
    AirMassPerTime
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000038

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_mAirPerCyl
    "Air mass per cylinder"
    SWORD
    AirMassPerCyl
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000003A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_qAirmThrSRCHiActv_mp
    "Quantity threshold to release the SRC high test"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001AB0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_stOffsTst
    "Status of offset drift test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000746

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_stPlsOffsDrftTstActv_mp
    "Status whether offset drift test is active or not"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009122

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_stSRCHiTstRls_mp
    "Release status of SRC high test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009123

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_stSRCLoTstRls_mp
    "Release status of SRC low test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009124

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_swtActvAftRun
    "Switch information whether SRC is allowed in AFTERRUN or not"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000747

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_tiCor_mp
    "Corrected air mass"
    SLONG
    Time_PwmHigh
    1
    100
    -107374182.400
    107374182.350

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0xD4001958

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_tiRaw
    "Raw air mass period"
    SLONG
    Time_PwmHigh
    1
    100
    -107374182.400
    107374182.350

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0xD00042C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_tiRawAvrg_mp
    "Average value of air mass period"
    SLONG
    Time_PwmHigh
    1
    100
    -107374182.400
    107374182.350

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0xD400195C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AFS_tiTransfCrvIn_mp
    "Measuring point for input to the AFS curve that converts period to air mass flow"
    SLONG
    Time_PwmHigh
    1
    100
    -107374182.400
    107374182.350

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0xD4001960

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirCtl_stAirCtlBits
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004360

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirCtl_stMon
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000074C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirC_pClnt
    ""
    SWORD
    PresAC_hPa
    1
    100
    -65536.00
    65534.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000074

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirC_rClgDem
    "Desired coolant fan ratio"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000076

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirC_stPsCmpr
    "Final digital output to the powerstage of AC compressor actuator"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000074A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirC_stPsCmprRedTrq
    "Reduce torque instruction to the compressor"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000074B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirC_stPsCmprRedTrq_mp
    "Measuring point for the Reduce torque instruction to the AC compressor before error handling."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009120

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirC_stPsCmpr_mp
    "Measuring point for the digital output to the AC compressor actuator before error handling."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009121

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirC_trqCmprMax
    "Maximum torque consumable by the AC compressor"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000078

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirC_uAnaRawClnt_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B0E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    AirSys_tFld
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD000007C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_pCACDs
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000082

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_pUnFltPCACDs
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000084

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_tAFS
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000086

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_tCACDs
    "charged air temperature down stream"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000088

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_tiRawTAFS
    ""
    SLONG
    Time_Period_HFM6
    1
    100
    -107374.182400
    107374.182350

    
    FORMAT "%13.6"
    
    ECU_ADDRESS 0xD00042CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_tSensTAFS_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AF6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_tSensTEGRClrDs
    "Sensed value of EGR cooler down stream temperature"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000008A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_uRawPCACD
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000008C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_uRawTAFS_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AF8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Air_uRawTEGRClrDs
    "Raw voltage value of EGR cooler down stream temperature"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000008E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    APP_r
    ""
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000003C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    APP_rUnFlt
    ""
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000003E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    APP_uRaw1UnLim_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B08

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    APP_uRaw2UnLim_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B0A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_arPipeSlw_mp
    "Tube surface"
    SWORD
    Area
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_arPipe_mp
    "Tube surface"
    SWORD
    Area
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009222

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_cndHtAirSlw_mp
    "Thermal conductivity of the air"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_cndHtAir_mp
    "Thermal conductivity of the air"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009226

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_cndHtEGSlw_mp
    "Thermal conductivity of the exhaust-gas"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_cndHtEG_mp
    "Thermal conductivity of the exhaust-gas"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD000922A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dmAFSCor
    "Corrected fresh air mass flow"
    SWORD
    AirMassPerTime
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000040

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dmEGFld
    "Field of the exhaust-gas mass flows"
    SWORD
    AirMassPerTime
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0000042

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dmEGMinVal_mp
    ""
    SWORD
    AirMassPerTime
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AB2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dmExhMnfDs
    "Exhaust-gas mass flow downstream of the exhaust manifold"
    SWORD
    AirMassPerTime
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000048

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dtPipeSlw_mp
    "Temperature change, tube"
    SLONG
    Temp_Kelv_Sec
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dtPipe_mp
    "Temperature change, tube"
    SLONG
    Temp_Kelv_Sec
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009230

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dVolEGPipe1_mp
    "Exhaust-gas volume flow for the pressure calculation in the exhaust system"
    SWORD
    AirVolPerTime
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001ACE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dVolEGPipe_mp
    "Exhaust-gas volume flow for the pressure calculation in the exhaust system"
    SLONG
    AirVolPerTime
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009218

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwEGPipeSlw_mp
    "Heat flow between gas and tube wall"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwEGPipe_mp
    "Heat flow between gas and tube wall"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009238

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwPipeEnvSlw_mp
    "Heat flow between tube wall and environment"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwPipeEnv_mp
    "Heat flow between tube wall and environment"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009240

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwPipeInSlw_mp
    "Heat flow at the tube inlet"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwPipeIn_mp
    "Heat flow at the tube inlet"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009248

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwPipeOutSlw_mp
    "Heat flow at the tube outlet"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwPipeOut_mp
    "Heat flow at the tube outlet"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009250

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwPipeSlw_mp
    "Heat change, tube"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_dwPipe_mp
    "Heat change, tube"
    SLONG
    Pwr1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009258

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_etaTrbCh_mp
    "Turbocharger overall efficiency"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001AE2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_facAirMass_mp
    ""
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001AB4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_facPowEGPipe_mp
    "Factor from the power function to calculate the pressure in the exhaust system"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000921C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_facRhoEtaEGPipe_mp
    "Temperature-dependent density and viscosity factor to calculate the pressure in the exhaust system"
    SWORD
    Fact_2pwr11
    1
    100
    -16.00000
    15.99951

    
    FORMAT "%8.5"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000921E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_facStrtDlv_mp
    ""
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001AB6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_facTrbnPT1_mp
    "Variable factor for the turbocharger temperature model"
    SLONG
    Fact_PT1
    1
    100
    -16777216.0000
    16777215.9922

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD4001968

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_htcArEGPipeSlw_mp
    "Heat transfer coefficient between gas and tube wall"
    SLONG
    ThermalCoEff
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_htcArEGPipe_mp
    "Heat transfer coefficient between gas and tube wall"
    SLONG
    ThermalCoEff
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009260

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_htcArPipeEnvSlw_mp
    "Heat transfer coefficient between tube wall and environment"
    SLONG
    ThermalCoEff
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_htcArPipeEnv_mp
    "Heat transfer coefficient between tube wall and environment"
    SLONG
    ThermalCoEff
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009268

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_htcEGPipeSlw_mp
    "Heat transfer coefficient between gas and tube wall"
    SWORD
    ThermalCoEff
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_htcEGPipe_mp
    "Heat transfer coefficient between gas and tube wall"
    SWORD
    ThermalCoEff
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009270

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_htcPipeEnvSlw_mp
    "Heat transfer coefficient between tube wall and environment"
    SWORD
    ThermalCoEff
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092D2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_htcPipeEnv_mp
    "Heat transfer coefficient between tube wall and environment"
    SWORD
    ThermalCoEff
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009274

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_nEng
    "dynamically corrected engine speed"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000004A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_nuPipeEnvSlw_mp
    "Nusselt number between tube wall and environment"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_nuPipeEnv_mp
    "Nusselt number between tube wall and environment"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009278

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_nuPipeSlw_mp
    "Nusselt number in the tube"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092D6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_nuPipe_mp
    "Nusselt number in the tube"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD000927C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_pCACDs_mp
    "pressure of charge air cooler down stream"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001AE4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_pDiffEGPipe_mp
    "Pressure difference over one tube of the exhaust-gas pipe"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009220

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_pEGFld
    "Field of the exhaust-gas pressures"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD000004C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_pEGPresPipe_mp
    "measuring point of curve input of ASMod_facRhoEtaEGPipe_MAP"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001AD0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_phiDiffStrt_mp
    ""
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001AB8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_pwrCmpr_mp
    "Compressor power"
    SWORD
    Pwr
    1
    100
    -308831.1
    308821.7

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001AE6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_qInjCmb
    "Fuel quantity involved in combustion"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000050

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_qPresPipe_mp
    "Input signal for ASMod_pDiffPipe_MAP"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001AD2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rAirPerTime_mp
    ""
    SWORD
    RatAirMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001ABA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rePipe1_mp
    "Reynolds number in the tube"
    SWORD
    ReynoldsNum
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001ACA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rePipeEnv1_mp
    "Reynolds number between tube wall and environment"
    SWORD
    ReynoldsNum1
    1
    100
    -32768000.
    32767000.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001ACC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rePipeEnvSlw_mp
    "Reynolds number between tube wall and environment"
    SWORD
    ReynoldsNum1
    1
    100
    -32768000.
    32767000.

    
    FORMAT "%8.0"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rePipeEnv_mp
    "Reynolds number between tube wall and environment"
    SWORD
    ReynoldsNum1
    1
    100
    -32768000.
    32767000.

    
    FORMAT "%8.0"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009280

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rePipeSlw_mp
    "Reynolds number in the tube"
    SWORD
    ReynoldsNum
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092DA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rePipe_mp
    "Reynolds number in the tube"
    SWORD
    ReynoldsNum
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009284

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rLamRecExhMnfDs
    "Reciprocal lambda signal of the gas mass flow downstream of the exhaust manifold"
    SWORD
    lambdaRecVal
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD0000052

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rPresCmpr_mp
    "Pressure ratio at the compressor"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001AE8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rTempAdbt_mp
    "Adiabatic temperature ratio"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001AEA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rTempClgCrvIn_mp
    "input of ASMod_facTempClg_CUR"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001AD6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rTempClnt_mp
    "Ratio excess engine temperature engine stop to engine start"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001AD8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_rTimePipe_mp
    "Ratio standstill time to cooling half-live period, tube"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00092EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_stInit
    "Status of the switchover to initialization values"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000748

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_stTempModIni
    "init status of temperature models"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008BA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tAirStrt_mp
    "Air temperature for the calculation of the start temperature"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001ADA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tAirTrbn_mp
    "Air temperature for the turbocharger temperature model"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AEC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tCorrIAT_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001ABC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tCorrMnf_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001ABE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tDiffCldEng_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AC0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tDiffEGPipeSlw_mp
    "Temperature difference between gas and tube wall"
    SWORD
    TempDiff_Kelv
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tDiffEGPipe_mp
    "Temperature difference between gas and tube wall"
    SWORD
    TempDiff_Kelv
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009288

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tDiffIAT_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AC2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tDiffPipeEnvSlw_mp
    "Temperature difference between tube wall and environment"
    SWORD
    TempDiff_Kelv
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092DE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tDiffPipeEnv_mp
    "Temperature difference between tube wall and environment"
    SWORD
    TempDiff_Kelv
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD000928C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tEGFld
    "Field of the exhaust-gas temperatures"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000054

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tEGPipeDs_mp
    "Exhaust-gas temperature at the tube outlet"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009290

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tEGPipeSlwDs_mp
    "Exhaust-gas temperature at the tube outlet"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tEGPresPipe_mp
    "input signal for the map ASMod_facRhoEtaEGPipe_MAP"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AD4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tEngStrt_mp
    "Engine temperature for the calculation of the start temperature"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001ADC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tEng_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AC4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tExhMnfDs
    "Exhaust-gas temperature downstream of the exhaust manifold"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000060

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tExhMnfDsRaw
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000062

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tExhMnfStat_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AC6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tExsClnt_mp
    "Excess engine temperature"
    SWORD
    TempDiff_Kelv
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001ADE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tIATS_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AC8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tiClg
    "Cooling time for the calculation of the start temperature"
    SLONG
    Time_s
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD00042C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tiClgRef_mp
    "Reference time from engine cooling"
    SLONG
    Time_s
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD4001964

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tMidEGPipeSlw_mp
    "Average temperature between gas and tube wall"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tMidEGPipe_mp
    "Average temperature between gas and tube wall"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009294

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tMidPipeEnvSlw_mp
    "Average temperature between tube wall and environment"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tMidPipeEnv_mp
    "Average temperature between tube wall and environment"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009298

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tPipeStrt
    "Initialization temperature for the pipe model at engine start"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0000064

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tShOffExsClnt_mp
    "Excess engine temperature at last engine stop"
    SWORD
    TempDiff_Kelv
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AE0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tShOffPipe_mp
    "Tube wall temperature at last engine stop"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00092F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tTrbnDs
    "Exhaust-gas temperature downstream from turbine"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000006A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tTrbnDsRaw
    "Raw value exhaust-gas temperature downstream of the turbocharger"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000006C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tWallFld
    "Field of the tube wall temperatures"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD000006E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tWallPipeSlw_mp
    "Tube wall temperature"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092E6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_tWallPipe_mp
    "Tube wall temperature"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD000929C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_vscDynPipeSlw_mp
    "Dynamic viscosity of the gas in the tube"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_vscDynPipe_mp
    "Dynamic viscosity of the gas in the tube"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD00092A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_vscKinPipeSlw_mp
    "Kinematic viscosity of the gas in the tube"
    SWORD
    Fact8
    1
    100
    -0.0003276800
    0.0003276700

    
    FORMAT "%12.10"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092EA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ASMod_vscKinPipe_mp
    "Kinematic viscosity of the gas in the tube"
    SWORD
    Fact8
    1
    100
    -0.0003276800
    0.0003276700

    
    FORMAT "%12.10"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD00092A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ATS_IntvVal_mp
    "Intervention value"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001AEE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ATS_stMonTimeLimit
    "Behaviour time limit response for new tester demands"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000749

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ATS_TstStatus_mp
    "Status of actuatorintervention"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009125

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    BattU_facCor
    ""
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD0000090

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    BattU_u
    ""
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000092

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    BattU_uRated
    "Battery voltage"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000094

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    BattU_uRaw
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000096

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    BattU_uSens
    ""
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000098

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Brk_st
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000074D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Brk_stMnRaw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000074E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CACDsT_t
    "intake air temperature from DE"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000009A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CEngDsT_t
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000009C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CEngDsT_tSens_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B04

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CEngDsT_uRaw_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B06

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Clth_st
    "Clutch signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000074F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Clth_stRaw
    "Raw value of the Clutch signal obtained from DIO pin"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008BB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    cnt_event_crk_off
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    cnt_event_crk_on
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    cnt_event_eng_stal
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    cnt_event_in_cam
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    cnt_event_ltoo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    cnt_event_ltoo1
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    cnt_event_tolo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CnvSet_etaCurr
    ""
    SWORD
    Eta3
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000009E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_st
    "Persent engine state"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000751

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stOld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000753

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stShutOffPath
    "active shut-off paths resulting from active reversible, irreversible, and afterrun shut-off paths"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004368

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stShutOffRSA
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000436C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stSoftShOffRls_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009131

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stSoftShOff_mp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD400196C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stStopEna
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000754

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stStrtEna
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000755

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiAfterrun
    "time since reaching engine state afterrun (COENG_STAFTERRUN)"
    ULONG
    Time_ms
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD0004370

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiAfterrunRed
    "time since reaching engine state afterrun (COENG_STAFTERRUN, 0x30) with reduced resolution for curve/map input"
    SWORD
    TimeRed
    1
    100
    -5242.880
    5242.720

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00000A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiNormal
    "time since state NORMAL was reached"
    ULONG
    Time_ms
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD0004374

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiNormalRed
    "time since engine state NORMAL (0x04) was reached, with reduced resolution for curve/map input"
    SWORD
    TimeRed
    1
    100
    -5242.880
    5242.720

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00000A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiSoftShOff_mp
    ""
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD4001970

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiStandby
    ""
    ULONG
    Time_ms
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD0004378

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiStandbyRed
    ""
    SWORD
    TimeRed
    1
    100
    -5242.880
    5242.720

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00000A6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiStart
    "time since engine state START (0x02) was reached"
    ULONG
    Time_ms
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD000437C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiStartRed
    "time since engine state START (0x02) was reached, with reduced resolution for curve/map input"
    SWORD
    TimeRed
    1
    100
    -5242.880
    5242.720

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00000A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiStrtDly
    ""
    SWORD
    GlwCtl_Time_ms
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00000AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoEOM_stOpModeAct
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004364

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoES_stAVSCoLSU
    "status message for activation of AVS functionality in sw modules"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000750

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoES_stAVSCoLSU_mp
    "status for activation of AVS functionality in sw modules"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009132

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoES_stFMAReadRls_mp
    "status of activation of FMA function for reading out of learned values"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009133

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoES_stFMAWriteRls_mp
    "status of activation of FMA function for writing of values from Service tester"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009134

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoES_stSig_mp
    "status message for activation of AVS functionality via DSQ (DSM-Service)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009135

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoES_stTrmMod_mp
    "status of supported AVS-services in CoES"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009136

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoETS_trqInrCurrLim
    ""
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00000A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CoTemp_rClgDes
    ""
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00000AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Cpu_rCurCSACons_mp
    ""
    UWORD
    Ratio_045_COMPU
    1
    100
    0.00
    99.99847

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001B10

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Cpu_rCurSysStackCons_mp
    ""
    UWORD
    Ratio_045_COMPU
    1
    100
    0.00
    99.99847

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001B12

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Cpu_rCurUsrStackCons_mp
    ""
    UWORD
    Ratio_045_COMPU
    1
    100
    0.00
    99.99847

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001B14

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Cpu_rMaxCSACons_mp
    ""
    UWORD
    Ratio_045_COMPU
    1
    100
    0.00
    99.99847

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001B16

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Cpu_rMaxSysStackCons_mp
    ""
    UWORD
    Ratio_045_COMPU
    1
    100
    0.00
    99.99847

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001B18

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Cpu_rMaxUsrStackCons_mp
    ""
    UWORD
    Ratio_045_COMPU
    1
    100
    0.00
    99.99847

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001B1A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CrC_stMnRaw_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009127

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CrC_stSLRaw_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009128

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CrC_uRawPan_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B0C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ct_sfty_aftr_rst_ajs_cut
    ""
    UBYTE
    Mo_ti_s_q0p04
    1
    100
    0.00
    10.20

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0xD00099C7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ct_sfty_tq_req_ajs_cut
    ""
    UBYTE
    Mo_ti_s_q0p04
    1
    100
    0.00
    10.20

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0xD00099C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ct_sfty_tq_req_plau
    ""
    UBYTE
    Mo_ti_s_q0p04
    1
    100
    0.00
    10.20

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0xD00099C9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CY320_stSensSply0_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000912D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CY320_stSensSply1_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000912E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CY320_stSensSply2_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000912F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CY320_stSensSply3_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009130

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CY320_stSensSply4_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000912B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    CY320_stSensSply5_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000912C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stDigOutErr_mp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001974

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stDigOutPrevTst_mp
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B1C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stDigOutTstImp_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009137

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stMonActrPrt
    "The current status of the actuator protection control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000759

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPWMOutErr_mp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001978

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPWMOutPrevTst_mp
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B1E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPWMOutTstImp_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009138

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPwrStgEnaCond
    "Status of various vehicle and engine conditions"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000054E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_ctCldStrtLSU_mp
    "Repeated cold starts counter for respective probe position"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_ctPlsLSUSrvTst_mp
    "number of valid gas pulses in service test mode"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092F9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_dmEG_mp
    "Exhaust-gas mass flow downstream"
    SWORD
    AirMassPerTime
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092FA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_dwLSU_mp
    "Exhaust-gas heat flow at sensor position"
    SLONG
    Pwr_kW
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00092FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_facCldStrtLSU_mp
    "Factor for threshold value increase in case of repeated cold start"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009300

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_stDewDetTstDem_mp
    "state of service test demand"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009139

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_stEEPWrite_mp
    "Status of Write process in RAM mirror for heater release LSU"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000913A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_stHtgLSULstTrp_mp
    "state of dewpoint detection release of last driving cycle"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009302

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_stHtgThresLSUHit_mp
    "Status whether heat quantity excedes heat threshold value"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009303

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_stIntegIni_mp
    "status integrator initialisation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009304

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_stPlsLSU_mp
    "Status bit valid gas pulse detected"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009305

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_stShOff_mp
    "status of lambda sensor shut off condition"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009306

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_tEG_mp
    "Exhaust gas temperature at respective probe position"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009308

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_tEngStrt_mp
    "Measuring point to display selected Engine temperature value"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B20

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_tIntegIniSel_mp
    "Current selected Temperature threshold value for the heat quantity integrator activation in normal mode"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000930A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_tPipeMinIdx_mp
    "the lowest temperature between two pipes from the ASMod_TempStrtCalc-Model for addressing of Curve DewDet_facCldStrtLSU_CUR"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B22

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_tPipeMin_mp
    "the lowest temperature between two pipes from the ASMod_TempStrtCalc-Model"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000930C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_tWallLSUInpCrv0_mp
    "Measuring point input to curve DewDet_wThresLSU0_MAP"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B24

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_tWall_mp
    "pipe wall temperature at respective probe position"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000930E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_wLSU_mp
    "Integrated heat quantity at sensor position."
    SWORD
    Energy
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009310

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_wThresLSUAct_mp
    "Current heat threshhold at the sensor."
    SWORD
    Energy
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009312

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_wThresLSUNoPls_mp
    "Heat threshold without valid gas pulse."
    SWORD
    Energy
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009314

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_wThresLSUPls_mp
    "Heat threshold for valid gas pulse"
    SWORD
    Energy
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009316

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DewDet_wThresLSU_mp
    "Threshold value heat quantity"
    SWORD
    Energy
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009318

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stRawDef
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 10
    ECU_ADDRESS 0xD0004380

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stErrLamp
    ""
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000756

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFD00
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFD20
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFD40
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFD60
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFD80
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFDA0
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFDC0
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFDE0
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFE00
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DgDgtDas_DIDFE20
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stClctFId_mp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000931C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Dme_ctDataSetVariant
    "Current dataset variant"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00080E1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Dme_numBytesAvailable
    "Number of available bytes for serial calibration"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0003570

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Dme_numBytesAvailableOvl
    "Number of available bytes for serial calibration of NOSERAP data"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0003574

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_Unused
    ""
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_InhibitAlways
    ""
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A82

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_CoordALS
    ""
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_CoordFBC
    ""
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A86

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_CoordTAA
    ""
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_CoordZFC
    ""
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A8A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_IVPlausRunUpTstActv
    ""
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_RailHpTstActv
    ""
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A8E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_Unused
    ""
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00080EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_InhibitAlways
    ""
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00080ED

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_CoordALS
    ""
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00080EE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_CoordFBC
    ""
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00080EF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_CoordTAA
    ""
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00080F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_CoordZFC
    ""
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00080F1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_IVPlausRunUpTstActv
    ""
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00080F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_RailHpTstActv
    ""
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00080F3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_Unused
    ""
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_InhibitAlways
    ""
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A72

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_CoordALS
    ""
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_CoordFBC
    ""
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A76

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_CoordTAA
    ""
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_CoordZFC
    ""
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A7A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_IVPlausRunUpTstActv
    ""
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_RailHpTstActv
    ""
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005A7E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_Unused
    ""
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD00080E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_InhibitAlways
    ""
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD00080E5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_CoordALS
    ""
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD00080E6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_CoordFBC
    ""
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD00080E7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_CoordTAA
    ""
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD00080E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_CoordZFC
    ""
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD00080E9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_IVPlausRunUpTstActv
    ""
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD00080EA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_RailHpTstActv
    ""
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD00080EB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_Unused
    ""
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0xD0005A90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_InhibitAlways
    ""
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0xD0005A92

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_CoordALS
    ""
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0xD0005A94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_CoordFBC
    ""
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0xD0005A96

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_CoordTAA
    ""
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0xD0005A98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_CoordZFC
    ""
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0xD0005A9A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_IVPlausRunUpTstActv
    ""
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0xD0005A9C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_RailHpTstActv
    ""
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0xD0005A9E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_xPId1
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Dspl_bFlTnk
    "Digital filling status of the fuel tank"
    UBYTE
    Dspl_bFlTnk_VERB
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000075A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Dspl_volFlTnkQnt
    "Display of Fuel level in the tank"
    SWORD
    Vol
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00000B2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ECBVlv_r
    "Input actuator set point value for ECB valve"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00000B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ECBVlv_rPs
    "Output duty cycle to the powerstage for ECB valve"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00000B6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eeebd_numSectChg
    "Number of sector changes"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000D7BA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eeebd_stEee
    "Main state of emulation"
    UBYTE
    Eeebd_EeeStates_Verb
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD00085AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eep_EnvRamHist
    "EEP ENVRAM History marker"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0008117

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eep_EnvRamInvld
    "EEP ENVRAM Invalid marker"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0008116

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eep_numBlkCtr
    "Array contains block counters from each EEP block"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 60
    ECU_ADDRESS 0xD000D664

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eep_numEnvRamLength
    "Number of bytes of ENVRAM"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005B38

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stBlk
    "Status array with status of each EEP block"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 59
    ECU_ADDRESS 0xD0005AC2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stBlockFail
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D75E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stMain
    "Main state of EEP"
    UBYTE
    Eep_MainStates_Verb
    1
    100
    0.00
    11.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0xD0008120

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stPostDrv
    "Status of EEP process in PostDrive / PreDrive"
    UBYTE
    Eep_PostDrvState_Verb
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000811E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Eep_xIniTimeus
    "Initialization time of EEP in us"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00038D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_facCorFlt_mp
    "Measurement point for battery correction factor."
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B26

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_r
    "Input actuator set point value for EGR valve"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00000B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_rCnv_mp
    "Measurement point for output of the MAP."
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B28

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_rEGR
    "Control value for the EGR valve."
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00000BA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_rPs
    "Output duty cycle to the powerstage for EGR valve"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00000BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_stAdap
    "Status of offset learning."
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000550

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_stMon
    "EGR valve monitoring status"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000552

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_stOLXPostDrv_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000913B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_stOpnLdDia
    "Open Load Diagnosis Status for Electrical EGR Valve"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000075B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EGRVlv_uRaw_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AF0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EngDa_tEng
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00000E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EngDa_tFld
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00000E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EngDa_tiEngOff
    ""
    SWORD
    TimeEngOn
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00000EA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EnvP_p
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00000EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EnvP_pSens_mp
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001AF2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EnvP_uRaw_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AF4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EnvT_t
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00000EE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_ctInjSer
    "current number of testinjections done in series"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C5C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_ctTstInj
    "number of testinjections since start of backup-camshaft"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005578

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_ctWaitTDC
    "Counter for cylinders to be waited after an injection was released and the time until the injection will be done"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C5D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_CurrCyl
    "current cylinder for which the factor of the segment-times should be calculated"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C5E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_facTimes_mp
    "Factor of the segment-times belonging to the last cylinder in EpmBCa_CurrCyl"
    SWORD
    EpmBCa_FacTstInj
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001B2A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_numCylInj
    "bitfield in which the cylinders are marked in which no more testinjection should be done"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000557A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_numWaitTDC
    "number of cylinders to be waited before a test-injection is activated"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C5F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_stTstInj
    "current state of statemachine EpmBCa_TstInj"
    UBYTE
    EpmBCa_stTstInj_State_t
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C60

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_stTstInjRslt_mp
    "Result-Parameter of function EpmBCa_TstInj for Epm_OpMode"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000913C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_tiSegOld_mp
    "Segment-time of old segment in us"
    SLONG
    OneToOne_us
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD400197C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCa_tiSeg_mp
    "Segment-time of new segment in us"
    SLONG
    OneToOne_us
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001980

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_nEng
    "engine speed calculated during backup crankshaft"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005B76

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_phiCurrCaSEdge
    "position of current detected camshaft edge during backup crankshaft"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005B70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_phiNxtCaSEdge
    "position of the next expected camshaft edge during backup crankshaft"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005B72

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_phiPos
    "engine postion at time of Interrupt at a segment-edge of the camshaft"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005B74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_phiSeg2Seg
    "distance between the segmentedges"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005B6C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_rSeg2SegMax_mp
    "calculated maximum value of the ration between the last two segments (interpolated from EpmBCr_rSeg2SegMax_GCUR)"
    SWORD
    Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B2C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_rSeg2SegMin_mp
    "calculated minimum value of the ration between the last two segments (interpolated from EpmBCr_rSeg2SegMin_GCUR)"
    SWORD
    Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B2E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_rSeg2Seg_mp
    "calculated ratio between two segment times in backup CrS"
    SWORD
    Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B30

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_rSeg2SyncMax_mp
    "calculated maximum value of the ratio between segment- and synctime (interpolated from EpmBCr_rSeg2SyncMax_GCUR)"
    SWORD
    Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B32

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_rSeg2SyncMin_mp
    "calculated minumum value of the ratio between segment- and synctime (interpolated from EpmBCr_rSeg2SyncMin_GCUR)"
    SWORD
    Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B34

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_rSeg2Sync_mp
    "calculated ratio between segment time and sync tooth time in backup CrS"
    SWORD
    Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B36

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_stIntrCo
    "state of interruptcoordinator of backup crankshaft"
    UBYTE
    EpmBCr_stIntrCo_State_t
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000818F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_stPlaus_mp
    "state of plausibilisation of the camshaft-signal during backup crankshaft"
    UBYTE
    EpmBCr_stPlaus_State
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000913D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_stPos
    "state of position-detection during backup crankshaft"
    UBYTE
    EpmBCr_stPos_State
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0008194

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_stTmrModeStarted
    "state if the timermode of crankshaft-evaluation is started for backup crankshaft"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0008190

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_tiIncPer
    "Period-time of a simulated crankshaft-increment"
    SLONG
    OneToOne_us
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000393C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmBCr_tiSeg
    "time between 2 segment-edges (time during the angle EpmBCr_phiSeg2Seg)"
    SLONG
    OneToOne_us
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0003938

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_ctEdgeEquid
    "Offset of last equidistant camshaft edge in EpmSyn_ctEdgeMapEquid"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000760

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_ctErrSigDef
    "Number of crankshaft increments while camshaft pattern matching fails"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0005B92

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_ctErrSigOk
    "Number of crankshaft increments while camshaft pattern matching succeeds"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0005B94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_ctNoSig
    "Number of crankshaft increments without camshaft signal"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0005B90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_ctOfsErr_mp
    "debounce counter camshaft offset"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009360

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_nCaS_mp
    "camshaft spedd based on one camshaft rotation"
    SWORD
    EngNCaS
    1
    100
    -8192.000
    8191.750

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B3C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_nEng
    "engine speed based on a camshaft-revolution"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00000F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_numBufEntry_mp
    "index of the next free element inside the buffer"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009361

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_numCurrEdge
    "Number of actual counted camshaft edges"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0005B8E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_numRawValue_mp
    "Index on the latest valid element in the array of the camshaft raw values."
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000913E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_numSegTeeth_mp
    "number of equidistant segment edges on one camshaft wheel revolution"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000913F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_numValidTeeth_mp
    "Number of equidistant edges found during one process call"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009362

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiAdapRefPosI1_mp
    "adapted reference-positions of inlet-camshaft 1"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 10
    ECU_ADDRESS 0xD0009334

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiCaSOfsAvg
    "average value of camshaft offset"
    SLONG
    AngleCrS
    1
    100
    -47185920.0000
    47185919.9780

    
    FORMAT "%13.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0003940

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiCor
    "Correction angle of the camshaft for engine speed and temperature"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00000F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiDiff
    "difference of actual camshaft position to reference position"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00000F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiDiffLimFil_mp
    "filtered diffenence-angle from adaption"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009348

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiDiff_mp
    "difference of the real camshaft-position to the (adapted) refenceposition"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000934A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiEdge
    "angle of camshaft edge"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00000F6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiMissedSeg_mp
    "Expected angle of a missed equidistant camshaft edge"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009364

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiOfsCorr
    "filtered vaule of camshaft offset"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00000F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiRawValue_mp
    "Array with the raw values of the edge positions of the camshaft."
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 10
    ECU_ADDRESS 0xD000934C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiSegLenTolc_mp
    "Calculated tolerance for the edge distance of equidistant camshaft edges"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B38

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiSpeedSegLen_mp
    "Calculated length of equidistant segments for the camshaft offset"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B3A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_phiTempCor
    "Angle correction value for each camshaft depending on temperature"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00000FA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_stAdap
    "status of the camshaftadaption"
    UBYTE
    EpmCaS_stAdap_State
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000D864

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_stAdapErr
    "error of the camshaft adaption which occured during adaption or test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0008196

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_stDiag
    "State of the camshaft diagnosis"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0008199

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_stErrSig
    "Error state for disturbed camshaft signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000819A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_stNEng
    "State of the camshaft engine speed"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000761

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_stNoSig
    "Error state for lost camshaft signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000819B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_stOfs
    "state of camshaft offset calculation"
    UBYTE
    EpmCas_stOfs_State
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000428C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_stOfsErr
    "error state of camshaft offset calculation"
    UBYTE
    EpmCaS_stOfsErr_Val
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00081A3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCaS_tiEdge
    "time of camshaft edge"
    SLONG
    Per_Dur
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00042D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctCaSRev_mp
    "debounce counter no crankshaft signal"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B3E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctErrSig
    "debounce counter wrong crankshaft signal"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000557C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctGlitch
    "debounce counter for glitch events on crankshaft"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000557E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctGlitchRev_mp
    "debounce counter for glitch events on crankshaft"
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009140

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctInc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00081BB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctRange_mp
    "counter for selecting speed limits in dynamic plausibilisation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009145

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctRev100msLim_mp
    "counter of crankshaft revolutions in 100ms limited"
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009141

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctRevCnt
    "crankshaft revolution counter"
    UWORD
    RevCnt
    1
    100
    0.00
    4095.938

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005BF4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctRevIni
    "crankshaft revolutions since synchronisation"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00000FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctRevStrt
    "crankshaft revolution since switch off start BIT"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00000FE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_ctRevWaitDiag
    "healing debounce counter wrong crankshaft signal"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005580

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_facScale_mp
    "TTMeasure - current adjusted resolution for tooth time measurement"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009147

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_numNewInc_mp
    "TTMeasure - number of new tooth times since last interrupt"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009148

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_numSeg
    "counter of part segments"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000762

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_numTiIncPerAvrg_mp
    "current number of crankshaft teeth to calculate average of tooth time"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009146

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_phiIntSeg
    ""
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000100

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_stDiag
    "state of crankshaft signal diagnosis"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000763

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_stDiagErrSig
    "current state of error wrong crankshaft signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00081B7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_stDiagFFReset_mp
    "lock state of stall detection crankshaft diagnosis"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009142

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_stDiagNoSig
    "current state of error NoSig"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00081B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_stDiagReset_mp
    "general lock state crankshaft diagnosis"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009143

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_stDiagVehSpdReset_mp
    "lock state towing detection crankshaft diagnosis"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009144

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_stSigDiagSrc
    "reason of cranksahft error"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005BE6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_stSigMode
    "state of crankshaft signal evaluation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000764

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_tiIncPer_mp
    "current tooth-time on crankshaft"
    SLONG
    TimeGT0Tic
    1
    100
    -858993.459200
    858993.458800

    
    FORMAT "%13.6"
    
    ECU_ADDRESS 0xD4001984

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_tiInc_mp
    "TTMeasure - CrS-tooth times since last interrupt"
    UWORD
    TimeGPTATick
    1
    100
    0.00
    3276.750

    
    FORMAT "%8.3"
    ARRAY_SIZE 20
    ECU_ADDRESS 0xD0009366

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_tiSeg
    "segment time"
    SLONG
    Per_Dur
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00042D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_tiSegCurr
    "time of one part segment"
    SLONG
    Per_Dur
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00042D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmHCrS_FindGap_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C61

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmHCrS_stCrkDlyCnf_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmHCrS_stSigErr
    "crankshaft signal errors"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005BFC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmHCrS_stSigMode
    "State of crankshaft signal evaluation"
    UBYTE
    EpmHCrS_stSigMode_State_t
    1
    100
    0.00
    8.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD00081BE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmHCrS_stTimer
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C62

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmHCrS_TimerVal_mp
    ""
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmHInt_tiInt4Del_mp
    "latency of segment syncronous interrupt"
    ULONG
    OneToOne_us
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001988

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmRRS_bEngSwOff
    "Emergency engine switch off (reverse running engine)"
    UBYTE
    default
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD00008BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSeq_numIncDiffInt
    "Difference between 2 synchro-interrupts in crankshafttooth"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0000102

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSeq_numInt
    "type of current interrupt"
    UBYTE
    EpmSeq_numInt_Compu
    1
    100
    0.00
    16.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0xD0000765

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSeq_phiNxtInt
    "angle of the next syncrointerrupt"
    SWORD
    AngleCrS
    1
    100
    0.00
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005C00

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSeq_stInt
    "status of sequencemanager"
    UBYTE
    EpmSeq_stInt_Compu
    1
    100
    0.00
    8.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD00081BF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSrv_stCnvAgT2Ag_mp
    "Internal state of the function EpmSrv_CnvAgT2Ag"
    UBYTE
    EpmSrv_stCnvAgT2Ag_t
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD0009149

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_CaSData
    "detected camshaftsegments"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 16
    ECU_ADDRESS 0xD0005C14

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_ctEdgeEarly
    "number of tolerated camshaft edges, they are too early"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00081DE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_ctEdgeLate
    "number of tolerated camshaft edges, they are too late"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00081DF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_ctLstEdge_mp
    "last counter value of camshaft signal edge counter"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_ctSigTabLstEntr_mp
    "index of last entry in signal table"
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000914A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_EdgeFailType
    "camshaft edge failure types for tolerant pattern matching"
    UBYTE
    EpmSyn_EdgeFailTypes
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00081DD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_numCaSSync
    "camshaft used for phase position detection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00081C5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_numIntTyp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_numMatches_mp
    "number of matches between EpmCaS_dSegSeries_C and signal table"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000914B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_numMatchPos
    "position of EpmCas_dSegSeries_C where matching the detected pattern"
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00081DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_numMatchPos_mp
    "position of the match"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000914C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_numNewEdges_mp
    "number of new edges since last call"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000914D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_numSegInSigTab_mp
    "number of segment entries in signal table"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000914E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_phiCaSPos
    "angle of camshaft position after pattern matching"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0005C12

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_phiDiff_mp
    "difference between camshaft and crankshaft"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B42

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_phiIncCor_mp
    "Corerection value engine speed depending phase error crankshaftsignal"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B44

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_phiInt
    "Position of syncro interrupt"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000106

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_phiOffs
    "Synchronisation offset"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005C30

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_phiSegLenUncorr
    "uncorrected segment length used by tolerant pattern matching"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0003C50

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_stCasEval
    "state of camshaft evaluation"
    UBYTE
    EpmSyn_stCaSEvalComp
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD00081E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_stCaSPos
    "state of camshaft position"
    UBYTE
    EpmSyn_stCaSPosComp
    1
    100
    0.00
    20.0000000000

    
    FORMAT "%13.10"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00081C6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_stCrSPos
    "state of crankshaft position"
    UBYTE
    EpmSyn_stCrSPos_State_t
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0000766

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_stCrSPosErr
    "error of crankshaft position"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005C34

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_stGapPos
    "1=use of gap position for phase verification"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00081E3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_stPreSeg_mp
    "state of pre segment detection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000914F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    EpmSyn_stRR
    "state of reverse running detection with camshaft pattern matching"
    UBYTE
    EpmSyn_stRRComp
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000767

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_ctCyl
    "Current cylinder number"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000768

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_ctCylPerECU
    "cylinder counter per ECU (master/slave)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000769

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_ctCyl_cor
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009126

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_ctReSync_mp
    "number of new synchronisations during synchronisation phase in state Epm_stOpMode = 33"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009150

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_ctTDCPhys_mp
    "cylindercounter, that counts in the injectionseries"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009151

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_dnEng
    "Enginespeed-gradient calculated over current crankshaft-segment (S0-S0 oder S1-S1)"
    SWORD
    EngNGrd
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000108

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_dnEngFlt
    "Filtered enginespeed-gradient calculated over current crankshaft-segment (S0-S0 oder S1-S1)"
    SWORD
    EngNGrd
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000010A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEng
    "engine speed"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000010E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEng10ms
    "engine speed calculated in 10ms"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000010C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEngCurr
    "current engine speed"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000110

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEngDiff
    "Difference fo enginespeeds calculated over current crankshaft-segment (S0-S0 oder S1-S1)"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000112

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEngLRes
    "engine speed with low resolution"
    UBYTE
    EngN_LRes
    1
    100
    0.00
    10200.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD000076A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEngOldS0_mp
    "Engine speed of last S0-Synchro"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B4C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEngOldS1_mp
    "Engine speed of last S1-Synchro"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B4E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEngRaw
    "raw engine speed for OBD tester"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000114

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEngTooth10ms_mp
    "engine speed from one tooth period"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B48

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_numCyl
    "Real number of cylinder"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000076B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_numVariant
    "Active EPM variants in the actual software."
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000554

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_numVersion
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0008D76

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_phiDiffTDC
    "distance between two cylinders"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000116

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_phiIntDelay_mp
    "angle difference between set and actual position of syncro interrupt"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B46

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_stCmbTestReq
    "state for request a combustion test"
    UBYTE
    Epm_stCmbTestReq_State_t
    1
    100
    0.00
    10.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0xD000076C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_stOpMode
    "state of operation mode"
    UBYTE
    Epm_stOpMode_State_t
    1
    100
    1.00000000000
    60.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0xD000076D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_stReSyncReason_mp
    "Reason of resynchronisation / lost of synchronisation in state Epm_stOpMode = 33"
    UBYTE
    Epm_stReSyncReason_State_t
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0009152

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_stRmtInjVlv
    "injection of next cylinder is in master (=0) or in slave (=1)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000076E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_stSpd
    "Selection of engine speed"
    UBYTE
    Epm_stSpd_t
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000076F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_stSporadicAgTrg_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009153

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_stSync
    "state of synchronization"
    UBYTE
    Epm_stSync_State_t
    1
    100
    0.00
    30.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0xD0000770

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_tiSegRaw_mp
    "raw value of time of a segment"
    SLONG
    OneToOne_us
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD400198C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Epm_tiSpd2Zero_mp
    "timer until engine speed will set to zero"
    UWORD
    Time_ms
    1
    100
    0.00
    655350.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001B4A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ESC_stErr
    "Sampling time stack overflow error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00081F7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ESC_stSchdFlag_mp
    "Measurement Point for the actual position of the conditional scheduling"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009154

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ESC_stSchdLevel_mp
    "Measurement Point for the active engine speed range for scheduling limitation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009155

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ESC_stSchdS0_mp
    "Measurement Point of one S0-interrupt table entry showing the activation of the container"
    UBYTE
    ESC_stSchdSx_CntnrNames_t
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    ARRAY_SIZE 16
    ECU_ADDRESS 0xD000938E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ESC_stSchdS1_mp
    "Measurement Point of one S1-interrupt table entry showing the activation of the container"
    UBYTE
    ESC_stSchdSx_CntnrNames_t
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    ARRAY_SIZE 16
    ECU_ADDRESS 0xD000939E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ESC_tiSampling
    "Sampling time"
    SLONG
    Per_Dur
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0003CA4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_ctDelta_mp
    "Counter for the number of intervals driven at a length of ETClb_lLrnDelta_C"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B52

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_ctInjCycl_mp
    "Current number of injection cycles for the energizing time calibration"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B50

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_ctLrnCyclAllw_mp
    "Number of learning cycles allowed for each rail pressure calibration point"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD000940F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_ctLrn_mp
    "Learning cycle counter for each rail pressure calibration point of energizing time calibration"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00093AE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_dtiETFlt0_mp
    "Filtered energizing time difference of the energizing time calibration for each cylinder at a rail pressure calibration point of 0"
    SWORD
    InjTimeHiRes_us
    1
    100
    -1638.400
    1638.350

    
    FORMAT "%8.3"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00093B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_dtiETFlt1_mp
    "Filtered energizing time difference of the energizing time calibration for each cylinder at a rail pressure calibration point of 1"
    SWORD
    InjTimeHiRes_us
    1
    100
    -1638.400
    1638.350

    
    FORMAT "%8.3"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00093C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_dtiETFlt2_mp
    "Filtered energizing time difference of the energizing time calibration for each cylinder at a rail pressure calibration point 2"
    SWORD
    InjTimeHiRes_us
    1
    100
    -1638.400
    1638.350

    
    FORMAT "%8.3"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00093CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_numCylCur_mp
    "Current cylinder for the energizing time calibration at each rail pressure calibration point"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00093D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_numPres_mp
    "Current rail pressure calibration point of the energizing time calibration"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009156

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_numRailPresClbPnt_mp
    "Number of rail pressure calibration points for the energizing time calibration"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009157

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_pRailSet
    "State of the energizing time calibration"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00000BE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_stCor
    "Display of the status of the releases for the ZFC energizing time correction"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000075C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_stDemCor_mp
    "Request for energizing time correction of the energizing time calibration"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009158

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_stEvalResult_mp
    "Result of the energizing time calibration injections"
    UBYTE
    ETClb_Eval_Rslt
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000915D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_stEval_mp
    "State of the state machine for evaluating the energizing time calibration"
    UBYTE
    ETClb_Eval_State
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD000940C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_stLimClbFrq
    "Release status of the learning frequency limitation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000075D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_stOld_mp
    "Old state of the energizing time calibration"
    UBYTE
    ETClb_State
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0009159

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_stQISActv
    "State of Quick Initial Search (QIS) activ (1=QIS is activ)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000075E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_stRlsCylCor_mp
    "Cylinder specific release of the energizing time correction of the energizing time calibration"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000915A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_st_mp
    "State of the energizing time calibration"
    UBYTE
    ETClb_State
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000915B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_swtCorActv
    "SW switch for activating the ZFC energizing time correction"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000075F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_swtQckClb_mp
    "Indicator of switchover to quick energizing time calibration"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000915C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_swtRCClb_mp
    "Display indicating roller dynamometer calibration ON"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000915E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETAvrg
    "State of the energizing time calibration"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00000C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETChkCor0_mp
    "Energizing time of the ZFC zero quantity after correction by the injector quantity adjustment for a rail pressure calibration point 0"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009412

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETChkCor1_mp
    "Energizing time of the ZFC zero quantity after correction by the injector quantity adjustment for a rail pressure calibration point 1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000941E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETChkCor2_mp
    "Energizing time of the ZFC zero quantity after correction by the injector quantity adjustment for a rail pressure calibration point 2"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000942A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETCor0_mp
    "Energizing time correction value of the energizing time calibration for a rail pressure calibration point 0"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00093DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETCor1_mp
    "Energizing time correction value of the energizing time calibration for a rail pressure calibration point 1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00093E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETCor2_mp
    "Energizing time correction value of the energizing time calibration for a rail pressure calibration point 2"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00093F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETCur_mp
    "Current energizing time of the energizing time calibration for each rail pressure calibration point"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0009400

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETMax
    "Result of the energizing time calibration injections"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00000CA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETMin
    "Result of the energizing time calibration injections"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00000D6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ETClb_tiETMinEff_mp
    "Zero quantity energizing time of the current cylinder for each rail pressure calibration point"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0009406

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Etc_ctCurRunTst
    "Stores the number of actual running engine tests"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000771

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Exh_pPFltDiff
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000118

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Exh_pPFltUs
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000011A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Exh_stPullUpTOxiCatUs
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008BD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Exh_stPullUpTPFltUs
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008BE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Exh_uRawPPFltUs_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B00

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Exh_uRawPTrbnUs
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000011C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Exh_uRawTOxiCatUs
    "Raw value of temperature at upstream of the oxidation catalyst"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000011E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Exh_uRawTPFltUs_mp
    ""
    UWORD
    V02_RSA
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B02

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_AACoef_mp
    "anti-aliasing filter coefficients"
    FLOAT32_IEEE
    OneToOne
    1
    100
    0.00
    1.00000000

    
    FORMAT "%10.8"
    ARRAY_SIZE 9
    ECU_ADDRESS 0xD0009450

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_AAInSum_mp
    "sum of segment times of mini segments"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -150000000.
    150000000.

    
    FORMAT "%10.0"
    
    ECU_ADDRESS 0xD4001990

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_AAIn_mp
    "segment time of sub segments (FBC_AAIn_mp[0] is the most recent time in array)"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -150000000.
    150000000.

    
    FORMAT "%10.0"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0009474

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_AAOrd_mp
    "order of anti-aliasing filter"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009160

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_AAOut_mp
    "output of anti-aliasing filter"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -150000000.
    150000000.

    
    FORMAT "%10.0"
    
    ECU_ADDRESS 0xD4001994

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_AAPhiAbs_mp
    "absolute starting angle of anti-aliasing segment (FBC_AAPhiAbs_mp[0] is the most recent value)"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0009484

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_AAPhiLen_mp
    "length of anti-aliasing segment (FBC_AAPhiInt_mp[0] is the most recent value)"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B58

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_Badpt
    "adaption status (bit1: correction values available, bit2: adaption stopped, bit3: new correction values learned)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000772

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_ctSegInt
    "internal segment counter of FBC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000774

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_dBPCaS
    "current band pass numerator of f = fCaS (gear dependent)"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -5000.00000
    5000.00000

    
    FORMAT "%10.5"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0004294

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_dBPCaSOld_mp
    "array of band pass outputs of last segment"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -5000.00000
    5000.00000

    
    FORMAT "%10.5"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0009438

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_dBPSum
    "FBC fuel quantity substitute signal, input of PI-governor"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000120

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_DXAdap_mp
    "current adaption quality"
    SWORD
    FBC_Dxs_s16
    1
    100
    -0.7812500
    0.7812262

    
    FORMAT "%9.7"
    
    ECU_ADDRESS 0xD4001B5A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_DXSfn_mp
    "negative filter for evaluation"
    SWORD
    FBC_Dxs_s16
    1
    100
    -0.7812500
    0.7812262

    
    FORMAT "%9.7"
    ARRAY_SIZE 12
    ECU_ADDRESS 0xD000948C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_DXSfp_mp
    "positive filter for evaluation"
    SWORD
    FBC_Dxs_s16
    1
    100
    -0.7812500
    0.7812262

    
    FORMAT "%9.7"
    ARRAY_SIZE 12
    ECU_ADDRESS 0xD00094A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_DXSf_mp
    "filtered, current, normalized pitch error of toothed wheel (adaption filter, actual values)"
    SWORD
    FBC_Dxs_s16
    1
    100
    -0.7812500
    0.7812262

    
    FORMAT "%9.7"
    ARRAY_SIZE 12
    ECU_ADDRESS 0xD00094BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_DXSl_mp
    "filtered, normalized pitch error of toothed wheel (adaption filter, learned values)"
    SWORD
    FBC_Dxs_s16
    1
    100
    -0.7812500
    0.7812262

    
    FORMAT "%9.7"
    ARRAY_SIZE 12
    ECU_ADDRESS 0xD00094D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_DXS_mp
    "normalized pitch error of toothed wheel (unfiltered)"
    SWORD
    FBC_Dxs_s16
    1
    100
    -0.7812500
    0.7812262

    
    FORMAT "%9.7"
    ARRAY_SIZE 12
    ECU_ADDRESS 0xD00094EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_dynSpd_mp
    "engine speed dynamic value"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -150000000.
    150000000.

    
    FORMAT "%10.0"
    
    ECU_ADDRESS 0xD4001998

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_facBPNum_mp
    "currently used band pass numerators"
    SWORD
    FBC_BPfac
    1
    100
    -60.00183
    60.00000

    
    FORMAT "%8.5"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0009444

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_facSegVal_mp
    "currently used segment value"
    UWORD
    Per_Ratio
    1
    100
    0.00
    255.9961

    
    FORMAT "%8.4"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD000944A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_nMaxOvrRun_mp
    "upper engine speed limit of band pass calculation"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B54

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_numAASeg_mp
    "number of FBC partial segments"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009161

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_q
    "FBC quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000122

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_qArr
    "FBC output quantity, interface for injection system"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000124

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_qDvtCyl
    "current cylinder-individual correction quantity: integrator outputs in firing sequence"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000013C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_qDvtCylPhys
    "current cylinder-individual correction quantity: integrator outputs in geometrical order"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000130

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_qIntegrator
    "cylinder-individual correction quantity: integrator output"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -327.000000
    327.000000

    
    FORMAT "%10.6"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00042AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_qLimAct
    "Actual limiting value for FBC_q"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000148

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_qLimIncr
    "offset for FBC limiting fuel quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000014A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_qSet
    "fuel quantity demand with FBC correction at corresponding MI-Interrupt"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000014C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_qSetOld_mp
    "fuel quantity demand with FBC correction at corresponding MI-Interrupt of last segment"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B56

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_RegionChng
    "Signals a change of the learning-region in the FBC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000773

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_stActive
    "Status of FBC Govern -> '1': Govern; '0': Control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000775

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_stBPRedNum_mp
    "status of reduction of bandpass amplification (TRUE: 'active' ; FALSE: 'inactive')"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000915F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_stBufSeg_mp
    "return value of function EpmHCrS_GetBufSegFBC for one EDC segment"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009162

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_stBufSubSeg_mp
    "return values of function EpmHCrS_GetBufSegFBC for FBC sub segments"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0009504

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_stEqualInit
    "initialization status for FBC controller (0: 'normal operation', 1: 'controller initialisation')"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000776

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_stLearn
    "status of fly-wheel adaption (bit1: 'dynamic-overflow', bit2: 'not overrun', bit3: 'changing of spd.-region', bit4: 'not a valid learn.-region')"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000556

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_stRegionESpP_mp
    "status of toothed wheel adaption depending on speed"
    UBYTE
    FBC_RegionESpP_st
    1
    100
    1.00000000000
    16.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0xD0009163

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_stRegionSRCtl
    "status of controller depending on fuel quantity/engine speed ('closed-loop control','open-loop control','inactive')"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000777

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_stStateESpP_mp
    "status of state machine for adaption"
    UBYTE
    FBC_StateESpP_st
    1
    100
    1.00000000000
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0009164

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_swtESpPEEPIni
    "initialisation of all learned pitch errors of toothed wheel (FBC_DXSl_mp) to 0"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000778

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_TSmCoef_mp
    "coefficients for mean value filter"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -11.5000000
    12.5000000

    
    FORMAT "%10.7"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009508

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_WheelLrnOut
    "input signal of FBC band passes"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -1.00000000E+035
    1.00000000E+035

    
    FORMAT "%10.0"
    
    ECU_ADDRESS 0xD0004290

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FBC_WheelLrnOutOld_mp
    "input signal of FBC band passes of last segment"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -1.00000000E+035
    1.00000000E+035

    
    FORMAT "%10.0"
    
    ECU_ADDRESS 0xD400199C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlFWLvl_stRaw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000077A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_dvolFlCons
    "actual fuel consumption [l/h] (only torque relevant injection quantity)"
    SWORD
    FlConsum_l_h
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000164

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_dvolPerStroke_mp
    "fuel consumption per stroke [mm^3/hub] (only torque relevant injection quantity)"
    SWORD
    InjQnt
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B62

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_facStoich
    "stochiometric fuel factor"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000166

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_p
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000168

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_rhoFl
    "fuel density coefficient"
    SWORD
    RhoFuel
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000016A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_rhoFlCnvFac
    "customer specific fuel conversion factor"
    SWORD
    RhoFuel
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000016C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_rhoFlSel_mp
    "selected fuel factor"
    SWORD
    RhoFuel
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001B64

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_stDeflate
    "Activation of the low pressure deflation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000077B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_stDeflateActv_mp
    "Activation of the low pressure deflation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009165

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_stDeflateFin
    "Finished state of low pressure deflation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000077C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_stDeflateOffDeflateTst
    "Activation of finished state of low pressure deflation via tester"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000077D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_stDeflateXPostDrv_mp
    "Postdrive extension by deflate function"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009166

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_stRefDeflateTst
    "status report of a refuesed deflate test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000558

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_stStMDeflateTst
    "status of state machine of deflate test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000077E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_stTnk
    "bit-coded message for tank level"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000077F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_swtRhoFlCnv
    "switch for customer specific fuel conversion factor"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000780

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_swtSrcPSDeflateTst
    "Switch from internal deflation time to tester time of low pressure deflation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000781

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_tiDeflate
    "Passed deflation time of low pressure deflation"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD000016E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_tiDeflateDeflateTst
    "Deflation time of low pressure deflation set via tester"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000170

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_tiDeflateMax_mp
    "Maximum deflation time of low pressure deflation"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001B5C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_tiDeflateRdEEP_mp
    "Passed deflation time of low pressure deflation safed in EEPROM while ECU afterrun"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001B5E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_tiDeflateStp_mp
    "Passed deflation time of low pressure deflation after ECU start"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001B60

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_tiEvalDeflateTst_mp
    "measurement point of evaluation time of deflate test"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD40019A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_volFlCons
    "absolute fuel consumption in ul/20ms"
    SLONG
    FlConsum_ul_20ms
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00042E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_volFlConsAct_mp
    "summarized fuel consumption until now"
    SLONG
    Vol
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD40019A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_volFlConsRdEEP_mp
    "fuel consumption written to EEPROM in postrun mode"
    SLONG
    Vol
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD40019A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FlSys_volFlConsWrEEP_mp
    "fuel consumption read from EEPROM in init phase"
    SLONG
    Vol
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD40019AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Fl_volTnkQnt
    ""
    SWORD
    Fl_Vol_q0p05
    1
    100
    -1638.400
    1638.350

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000172

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_dqAbs_mp
    "Absolute value of derivative of fuel quantity for FMA"
    SWORD
    InjMassSec
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B7E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_drLamAbs_mp
    "Absolute value of variation in Lambda for FMA"
    SWORD
    lambdaSec
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001B80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facAirSwtOff_mp
    "Intake air temperature dependent switch off factor of FMA"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B82

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facAPSwtOff_mp
    "Atmosphere pressure dependent"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facEngSwtOff_mp
    "Engine temperature dependent switch off factor of FMA"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B86

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facFaultSwtOff_mp
    "Factor for smooth switch off of FMA due to serious system faults"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facFlSwtOff_mp
    "Fuel temperature dependent switch off factor of FMA"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B8A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facNQSwtOff_mp
    "Engine speed / fuel quantity dependent switch off factor of FMA for operating range dependent switch off"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B6E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facRgnSwtOff_mp
    "FMA - switch-off factor due to active regeneration"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facSlpSwtOff2Var_mp
    "switch off factor of FMA from variant function part"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B8E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facSlpSwtOff_mp
    "FMA - switch-off factor after slope limitation"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facSwtOff
    "Switch off factor for smooth switch off and on of FMA"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD000014E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_facSwtOffTot_mp
    "Total switch-off factor for slow switching off of FMA"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001B70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_numLimMax_mp
    "number of map-points above upper diagnosis level"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B72

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_numLimMin_mp
    "number of map-points below lower diagnosis level"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qAct_mp
    "injection quantity calculated by lambda signal and air mass measurement; real injection quantity of FMA"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B66

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qAirCtlCor
    "FMA correction quantity for local usage in AirCtl"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000150

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qCor
    "correction quantity of FMA (Indirect Control)"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000152

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qCtl_mp
    "quantity information for calculation of quantity fault"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B6A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qDC
    "By FMA determinated injection quantity fault rather correction factor for operation point Direct Control"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000154

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qDev_mp
    "deviation of real injection quantity to the desired injection quantity of FMA"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B68

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qDiff_mp
    "Difference between injection quantity error and actual map-value"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B76

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qErrMod_mp
    "fuel quantity deviation to be filtered"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qMapRow0_mp
    "Map values in the first row of fuel quantity co-ordinates (first of adapive map)"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 8
    ECU_ADDRESS 0xD0009510

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qMapRow1_mp
    "Map values in the second row of fuel quantity co-ordinates (second row of adaptive map)"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 8
    ECU_ADDRESS 0xD0009520

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qMapRow2_mp
    "Map values in the third row of fuel quantity co-ordinates (third row of adaptive map)"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 8
    ECU_ADDRESS 0xD0009530

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qMapRow3_mp
    "Map values in the fourth of fuel quantity co-ordinates (fourth row of adaptive map)"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 8
    ECU_ADDRESS 0xD0009540

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qMapRow4_mp
    "Map values in the fifth row of the fuel quantity co-ordinates (fifth row of adaptive map)"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 8
    ECU_ADDRESS 0xD0009550

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qMapRow5_mp
    "Map values in the sixth row of the fuel quantity co-ordinates (sixth row of adaptive map)"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 8
    ECU_ADDRESS 0xD0009560

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qMapRow6_mp
    "Map values in the seventh row of fuel quantity co-ordinates (seventh row of adaptive map)"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 8
    ECU_ADDRESS 0xD0009570

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qMapRow7_mp
    "Map values in the eighth row of fuel quantity co-ordinates (eighth row of adaptive map)"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 8
    ECU_ADDRESS 0xD0009580

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qReg_mp
    "Actual fuel quantity error in learning region"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B7A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_qSetFil_mp
    "Initialisation value for Integrator or PT1-Filter"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_q_mp
    "quantity fault multiplied by shutoff factor of error model"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001B6C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_stDynDlyd_mp
    "FMA-Status: Currently or shortly before large change of fuel quantity (delayed fuel quantity dynamics)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009167

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_stDynLam_mp
    "FMA- status: currently or shortly before large change in Lambda value"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009168

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_stNoAdapt_mp
    "Status: Adaptation of FMA error model stopped"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B92

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_stOvrRunDlyd_mp
    "Status: Current or shortly before terminated overrun (delayed overrun)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009169

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_stReset_mp
    "Status: Reset FMA error model"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000916A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_stRngLam_mp
    "FMA- status: currently or shortly before Lambda over range check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000916B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_stSwtOff
    "cutoff state of FMA"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000779

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_stSwtOff3Var_mp
    "FMA switch off request from variant function part for switch off possibility 3"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000916C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_tiFuncOp
    "Operating time of error-model since last initialization of learned values"
    SLONG
    Time_s
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD00042DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMA_trqAirCtlCor
    "FMA correction torque for local usage in AirCtl"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000156

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMO_facAirMsCor
    "Correction factor for air mass signal"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD0000158

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMO_qASMod
    "correction quantity of FMO (unlimited) for recirculation in ASMod"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000015A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMO_qCor
    "Correction quantity from the observer"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000015C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMO_qEmiCtlCor
    "FMO Fuel mass correction quantity for emission control"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000015E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMO_qFullLdCor
    "Correction quantity for full-load correction"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000160

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FMO_trqEmiCtlCor
    "FMO torque correction quantity for emission control"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000162

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FuelT_t
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000174

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FuelT_tFlSys
    "Fuel system temperature"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000176

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FuelT_tSens
    "Sensed fuel temperature"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000178

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    FuelT_uRaw
    "Raw ADC value of fuel temperature"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000017A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlbDa_lDrvWhlCirc
    "Global Dara message used in adapter"
    SWORD
    Length_fine
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD000017C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlbDa_lTotDst
    ""
    SLONG
    Length
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00042E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_qInjQnt
    "Actual injection quantity inside GlwCtl"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000017E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_qNoPst_mp
    "Injection quantity threshold for transition to ""no post glow"""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BB4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_qPst_mp
    "Injection quantity threshold for transition to post-glow"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BB6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stActrOut_mp
    "Glow Plug Control status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000916D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stAftDemClgTmr_mp
    "Status Afterrun Delay Demand Cooling Timer"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009170

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stAftEnrgInteg_mp
    "Status Afterrun Delay Demand Cooling Ramp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009171

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stAftRunDelDem
    "Status afterrun delay demand from glow control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000784

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stAftRunXPostDrv_mp
    "status for extension of after run"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009172

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stAllw_mp
    "Status of transition from No glow to Intermediate glow"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000917A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stGlw
    "glow control state"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000055A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stGlwPlgActr_mp
    "Glow plug activation information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000916E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stHiPreGlwActv_mp
    "Status pre-glow with energy entry"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009173

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stHiPreGlwEnbl_mp
    "Status of push allowance"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009174

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stPshDisbl_mp
    "Status regarding whether pushing is currently forbidden"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009175

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stPshRd
    "Push information read from EEPROM for current cycle"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000785

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stPshRdStrt_mp
    "unchanged pushing information read from Eeprom during ECU init"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009176

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stPshWr
    "Push information written into EEPROM for next operating cycle"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000786

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stPshWrInteg_mp
    "Status whether energy integrator reached 0"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009177

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stPshWrTmr_mp
    "Status whether cooling timer is elapsed"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009178

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stShOff_mp
    "Shut off condition status for glow plug and lamp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000916F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_stTmr_mp
    "Status of the glow-plugs cooldown timer (0:stopped, 1: running)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009179

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_swtGlwPlgMode
    "Message for selection of the glow plug system"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000787

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_swtPreGlw
    "EEPROM switch for the glow indicator"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000788

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tAirPwrCtl_mp
    ""
    SWORD
    Temp_Cels_1deg
    1
    100
    -33041.14
    32493.86

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001B96

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tAirStM_mp
    "Air temperature from air temperature field"
    SWORD
    Temp_Cels_1deg
    1
    100
    -33041.14
    32493.86

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BB8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tEng
    "Glow control engine temperature"
    SWORD
    Temp_Cels_1deg
    1
    100
    -33041.14
    32493.86

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000180

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tEngAdj
    "Glow control engine temperature value after adjustment"
    SWORD
    Temp_Cels_1deg
    1
    100
    -33041.14
    32493.86

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000182

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tiHiPreGlwPrectl_mp
    "Time for Preconditioning of the Glow Plugs"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001B98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tiLmp_mp
    "Activation time of the glow indicator lamp in the event of pre-glow"
    SWORD
    GlwCtl_Time_ms
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001B94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tiPreGlwRmn
    "Remaining pre glow time"
    SWORD
    GlwCtl_Time_ms
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD0000184

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tiPre_mp
    "Pre glow time"
    SWORD
    GlwCtl_Time_ms
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001BBA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tiPst_mp
    "Post-glow time"
    SWORD
    GlwCtl_Time_ms
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001BBC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tiRdy_mp
    "Duration for readiness glow"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BBE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tiThresFl1_mp
    "Threshold time for No glow to intermediate glow transition"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BC0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tTempVal_mp
    "Selected temperature of the engine temperature field Eng_tFld"
    SWORD
    Temp_Cels_1deg
    1
    100
    -33041.14
    32493.86

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BC2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_tValEEP_mp
    "Adjustment engine temperature value from EEPROM"
    SWORD
    TempDiff_Kelv_1K
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BC4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uGlwPlgHiPreGlwRaw_mp
    "Raw Push voltage without offset compensation"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001B9A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uGlwPlgHiPreGlw_mp
    "Voltage for Pre Glow with energy entry with offset correction"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001B9C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uGlwPlgRaw
    "Glow plug voltage from glow power calculation"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000186

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uOutGlw_mp
    "Glow plug voltage depending on the glow status"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001B9E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uOutItm_mp
    "Glow plug voltage at intermediate glow"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BA0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uOutPst_mp
    "Glow plug voltage at post-glow"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BA2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uOutRdyPre_mp
    "Preliminary glow plug voltage for readiness glow"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BA4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uOutRdy_mp
    "Glow plug voltage at readiness glow"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BA6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uOut_mp
    "Voltage from the map GlwCtl_uOut_MAP"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BA8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uPresPstCor_mp
    "Pressure dependent correction voltage for post glow"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BAA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uPstCor_mp
    "Correction voltage for post glow"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BAC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_uTIndPstCor_mp
    "Corrected voltage for Post glow, dependent from air temperature"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BAE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_wEnrgPre_mp
    "Energy from the curve GlwCtl_wEnrgPre_CUR"
    SWORD
    SqrVltg_s
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001BB0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwCtl_wIntegEnrg_mp
    "Energy from the integrator"
    SWORD
    SqrVltg_s
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001BB2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwLmp_st
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000789

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwPlg_rGCUFdbk
    ""
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000188

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwPlg_rLVS
    ""
    SLONG
    DtyCyc
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD00042E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwPlg_rLVSPs
    "PWM output to the actuator"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000018A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwPlg_stPs
    "Glow plug digital actuator signal to the power stage."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000078A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwPlg_stPwmInErr_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000917B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    GlwPlg_u
    "Glow plug voltage for Device Encapsulation"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD000018C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    HCIVlv_r
    ""
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000018E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    HCIVlv_rPs
    ""
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000190

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    HCVlv_st
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008BF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    HCVlv_stPs
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000078B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    HESrv_stMSid
    "Indicates the type of ECU"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000078C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    HLSDem_nSetPLo
    ""
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000192

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ImmCtl_Noise
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007F6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ImmCtl_stEmul
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_numInjLim_mp
    "Number of injections allowed"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E10

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_numInjMaxSys
    "Maximum number of injections allowed determined by the system"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007FD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_numInjRtmLim_mp
    "legal number of injections due to runtime"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_numPoI1Splt
    "Number of active splitted injections of PoI1"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007FE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiDiffBnkPoI1_mp
    ""
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E12

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiDiffBnk_mp
    ""
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E14

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiMI1Des
    "Desired reference angle for the start of MI1"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002AE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiMIMax_mp
    ""
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E16

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiPiI1Des
    "Desired angular component for PiI1 start of energizing"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiPiI2Des
    "Desired angular component for PiI2 start of energizing"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002B2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiPiI3Des
    "Desired angular component for PiI3 start of energizing"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiPiIMax_mp
    ""
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E18

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiPoI1Des
    "Desired reference angle for the start of PoI1"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002B6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiPoI1Splt2Min_mp
    ""
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E1A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiPoI2Des
    "Desired reference angle for the start of PoI2"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_phiPoIMin_mp
    ""
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E1C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qAfterDesCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E1E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qAfterDesRls_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E20

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qAfterLimCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E22

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qAfterMI1Min_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E24

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qAfterMinCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E26

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qAfterSum_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E28

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qAfterTotMax_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E2A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qDiffCorAfter_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002BA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qDiffCorPost_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qDiffCorPreInj2_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002BE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1AftrDesCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E2C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1AftrDesRls_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E2E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1AftrMinCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E30

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1AftrSum_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E32

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1Des
    "desired quantity for main injection"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1DesCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E34

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1DesRls_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E36

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1MinCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E38

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1Min_mp
    "Minimum injection quantity of main injection 1"
    SWORD
    InjMass_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002C2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1PostDesCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E3A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1PostDesRls_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E3C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1PostMinCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E3E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1PostSum_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qMI1Sum_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E42

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPause_mp
    ""
    SWORD
    InjMass_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E44

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1Des
    "Desired PiI1 injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00002C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1DesCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E46

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1DesRls_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E48

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1Des_mp
    "desired quantity for PiI1"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CCE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1LimCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E4A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1MI1Min_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E4C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1MinCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E4E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1Min_mp
    ""
    SWORD
    InjMass_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1PreInj1_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CD0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1PreInj2_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CD2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI1TotMax_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E50

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI2Des
    "Desired PiI2 injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00002D2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI2Minp1_mp
    ""
    SWORD
    InjMass_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E52

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPiI3Des
    "Desired PiI3 injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00002DE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI1Des
    "Desired PoI1 injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00002EA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI1Des_mp
    "Post injection 1 setpoint quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CD4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI1Min_mp
    "Minimum value of the PoI1 injection quantity"
    SWORD
    InjMass_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E54

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI1Splt
    "Splitted PoI1 injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00002F6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI1Splt1Min_mp
    ""
    SWORD
    InjMass_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E56

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI1Splt2Min_mp
    ""
    SWORD
    InjMass_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E58

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2AfterMin_mp
    ""
    SWORD
    InjMass_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000302

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2After_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E5A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2Des
    "Post injection 2 setpoint quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000304

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2DesCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E5C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2DesRls_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E5E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2Des_mp
    "Post injection 2 setpoint quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CD6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2Eff
    "Effective PoI2 injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000310

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2LimCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E60

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2MI1Min_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E62

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2MinCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E64

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2PostMin_mp
    ""
    SWORD
    InjMass_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000031C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2Sum_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E66

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_qPoI2TotMax_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E68

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_rTrqInrLimMax
    "Maximum limit for CSC intervention on DOD of MI1"
    SWORD
    Prc_Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000031E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_rTrqInrLimMin
    "Minimum limit for CSC intervention on DOD of MI1"
    SWORD
    Prc_Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000032A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stAfterMinQnt_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stAfterMinRls_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stAfterTiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stInjCharActVal
    "release status of injection types"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007FF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stInjCharComp
    "state of fuel compensation for injection characteristic"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000805

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stInjCharShOffTst
    "characteristic of injections in case of shut off test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000806

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stMI1AftrTiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stMI1DurCSCFrz
    "status of MI1CSC-energizing time correction"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000080C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stMI1PostTiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stMI1QntCSCCorActv
    "type of MI1-CSC corrections (0- Energizing time, 1- quantity)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000080D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stMI1TiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPiI1MinQnt_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPiI1MinRls_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPiI1TiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPiI2TiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPoI1Splt1TiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPoI1Splt2TiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008C9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPoI1TiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008CA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPoI2MinQnt_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPoI2MinRls_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008CB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPoI2TiMin
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stPoI2TiMin_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_stStMShOffTst
    "state of statemachine of shut off test"
    UBYTE
    ShutOffTst_States
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000080E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiAfterET
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000336

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiMI1AftrET
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000338

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiMI1ET
    "Estimated MI1 energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000033A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiMI1PostET
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000033C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPiI1Des
    "Desired time component for PiI1 start of energizing"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000033E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPiI1ET
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000340

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPiI1PreInj1_mp
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CD8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPiI1PreInj2_mp
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CDA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPiI2Des
    "Desired time component for PiI2 start of energizing"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000342

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPiI2ET
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000344

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPoI1ET
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000346

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPoI1Splt
    "Time offset of splitted injection of PoI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000034C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPoI1Splt1ET
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000348

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPoI1Splt2ET
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000034A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPoI1SpltDiffMin
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000034E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPoI1SpltDiff_mp
    "Time distance between the splitted injections of PoI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CDC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPoI1SpltSet_mp
    "Time distance between the energizing times of the splitted injections of PoI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CDE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPoI2Des
    "Desired reference time component for start of PoI2"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000350

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPoI2ET
    "Estimated energizing time for PoI2"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000352

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPseAfter_mp
    ""
    SWORD
    InjTime_us_RSA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E6A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPseLatePost_mp
    ""
    SWORD
    InjTime_us_RSA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E6C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPseNxtCylPoI1_mp
    ""
    SWORD
    InjTime_us_RSA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E6E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPseNxtCyl_mp
    ""
    SWORD
    InjTime_us_RSA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPsePinj1Pinj2_mp
    ""
    SWORD
    InjTime_us_RSA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E72

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPsePinj2Main_mp
    ""
    SWORD
    InjTime_us_RSA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPsePoI1Splt2_mp
    ""
    SWORD
    InjTime_us_RSA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E76

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_tiPsePost_mp
    ""
    SWORD
    InjTime_us_RSA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volAfterCor_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E7A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volAfter_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volMI1AftrCor_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E7E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volMI1Aftr_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volMI1Cor_mp
    "MI1 injection volume with correction values"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E82

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volMI1PostCor_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volMI1Post_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E86

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volMI1_mp
    "MI1 injection volume"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPiI1Cor_mp
    "Corrected injection volume for estimating PiI1 energizing time"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E8A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPiI1_mp
    "Limited injection volume for PiI1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPiI2Cor_mp
    "Corrected injection volume for estimating PiI2 energizing time"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E8E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPiI2_mp
    "Limited injection volume for PiI2"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPoI1Cor_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E92

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPoI1Splt1Cor_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPoI1Splt1_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E96

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPoI1Splt2Cor_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPoI1Splt2_mp
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E9A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPoI1_mp
    "Limited injection volume for PoI1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E9C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPoI2Cor_mp
    "Corrected injection volume for estimating PoI2 energizing time"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E9E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCrv_volPoI2_mp
    "Limited injection volume for PoI2"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001EA0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCtl_qCurr
    "current injection mass"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000354

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCtl_qRaw
    "raw value of injection mass"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000356

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjCtl_qSetUnBal
    "current injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000358

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_qInrCmb
    "Inner combusted quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000035A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_qOutrCmb
    "Outer combusted quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000366

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_qTot
    "Total injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000372

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_stCtlQnt
    "Status of the control quantity"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000080F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_stLeadPar
    "Chosen leading parameter for injection system"
    UBYTE
    SETPOINTCALC_TRQBASED_SY_Compu
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0000810

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_tAir
    "Intake air temperature selected for the injection system"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000374

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_tAirRail
    "Air Temperature for Rail pressure Setpoint calculation for EOM0"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000376

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_tAirRailRgn
    "Air Temperature for Rail pressure Setpoint calculation for EOM1-EOM7"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0000378

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_tAirRgn
    "Intake air temperature selected for the injection system in Regeneration mode"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000037A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_tEng
    "Engine temperature selected for the injection system"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000037C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjSys_tEngRgn
    "Engine temperature selected for the injection system in regeneration mode"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000037E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjUn_stSta
    "state of starter (released / not released)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000811

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjUn_stStrt
    "Service information for trouble in starting of engine."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000812

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjUn_stStrtCsBlk_mp
    "Reason for starting trouble"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000917C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctCylMI1_mp
    "Cylinder currently being used for the first main injection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009181

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctCylPiI1_mp
    "Cylinder number pertaining to pilot injection 1"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009182

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctCylPiI2_mp
    "Cylinder number pertaining to pilot injection 2"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009183

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctCylPiI3_mp
    "Cylinder number pertaining to pilot injection 3"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009184

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctCylPoI1_mp
    "Cylinder number pertaining to post injection 1"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009185

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctCylPoI2_mp
    "Cylinder number pertaining to post injection 2"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009186

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctMI1AgDiff_mp
    "Counter for angle violations in the programming of the MI1 start of energizing"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C2C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctPiI1AgDiff_mp
    "Counter for angle violations in the programming of the PiI1 start of energizing"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C30

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctPiI2AgDiff_mp
    "Counter for angle violations in the programming of the PiI2 start of energizing"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C34

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_ctPiI3AgDiff_mp
    "Counter for angle violations in the programming of the PiI3 start of energizing"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C38

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_facAddBalRls
    "Result from release map for computing the fuel quantity correction as an array (cylinder specific)"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000380

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_frqTDC_mp
    "Frequence of the TDCs in firing order depending on the engine speed"
    SLONG
    FrqTDC
    1
    100
    -42949672.9600
    42949672.9400

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD40019B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_numCylECU_mp
    "Number of cylinders on the ecu"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BE0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_numInjChrgBal
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000813

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_numInjChrgBalLim_mp
    "number of injections limited by charge balance"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000917D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_numInjChrgBalRaw_mp
    "Maximum number of injections based on buffer capacitor charge balance (raw value)"
    SWORD
    NumInjChrgBalRaw
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BE2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_numInjDes_mp
    "desired number of injections to select the state of InjVlv_ChrgBalInjLim (normal, overload)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000917E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_numInjOvrLdRaw_mp
    "raw value of the limitation of the maximum number of injections in overload mode"
    SWORD
    NumInjChrgBalRaw
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BE4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_numInjOvrLd_mp
    "limitation value of the maximum number of injections in overload mode"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000917F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_numPrepLeft_mp
    "Number of activations left for injection valve preparation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009187

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_phiMI1Diff_mp
    "Angle differential between the desired start of energizing and the system based earliest MI1 start of energizing"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C2E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_phiPiI1Diff_mp
    "Angle differential between the desired start of energizing and the system based earliest PiI1 start of energizing"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C32

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_phiPiI2Diff_mp
    "Angle differential between the desired start of energizing and the system based earliest PiI2 start of energizing"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C36

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_phiPiI3Diff_mp
    "Angle differential between the desired start of energizing and the system based earliest PiI3 start of energizing"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C3A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_pInET_mp
    "X-input for InjVlv_tiET_MAP map on application tool"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001BF4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_pwrDCDCMax_mp
    "maximum power of the DC/DC-converter"
    SWORD
    Pwr_PA
    1
    100
    -163840.0
    163835.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BE6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_pwrDCDCOvrLdMax_mp
    "Max. allowed power output of all DCDC converters of the ECU in overload state"
    SWORD
    Pwr_PA
    1
    100
    -163840.0
    163835.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BE8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_pwrInjAvrg_mp
    "average value of actuator power loss at 1 injection per cyl and sequence"
    SWORD
    Pwr_PA
    1
    100
    -163840.0
    163835.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001BEA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qInZFCETGMap_mp
    "Fuel quantity for input display for the group maps InjVlv_rZFCETMsk_GMAP, ...Dif0_GMAP, ...Dif1_GMAP"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C3E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qMI1Bal_mp
    "Main injection 1 fuel correction quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BC6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qMI1Cor_mp
    "Corrected quantity for main injection 1"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BFA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPiI1Bal_mp
    "Pilot injection 1 fuel correction quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BC8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPiI1Cor_mp
    "Corrected quantity for pilot injection 1"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C02

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPiI2Bal_mp
    "Pilot injection 2 fuel correction quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BCA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPiI2Cor_mp
    "Corrected quantity for pilot injection 2"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C0A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPiI3Bal_mp
    "Pilot injection 3 fuel correction quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BCC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPiI3Cor_mp
    "Corrected quantity for pilot injection 3"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C12

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPoI1Bal_mp
    "Post injection 1 fuel correction quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BCE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPoI1Cor_mp
    "Corrected quantity for post injection 1"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C1A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPoI2BalEff_mp
    "Fuel correction quantity for post injection 2, torque forming part"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BD0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPoI2Bal_mp
    "Post injection 2 fuel correction quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BD2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_qPoI2Cor_mp
    "Corrected quantity for post injection 2"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C22

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_rZFCETCoeffDif_mp
    "Evaluation factors the energizing time correction by ZFC"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00095D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_rZFCETCoeffMsk_mp
    "Overall evaluation factor of energizing time correction by ZFC"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjCharComp
    "state of compensation of injections"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000814

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjCharPrg_mp
    "injection characteristic (final value given to injection driver)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009193

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjClsnPerm_mp
    "Energizing Collision Indicator (sticky bits)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009194

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjClsn_mp
    "Energizing Collision Indicator"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009590

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjCo
    "State of injection coordinator"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000815

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjCoRun_mp
    "State: visited states of InjVlv_stInjCo"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BF8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjMI1_mp
    "Status of main injection 1 programming"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000918B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjMI2_mp
    "Status of main injection 2 programming"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000918C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjPiI1_mp
    "Status of pilot injection 1 programming"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000918D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjPiI2_mp
    "Status of pilot injection 2 programming"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000918E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjPiI3_mp
    "Status of pilot injection 3 programming"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000918F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjPoI1_mp
    "Status of post injection 1 programming"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009190

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjPoI2_mp
    "Status of post injection 2 programming"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009191

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjRls
    "status of released injections"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000816

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stInjZFC_mp
    "Status of ZFC programming"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009192

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stOvrLdRls_mp
    "State of overload mode"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009180

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPrep
    "State of injection valve preparation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000081C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPrepInjErr_mp
    "Actuator specific state: programming of at least one injection caused an error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009188

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPrepInjOK_mp
    "Actuator specific state: programming of at least one injection was OK"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009189

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPrepPreCond_mp
    "Preconditions of InjVlv_Prep"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000918A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcChipVer_mp
    "hardware chip ID of common rail power stage IC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcDiaBnk1_mp
    "diagnosis inforamtion bank 1 of common rail power stage IC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcDiaBnk2_mp
    "diagnosis inforamtion bank 2 of common rail power stage IC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095B1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcErrCom
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000081D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcErrIlse
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000081E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcIniDiag
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00005BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcIniTrans
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00043E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcIni_mp
    "status of the initialisation of the common rail power stage IC"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcNumBnkPcP_mp
    "input PCP bank number if an error occured within module driver"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcNumBnk_mp
    "input SW bank number if an error occured within module driver"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcNumChipPcP_mp
    "input PCP chip number if an error occured within module driver"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcNumChip_mp
    "input SW chip number if an error occured within module driver"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcStBufDatEx_mp
    "state of module driver buffer during write"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcStBufTraInj_mp
    "state of module driver buffer during set"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcTraEvSyn_mp
    "event synchronous state of the common rail power stage IC module driver, actualised with static interrupt"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stPsIcTra_mp
    "status of the common rail power stage IC module driver, error collector"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00095D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_stTCtlInj_mp
    "state of setting duration for time controlled (immediate) injection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009195

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiChrgPrep
    "Charge time for injection valve preparation"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000038C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiDisChPrep
    "Discharge time of injection valve preparation"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000038E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiETPrep_mp
    "Activation time of injection valve preparation"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C2A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiMI1ETUnLim
    "Unlimited MI energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000390

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiMI1ET_mp
    "MI energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BD4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiMIIntr
    ""
    UWORD
    OneToOne_ms
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00005BE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiOfsSOEHyd
    ""
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000392

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiPiI1ET_mp
    "Pilot injection 1 energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BD6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiPiI1ZFCETCor_mp
    "Energizing time correction of ZFC for pilot injection 1 and each cylinder"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00095DA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiPiI2ET_mp
    "PiI2 energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BD8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiPiI2ZFCETCor_mp
    "Energizing time correction of ZFC for pilot injection 2 and each cylinder"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00095E6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiPiI3ET_mp
    "PiI3 energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BDA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiPiI3ZFCETCor_mp
    "Energizing time correction of ZFC for pilot injection 3 and each cylinder"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00095F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiPoI1ET_mp
    "PoI1 energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BDC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiPoI2ET_mp
    "PoI2 energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BDE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiPse
    "Fixed or measured minimum time between 2 injections"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000394

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiSOERngCor_mp
    "Corrected SOE"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0009596

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiSOERngDiff_mp
    "Correction value of SOE (relative)"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD000959C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiSOERngDst_mp
    "Input value of SOE"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00095A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiWaitAct_mp
    "actual waiting period till the release of the overload mode (since the first scheduleing of the function)"
    SWORD
    Time_Second
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001BEC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiZFCPiI1ETCor
    "ZFC energizing time correction for pilot injection 1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000396

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiZFCPiI2ETCor
    "Corrected PiI2 energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000398

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_tiZFCPiI3ETCor
    "Corrected PiI3 energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000039A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_uSetUpAvrg_mp
    "average set value of actuator voltage for up-level"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BEE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_uUpPrep
    "Set-Up voltage for injection valve preparation"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000039C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volInET_mp
    "Y-input for InjVlv_tiET_MAP map on application tool"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BF6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volMI1CorCyc
    "Cylinder specific correction volume from fuel balancing compensation and injector adjustment quantity for MI1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000039E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volMI1Cor_mp
    "Corrected quantity for main injection 1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BFC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volMI1QntAdj_mp
    "Injector adjustment volume for main injection 1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BFE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volMI1_mp
    "Main injection 1 injection volume after quantity adjustment"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C00

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI1CorCyc
    "Cylinder specific correction volume from fuel balancing compensation and injector adjustment quantity for PiI1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00003AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI1Cor_mp
    "Corrected volume for pilot injection 1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C04

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI1QntAdj_mp
    "Injector adjustment volume for pilot injection 1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C06

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI1_mp
    "Pilot injection 1 injection volume after quantity adjustment"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C08

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI2CorCyc
    "Cylinder specific correction volume from fuel balancing compensation and injector adjustment quantity for PiI2"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00003B6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI2Cor_mp
    "Corrected volume for pilot injection 2"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C0C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI2QntAdj_mp
    "Injector adjustment volume for pilot injection 2"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C0E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI2_mp
    "Pilot injection 2 injection volume after quantity adjustment"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C10

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI3Cor_mp
    "Corrected quantity for pilot injection 3"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C14

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI3QntAdj_mp
    "Injector adjustment volume for pilot injection 3"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C16

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPiI3_mp
    "Corrected volume for pilot injection 3"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C18

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPoI1CorCyc
    ""
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00003C2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPoI1Cor_mp
    "Corrected volume for post injection 1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C1C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPoI1QntAdj_mp
    "Injector adjustment volume for post injection 1"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C1E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPoI1_mp
    "Post injection 1 injection volume after quantity adjustment"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C20

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPoI2CorCyc
    "Cylinder specific correction volume from fuel balancing compensation and injector adjustment quantity for PoI2"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00003CE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPoI2Cor_mp
    "Corrected volume for post injection 2"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C24

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPoI2NoCorCyc_mp
    "Not corrected volume for post injection 2"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C3C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPoI2QntAdj_mp
    "Injector adjustment volume for post injection 2"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C26

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_volPoI2_mp
    "Post injection 2 injection volume after quantity adjustment"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C28

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_wInjCorr_mp
    "Corrected energy consumption of actuator per injection (buffer side)"
    SWORD
    W_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BF0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_wInjNom_mp
    "Nominal energy consumption of actuator per injection (buffer side)"
    SWORD
    W_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001BF2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_xIntegOvrLd
    "integration value for the release/locking of the overload mode"
    SWORD
    FACT_percent
    1
    100
    -100.0031
    100.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00003DA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_xIntegOvrLdOff_mp
    "integration factor for down integration in relax state"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD40019B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    InjVlv_xIntegOvrLdOn_mp
    "integration factor for up integration in overload state"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD40019B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_ch
    "Charge after loading on piezo actuator"
    SWORD
    Charge_PA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000194

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_chnImmdMeas
    "Measured channel in immediate mode"
    UBYTE
    default
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000078D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_facWActrDvtAvrg
    "actuator energy consumption deviation"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00001A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_facWActrDvtUnCor_mp
    "uncorrected factor of actuator energy deviation"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00095FE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_facWActrDvt_mp
    "limited average deviation of actuator energy"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C42

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_facWActrTemp_mp
    "temperature correction of expected actor energy consumption"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C44

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_numCylMeasNxt
    "next cylinder to be measured"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_numFacWVld_mp
    "number of valid energy deviation factors"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD40019BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_pRailLnk
    "linked rail pressure of measured injection"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00001A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stActrEnrg
    "state of actor energy calculation"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000055C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stCh
    "Status of IVActr_ch"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000078E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stGetImmdMeas
    "Status of actuator measurement, immediate mode"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000794

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stGetMeas
    "Status of actuator measurement, injection mode"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000795

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stMeasDisbl
    "state: measurement temporary disabled (cylinder specific) - Injection mode"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000079B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stMeasEna_mp
    "State of ADC measurement - Activated or not"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009196

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stMeasTyp
    "Last measurement mode activated"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000079C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stTiDisCh
    "state of piezo actuator discharging time"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000079D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stTiETMeas
    "status of measured energizing time"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007A3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stUChrgUp
    "state of piezo actuator voltage after charging"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007A9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stUDisChStop
    "state of piezo actuator voltage after discharging"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007AF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_stUUp
    "status of piezo actuator voltage up-level"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007B5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_tActr
    "temperatur of actuator"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00001AE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_tiActrMeasCurr
    "Cylinder specific time stamp of last actuator measurement, refreshed in 10ms."
    UWORD
    OneToOne_ms
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000568

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_tiActrMeasTmr_mp
    "Timeout's timer value for the surveillance of the measurement duration"
    SLONG
    Time_s
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD40019C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_tiChrgLnk
    "linked charging time setpoint"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00001B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_tiDiffActrInteg_mp
    "timegap between integrator adjustment and measurement of current cylinder"
    ULONG
    OneToOne_ms
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD40019C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_tiDisCh
    "piezo actuator discharging time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00001C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_tiDisChLnk
    "linked piezo actuator setpoint discharging time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00001BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_tiEnrgCalc
    "timestamp of actuator enetrgy calculation"
    UWORD
    OneToOne_ms
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000574

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_tiETMeas
    "measured energizing time"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00001D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_uActrRaw_mp
    "raw ADC actuator voltage value for IVActr_uActrLin_CUR"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C48

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_uChrgUp
    "piezo actuator voltage after charging"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00001E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_uChUpInCur_mp
    "input value for IVActr_wActrNom_CUR"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C46

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_uCh_mp
    "Measure point of IVActr_UCh"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C4A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_uDisChStop
    "piezo actuator voltage after discharging"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00001EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_uImmdMeasRaw_mp
    "Raw value of immediate measurement"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C4C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_uUp
    "piezo actuator voltage up-level"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000204

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_uUpLnk
    "linked piezo actuator setpoint voltage up-level"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00001F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_wActrDiff_mp
    "actuator charge-discharge-cycle energy"
    SWORD
    W_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000960A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_wActrNomCor_mp
    "temperature corected nominal actuator energy consumption"
    SWORD
    W_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009616

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_wActrNom_mp
    "nominal actuator energy consumption"
    SWORD
    W_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009622

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_wChActrRaw_mp
    "raw acutator charge energy"
    SWORD
    W_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000962E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVActr_wDisChActrRaw_mp
    "raw acutator discharge energy"
    SWORD
    W_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000963A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_clsIVA
    "Injetor Voltage Adjustment class of piezo actuator"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007BB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_ctNVCEna_mp
    "value of NVC-learning counter"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009646

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_facNVC
    "NVC-factor"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000210

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_facNVCEepWrI_mp
    "in EEPROM stored value of NVC-I-governor"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009652

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_facNVCInitI_mp
    "initialisation value of NVC-I-governor"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000965E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_pDiffNVCSetCURIn_mp
    "input-value of voltage-difference reference curve"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001C4E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_stChkErr_mp
    "status of check sum error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009198

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_stChkSumErrAdj_mp
    "error status of checksum-violation of injector adjustment values"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009197

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_stIVAErr
    "IVA error status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD00007C1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_stNVCCond_mp
    "status of NVC-learning conditions"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C50

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_stNVCEna_mp
    "status of NVC-learning release"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009199

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_stNVCGovInit_mp
    "status of selected operation (return value of IVAdj_NVCGovInit)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000919A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_stNVCRls
    "release status of NVC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007C5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_tiNVCGovCalc
    "system time of last NVC calculation"
    UWORD
    OneToOne_ms
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000580

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_uDiffNVCInPI_mp
    "NVC-governor input value"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000966A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_uDiffNVCSet_mp
    "current value from voltage difference reference curve"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009676

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_uDiffNVC_mp
    "current value of NVC-controlled value (difference between current actuator charge-up-voltage and current actuator up-voltage)"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009682

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVAdj_valDestPtr_mp
    "value of Destination-Pointer (red EEPROM value) (function parameter of IVAdj_NVCGovInit)"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000968E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_facVltgTempCor
    "Temperature correction factor of actuator voltage"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD000021C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_iChrg_mp
    "Charge-up current limit"
    SWORD
    Curr
    1
    100
    0.00
    20000.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00096BE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_iCorPI
    "Discharge time governor output"
    SWORD
    Curr
    1
    100
    -10000.00
    10000.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000021E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_iCorPIUnLim_mp
    "Unlimited output of discharge time governor"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000969A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_iDisChUnCor_mp
    "uncorrected discharge current"
    SWORD
    Curr
    1
    100
    -30000.00
    30000.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00096A6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_iDisCh_mp
    "Discharge current"
    SWORD
    Curr
    1
    100
    -30000.00
    30000.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00096B2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_p
    "current Railpressure for setpoint voltage calculation"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD000022A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_stOBDErr
    "OBD error status of Up-voltage"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD00007C6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_stStrt
    "State: start-voltage of piezo valve active"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD00007C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_stTGovPIHi_mp
    "State: PI-governor of discharge time exceeds upper limit (cylinderspecific)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000919B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_stTGovPILo_mp
    "State: PI-Governor of discharge time exceeds lower limit (cylinderspecific)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000919C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_stUDiffUpImPlaus_mp
    "State: governor input IVCtl_uDiffUp is implausible (cylinderspecific)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000919D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_stVltgGovPIHi_mp
    "State: voltate governor output exceeds upper limit (cylinderspecific)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000919E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_stVltgGovPILo_mp
    "State: voltage governor output exceeds lower limit (cylinderspecific)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000919F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_tiChrg
    "Chargetime setpoint value"
    SWORD
    InjTime_us
    1
    100
    0.00
    400.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000022C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_tiDiff
    "Input of discharge time governor"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000022E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_tiDisCh
    "Dischargetime setpoint value"
    SWORD
    InjTime_us
    1
    100
    0.00
    400.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000023A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_tiPseChrg
    "Charge-up current pusle pause time"
    SWORD
    Time_PzoChrgPse
    1
    100
    2.000000
    20.00000

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD000023C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_tiPseDisCh
    "Discharge current pulse pause time"
    SWORD
    Time_PzoChrgPse
    1
    100
    2.000000
    20.00000

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD000023E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_tiStrt_mp
    "cranking time"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001C5C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_tiTGovCalc
    "timestamp: last calculation of discharge time governor"
    UWORD
    OneToOne_ms
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000058C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_tiVltgGovCalc
    "timestamp: last calulation of voltage governor"
    UWORD
    OneToOne_ms
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000598

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uChrgMapIn_mp
    "Input for IVCtl_iChrg_MAP"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C54

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uChrgUp_mp
    "Setup voltage after chage up"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00096CA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uCorPI
    "Actuator voltage governor output"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000240

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uCorPIUnLim_mp
    "Unlimited output of actuator voltage governor"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00096FA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uCorPreCtl_mp
    "Pre-control correction voltage"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00096D6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uDiffUp
    "Input of actuator voltage governor"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000024C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uUp
    "Voltage setpoint up-level"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000025A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uUpMapIn_mp
    "input for IVCtl_iDisCh_MAP"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C52

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uUpOBDMax_mp
    "Upper OBD-limit of Up-voltage monitoring"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C56

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uUpOBDMin_mp
    "Lower OBD-limit of Up-voltage monitoring"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C58

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uUpStrt
    "Start-up voltage of piezo actuator"
    SWORD
    Vltg_PA
    1
    100
    0.00
    210.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000258

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uUpUnCor_mp
    "Uncorrected voltage setpoint up-level"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00096E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVCtl_uUpUnLim_mp
    "Unlimited voltage setpoint up-level"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00096EE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_ctDebShCirChSwt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C6E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_numTstLeft_mp
    "Number of test activations left for IVDia_Tst"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C60

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_st
    "Message for detecting multiple open load errors"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007C9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stChkShCirChSwt
    "State: Progress of charge switch short circuit detection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007CA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stClctComplInvldCyl_mp
    "Bit of complete diagnostic information is invalid"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009706

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stCylSync_mp
    "State of cylinder specific synchronization of diagnostic information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009712

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stDFCPtt_mp
    "Error which goes to DFC paatern"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009718

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stErrClctChp_mp
    "collect chip errors"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009724

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stErrClctComplCyl_mp
    "Complete low level error message preprocessed for CY33x per cylinder"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009726

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stErrClctPsIcCyl_mp
    "Measurment point of error pattern which collect error of PsIc"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009732

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stErrCyl_mp
    "cylinder specific diagnostic information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000973E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stOnlyNeedPsIc_mp
    "Measurment point of bit mask which shows error pattern which detected by collect error of PsIc"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C5E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stPsIcChp
    "chip spec. diagnostic information of SPI transition and control byte"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00005A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stPsIcCyl
    "Cylinder spec. error from PsIc diagnostic register"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007CB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stPsIcMICyl
    "Cylinder specific diagnose information of PsIc on main injection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007D1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stRlsDFCRecgCompl_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009744

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stRlsDFCRecgPsIc_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000974A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stRlsErrRecgCompl_mp
    "Release of error recognition of complete diagnostic information"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009750

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stRlsErrRecgPsIc_mp
    "Release of error recognition of PsIc diagnostic information"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000975C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stShCirChSwt
    "State: short circuit on charge switch detected"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007D7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTst
    "State of short circuit and open load test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstActv
    "state: request for activation of short circuit and open load test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007D9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstBnkShCir
    "state: short circuit on bank detected by IVDia_Tst"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007DA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstBnkShCirChSwt
    "state: IVDia_Tst detected short circuit on charge switch (bank specific)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007DB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstChp
    "state: IVDia_Tst detected error on given chip"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstCylNoCls
    "state: IVDia_Tst detected non classifable error on given cylinder"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007DD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstCylNoLd
    "state: open load detected by IVDia_Tst (cylinderspecific)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007DE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstCylShCir
    "state: IVDia_Tst detected short circuit on given cylinder"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007DF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstCylShCirHSLS
    "state: IVDia_Tst detected highside-lowside short circuit on given cylinder"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstCylShCirMeas
    "state: IVDia_Tst detected short circuit on given cylinder (based on actuator voltage measurement)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007E1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stTstPreCond_mp
    "state: release conditions for IVDia_Tst"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stUPlausBnk
    "bank specific state of voltage plausibility"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00007E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_stUPlausCyl
    "cylinder specific voltage plausibility"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00007E3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_tiEval_mp
    ""
    UWORD
    OneToOne_ms
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0009768

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_tiMIPsIc
    ""
    UWORD
    OneToOne_ms
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00005A6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_uMonShCirChSwt_mp
    ""
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009774

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVDia_uThres_mp
    "thres hold of plausibility check of actuator voltage"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0009776

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_cntNSyncS0_mp
    "internal counter for static interrupt"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_cntNSyncS1_mp
    "internal counter for dynamic interrupt"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_cntSegDwnRunUpTst
    "number of segments for run down phase of run up test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00005B2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_cntSegUpRunUpTst
    "number of segments for run up phase of run up test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00005B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_cntSeg_mp
    "segment counter of run up test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C68

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nCyl
    "cylinder specific engine speed"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000026C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nEngDiffComprTst
    "Deviation in the average engine speed across tow cycles"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000278

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nEngDiffComprTst_mp
    "Deviation in the average engine speed across two engine cycle"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C62

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nHiDwnRunUpTst
    "engine speed at the beginning of run down phase of run up test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000027A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nHiUpRunUpTst
    "engine speed at the end of run up phase of run up test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000027C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nLoDwnRunUpTst
    "engine speed at the end of run down phase of run up test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000027E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nLoUpRunUpTst
    "engine speed at the beginning of run up phase of run up test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000280

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nMinComprTst
    "Minimum engine speed for the compression test to run"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000282

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nMinRunUpTst
    "minimum threshold of engine speed to release run up test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000284

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_nStrtRunUpTst
    "speed threshold for start of run up phase of run up test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000286

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_numMn2PrevTDCComprTst_mp
    "Number of TDC's for angle interval before TDC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_numPi2PrevTDCComprTst_mp
    "Number of TDC's for angle interval after TDC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_numShOffCyl
    "number of shut off cylinder"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_phiMI1DesRunUpTst
    "desired SOE angle-component of main injection 1 during run up test"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000028A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_phiMn2PrevTDCComprTst_mp
    "Angle between the current position and the point of measurement"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C64

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_phiPi2PrevTDCComprTst_mp
    "Angle between the current position and the point of measurement"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C66

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_phiPiI1DesRunUpTst
    "desired SOE angle-component of pilot injection 1 during run up test"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000028C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_phiPiI2DesRunUpTst
    "desired SOE angle-component of pilot injection 2 during run up test"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000028E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_phiPreTDCComprTst1
    "Farthest angle before TDC"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000290

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_phiPreTDCComprTst2
    "Nearest angle before TDC"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000292

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_phiPstTDCComprTst3
    "Farthest angle after TDC"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000294

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_phiPstTDCComprTst4
    "Nearest angle after TDC"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000296

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_pSetPntRunUpTst
    "rail pressure during run up test"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD0000288

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_qFBCCyl
    "cylinder specific fuel mass correction by the fuel balance control"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0000298

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_qPiI1DesRunUpTst
    "measured desired quantity of pilot injection 1 during run up test"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_qPiI2DesRunUpTst
    "measured desired quantity of pilot injection 2 during run up test"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002A6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_qSetUnBalLimRunUpTst_mp
    "limited injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C6A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_qSetUnBalRunUpTst
    "current injection quantity for run up test"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00002A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_rEGRVlvRunUpTst_mp
    "measurement point of ratio of EGR valve during run up test"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C6C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_rThrVlvRunUpTst_mp
    "measurement point of ratio of throttle valve during run up test"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C6E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_rTrbChRunUpTst_mp
    "measurement point of ratio of turbo charger during run up test"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_stEffectComprTst
    "status bits for external interventions in other modules"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007F1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_stEffectRunUpTst
    "bitledge of interventions into other modules during run up test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00005B6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_stInjCharRunUpTst
    "status of characteristic of injections during run up test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_stModeRunUpTst_mp
    "shows the current mode of the run up test ( 0: old 1:new )"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_stRefComprTst
    "status of refused compression test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00005B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_stRefRunUpTst
    "status of a refused run up test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00005BA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_stStMNSyncComprTst
    "state of statemachine of compression test n synchron"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007F3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_stStMRunUpTst
    "state of statemachine of run up test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_stStMTSyncComprTst
    "state of statemachine of compression test time synchron"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007F5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_swtSrcPSComprTst_mp
    "switch which source of dataset is used"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_swtSrcPSRunUpTst_mp
    "measurement point which shows the source of parameters used for run up test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_tiDwnRunUpTst
    "time for run down phase of run up test"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_tiEvalComprTst_mp
    "evaluation time of compression test"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD40019C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_tiEvalRunUpTst_mp
    "measurement point for evaluation time of run up test"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD40019CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_tiPiI1DesRunUpTst
    "desired SOE time-component of pilot injection 1 during run up test"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00002AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_tiPiI2DesRunUpTst
    "desired SOE time-component of pilot injection 2 during run up test"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00002AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_tiPreTDCComprTst
    "Array of captured time for applicated angles before TDC"
    SLONG
    OneToOne_us
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00042EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_tiPstTDCComprTst
    "Array of captured time for applicated angles after TDC"
    SLONG
    OneToOne_us
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0004304

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_tiUpRunUpTst
    "time for run up phase of run up test"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPlaus_tiWaitRunUpTst_mp
    "measurement point for waiting time to get a stabil rail pressure during run up test"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001C72

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_stIntegAdjRet
    "return state of integrator adjustment"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00007E9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_stIntegAdjStM
    "state of integrator adjustment"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007EA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_stIntegAdjVld
    "valid state of integrator adjustment"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00007EB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_tiIntegAdj
    "time stamp of integrator adjustment"
    ULONG
    OneToOne_ms
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_tiIntegRC
    "RC time constant for charge calculation"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000266

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_uIntegOfs
    "voltage offset of integrator"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000268

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_uIntegWrkPnt
    "work point voltage of integrator"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000026A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_uRawIntegClb_mp
    "Calibration raw value of integrator"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000977E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_uRawIntegLin_mp
    "Input point of calibration curve IVPSIC_uIntegLin_CUR"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_uRawIntegWrkPnt_mp
    "work point raw value of integrator"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009780

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSIC_uRawIntegZr_mp
    "Zero raw value of integrator"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009782

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSply_stBufErr
    "state: buffer capacitor of bank not loaded (bit coded)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSply_stDCDCCo
    "state: charging of dc/dc converters"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007ED

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSply_stDCDCStop
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00007EE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSply_stDCDCStrtLckd
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00007EF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSply_tiDCDCChrg_mp
    "measured charge time of buffer capacitors"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001C78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSply_uBufRaw_mp
    "raw ADC buffer voltage value for IVPSply_uBufLin_CUR"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C76

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    IVPSply_uBuf_mp
    "Measurement point of the buffer voltage"
    SWORD
    Vltg_PA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009784

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_bpPlausSetPoint_mp
    "Bit positions for engine operating conditions - full load, part load, over run"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091AF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_ctHtCoup
    "Number of times for which LSU_uO2FltRippel_mp should be above threshold, for detecting as heater coupling check error"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00005CA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_ctMeasPresComp_mp
    "Number of measure samples for adaptive pressure compensation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097D6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_ctRegrPresVltg_mp
    "sumXY - (1/n).sumX.sumY"
    SLONG
    VoltPres_HiRes
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_ctStdTempAdap
    "Adaptation counter"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000081F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_ctWaitPresComp_mp
    "wait counter for adaptive pressure compensation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_d2rO2Eval_mp
    "Maximum of evaluation filter (positive and negative) output"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_d2rO2_mp
    "Difference of filtered and unfitered difference between 21% and actal O2 ratio. Used as evaluation filter input."
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycDT1_mp
    "Measuring point for the DT1(differential) component of heater duty cycle"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097B6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycHt
    "Governor output duty cycle for LSU heater"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003E6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycHtCor
    "Battery voltage corrected duty cycle for heater power stage"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycHtCoupStp1
    "Heater duty cycle recorded during 1st sample of heater coupling check"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003DE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycHtCoupStp2
    "Heater duty cycle recorded during 2nd sample of heater coupling check"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycHtIniRmp
    "Starting duty cycle of the heater ramp"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00003E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycHtStrt
    "Duty cycle output from the heater ramp"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycI_mp
    "Measuring point for the integral component of heater duty cycle"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycLimActHt
    "Limitation of battery voltage corrected duty cycle to heater."
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycP_mp
    "Measuring point for the proportional component of heater duty cycle"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097BA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dcycRippel_mp
    "Change of heater dutycycle between first (just before heater OFF) & second sample (before heater ON again) of heater coupling check"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009794

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dHtCoupStepLast
    "Value of shifting register in the last cycle for heater coupling check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000820

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dHtCoupStp
    "Value of shifting register in this cycle during heater coupling check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000821

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dmEGFldHtCtl_mp
    ""
    SWORD
    AirMassPerTime
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C82

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dnEngSpdAbsFlt_mp
    "Absolute filtered gradient of engine speed"
    SWORD
    EngNGrd
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C92

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_dpExhGsAbsFlt_mp
    "Absolute filtered gradient of exhaust gas pressure"
    SWORD
    PreshPa_sec
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097DE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_drO2Adap
    "Correction value (O2 difference) learnt during over run"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_drO2AdapLoTemp
    "Correction value (O2 difference) learnt during over run at low temperature setpoint"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003EA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_drO2Flt_mp
    "Adaption filter output (filtered difference between 21% and actal O2 ratio)"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097A6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facO2CorLoTemp_mp
    "Correction factor of adaptation at low temperature"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facO2CorStdTemp_mp
    "Correction factor of adaptation at standard temperature"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facO2Cor_mp
    "Correction factor for adaptation of O2"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facO2TempCor_mp
    "Temperature compensation factor of lambda sensor"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097AE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facPresCompAdap
    "Adaptive factor of pressure compensation"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003EE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facPresCompAdapMul_mp
    "1-2mp_x-sqrt(1-4mp_x(1-p_x/p_0))"
    SWORD
    lambda
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facPresComp_mp
    "Measuring point for the pressure compensation factor (from the correction MAP output)"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facTempCompNom_mp
    ""
    UWORD
    Fact
    1
    100
    0.00
    7.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facTempComp_mp
    ""
    UWORD
    Fact
    1
    100
    0.00
    7.999878

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097B2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_facUCor_mp
    "Battery voltage correction factor for heater duty cycle"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001C7A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_mAirAftOvrRun
    "Air mass accumulated during adaption"
    SWORD
    AirMass_2
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00003F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_mAirPlausChk
    "Airmass accumulated in the current engine operating point for enabling O2 plausibility test (single flow)"
    SWORD
    AirMass_2
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numArgSqrt_mp
    "Input to the square root"
    SWORD
    Fact_10000
    1
    100
    -3.276800
    3.276700

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001C94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numBefSqrPresComp_mp
    "4.m.p_x(1-p_x/p_0)"
    SWORD
    Fact_10000
    1
    100
    -3.276800
    3.276700

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numCoefRegr_mp
    "Correlation coefficient R²"
    SWORD
    Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097E6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numDenomRegrPres_mp
    "sumX2 - (1/n).(sumX)2"
    SLONG
    PreshPa_Sq
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numDenomRegrVltg_mp
    "sumY2 - (1/n).(sumY)2"
    SLONG
    Volt_Sq_HiRes
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numGradPresCompAdap_mp
    "Normalized gradient 'm' (pressure sensitivity)"
    SLONG
    PresInv_hPa
    1
    100
    -214.748364800
    214.748364700

    
    FORMAT "%13.9"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numGradRegr_mp
    "Gradient 'a' of linear regression"
    SWORD
    Volt_per_Pres
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numMaxCmpChk_mp
    "Maximum number of comparison checks"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numOfsRegr_mp
    "Ordinate 'b' of linear regression"
    SLONG
    Volt_FnReso2
    1
    100
    -2147483.64800
    2147483.64700

    
    FORMAT "%13.5"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numRegr_mp
    "Number n of the regression"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numSqrPresComp_mp
    "sqrt(1-4.m.p_x(1-p_x/p_0))"
    SWORD
    Fact_10000
    1
    100
    -3.276800
    3.276700

    
    FORMAT "%8.6"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097FE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numSumCntPresSq_mp
    "(1/n).(sumX)2"
    SLONG
    PreshPa_Sq
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009800

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numSumCntPresVltg_mp
    "(1/n).sumX.sumY"
    SLONG
    VoltPres
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009804

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numSumCntVltgSq_mp
    "(1/n).(sumY)2"
    SLONG
    Volt_Sq
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009808

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numSumRegrPresSq_mp
    "sum X*X"
    SLONG
    PreshPa_Sq
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000980C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numSumRegrPresVltg_mp
    "sum X*Y"
    SLONG
    VoltPres
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009810

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numSumRegrPres_mp
    "sum X"
    SLONG
    PreshPa_FnReso
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009814

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numSumRegrVltgSq_mp
    "sum Y*Y"
    SLONG
    Volt_Sq
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009818

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_numSumRegrVltg_mp
    "sum Y"
    SLONG
    Volt_FnReso1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000981C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_pExhGasLstVal_mp
    "Exhaust gas back pressure, only for curve input axis reference"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C96

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_pExhGsAvrg_mp
    "Mean measured exhaust gas pressure"
    SWORD
    PreshPa_FnReso
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009820

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_pExhGs_mp
    "Exhaust gas pressure at the lambda sensor location"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009822

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_pKPresCompAdap
    "Adaptive pressure compensation value for LSU"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_pKRegrAdapUnLim_mp
    "Unlimited adaptive pressure compensation value for LSU"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009824

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_pPresCompAdapMul_mp
    "p_0/[2(m.p_0 - 1)]"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009826

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_pRegrPresAvrg_mp
    "Mean value of Xi"
    SLONG
    PreshPa_HiRes
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009828

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_pSumExhGsMeas_mp
    "Sum of pExhGs in one measure phase"
    SLONG
    PreshPa_FnReso
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000982C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_qStrt_mp
    "Start value of the injected fuel quantity in LSU Dynamics check"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C8A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_resRi
    "Lambda sensor internal resistance value"
    SWORD
    Resist
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000412

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_resRiClb
    "Actual Ri calibration value, frozen by Ri calibration errors"
    SWORD
    Resist
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000408

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_resRiClbRaw_mp
    "Raw Ri calibration value"
    SWORD
    Resist
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000978E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_resRiDvt
    "Ri calibration value after limitation and filtering"
    SWORD
    Resist
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000040A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_resRiHtCoupStp1
    "First sample of internal resistence during heater coupling check"
    SWORD
    Resist
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000040C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_resRiHtCoupStp2
    "Second sample of internal resistence during heater coupling check"
    SWORD
    Resist
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000040E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_resRiRaw
    "Raw resistance of LSU before filtering"
    SWORD
    Resist
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000410

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_resRiRippel_mp
    "Change of Ri Signal between first & second sample during heater coupling check"
    SWORD
    Resist
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009796

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_resRi_mp
    "Just for curve axis reference used in resistance to temperature conversion"
    SWORD
    Resist
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C7E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rLam
    "Lambda value measured from LSU"
    SWORD
    lambda
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rLamRec
    "Reciprocal lambda value measured from LSU"
    SWORD
    lambdaRecVal
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003F6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rNrmPresAvrg_mp
    "1 - p_x/p_0"
    SWORD
    Fact1000
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009830

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2Act
    "Actual oxygen value whithout filter and without freeze, only offset compensated"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003FA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2Adap
    "Adapted O2 ratio after over run correction"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2AdptLastLSU_mp
    "Only for curve axis reference"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    
    ECU_ADDRESS 0xD4001C80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2Calc_mp
    "Actual O2 concentration calculated from air mass & injection quantity"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    
    ECU_ADDRESS 0xD4001C8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2DiffCmpChk_mp
    "Measuring point to store O2-difference of a sensor pair"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097BE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2DvtNeg_mp
    "Negative allowed deviation from calculated O2 concentration"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    
    ECU_ADDRESS 0xD4001C8E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2DvtPos_mp
    "Positive allowed deviation from calculated O2 concentration"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    
    ECU_ADDRESS 0xD4001C90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2FrstValCmpChk_mp
    "O2-concentration of the first sensor of the difference check"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2PresComp
    "Pressure compensated O2 ratio"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00003FE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2PresTempComp
    "Temperature and pressure compensated O2 concentration"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000400

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2Raw
    "Raw Oxygen value, after filtering and frozen by oxygen not valid status"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000404

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2RawFlt_mp
    "Filtered value of LSU_rO2Raw used in detecting lambda=1 condition"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009786

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2RawTempComp
    "Temperature compensated raw O2 concentration"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000402

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2SecValCmpChk_mp
    "O2-concentration of the second sensor of the difference check"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097C2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2SignDyn_mp
    ""
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2Stat
    "Calculated O2 concentration filtered through PT1 filter. Filter constant depends on sensor position in exhaust path."
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000406

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2Thres1_mp
    "30% rise in the O2 concentration from over run detection in dynamics check"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097C6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rO2Thres2_mp
    "60% rise in the O2 concentration from over run detection in dynamics check"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rOutHWE_mp
    "Duty cycle to HWE (LSU heater)including tester demand"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000978A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_rPresAvrg_mp
    "p_x/p_0"
    SWORD
    Fact1000
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009832

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stActv_mp
    "Instrument for LSU adaption state machine"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091AB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stAdap
    "Status whether over run learning result is already present"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000823

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stAdapActv
    "Adaption activation status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000822

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stCalcSqr_mp
    "Status of square root calculation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009834

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stChkDyn_mp
    "Measuring point to show which O2 conc threshold is reached during dynamics check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097CA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stChng
    "Status whether in the current driving cycle a new learning result has already been generated."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000824

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stCirModeNew
    "Latest CJ125 mode status written to INIT1/INIT2 registers"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00005CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stClbTrg_mp
    "Measuring point to monitor LSU calibration trigger status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stCldSensDiaActv
    "Status to enable SCB check at IA/IP for a cold sensor"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000825

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stCmpChkCon_mp
    "Measuring point to check whether the other diagnostic checks are done before carrying out difference check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097CB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stCmpChk_mp
    "Status whether comparison check is completed"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stCmpErr_mp
    "Status whether difference check error occurred"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097CD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stDebBattHi_mp
    "Measuring point for debounced state of battery above threshold check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stDebOvrRun_mp
    "Debounced state for over run state of the vehichle"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091A9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stDiaIAEna
    "Status variable to SET SET_DIA_Q bit in CJ125"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000827

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stDiaReg_mp
    "Content of diagnostic register of CJ125"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009788

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stDPFThmRgn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000826

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stDynPresCompAdap_mp
    "Status dynamic recognition (bit0 = exhaust gas pressure; bit1 = engine speed)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009835

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stDynState
    "Dynamics plausibility check state machine variable"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000828

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stEGRActvOvrn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000829

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stEGRActvPlausChk_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stErr
    "This bit coded variable indicates various errors which are currently set in LSU"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00005CE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stHold_mp
    "Status disturbance of the oxygen signal is present"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stHtcond_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000912A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stHtCoupActv
    "Status of heater coupling active flip-flop"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000082A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stHtCtl
    "Heater control status - bit coded"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000082B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stHtDis
    "Heater switch off status because of engine/battery conditions and permanent heater powerstage errors"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000082C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stHtDisbl
    "Heater disable request during shunting detection and heater coupling check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000082D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stIniClb
    "Status of first calibration after ECU start"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000082E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stIpHiCurrEna
    "status Bit for setting 40uA ON"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000082F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stIpNrmCurrEna
    "status Bit for setting 20uA ON ) , CType(uint8[ctNumberOfSensors]"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000830

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stIsolChkActv
    "Status whether shunting detection is active or not"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000831

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stIsolChkO2Last
    "Status of whether O2 concentration is within a predefined window during shunting detection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000832

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stNotOpPoint1_mp
    "Measuring point to monitor the status of engine operating point1 where LSU calibration is released. When set indicates that operating point is not satisfied."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091AD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stNotOpPoint2_mp
    "Measuring point to monitor the status of engine operating point2 where LSU calibration is released. When set indicates that operating point is not satisfied."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091AE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stO2Act_mp
    "Status of O2 validity affected by O2 calibration status and LSU errors"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000978C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stO2Chk
    "Bit coded status message to display whether a particular diagnostic routine has been executed or not"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00005D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stO2ClbEna
    "O2 calibration enable status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000833

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stO2Clb_mp
    "State of O2 calibration sequence"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stO2Err
    "Bit coded status message to display result of the daignostics routines - error/no error"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00005D2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stO2IntValid
    "O2 signal valid to be used inside LSU software"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000834

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stO2SPICalDem
    "Demand to CJ125 to activate calibration mode of oxygen signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000835

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stOpnErrIP
    "Test active (1st bit) and error detected (0th bit) status open circuit detection at IP"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000836

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stOpnLdTstActv
    "Status of Open load test active at UN and VG pins"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000837

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stPlausChk
    "Result of the O2 plausibility check in the current operating point"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000839

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stPlausChkCon
    "Bit coded variable to indicate steady state detection and O2 plausibility enabled in the current engine operating point."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000838

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stPmpCtl
    "status of oxygen pump current"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000083A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stPmpEna
    "Trigger for enable of pump current during shunting detection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000083B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stPOpCmpChk_mp
    "Status to indicate that engine is in the currenty applied operating region for difference check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stPresCompAdap
    "Release status for pressure compensation adaptation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000083C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRdcRegrPresVltg_mp
    "State for reduction caused by sumXY"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009836

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRdcRegrPres_mp
    "State for reduction caused by sumX²"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009837

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRdcRegrVltg_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009838

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRecValEval_mp
    "Status indicating whether recorded values shall be evaluated"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009798

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRefCurrTrans_mp
    "Instrument for LSU reference pump current status transition (high current to low current and vice versa)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009844

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRefPmp
    "status of reference pump currents"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000083E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRefPmpDis
    "Status variable to disable reference pump current in case of SCG of sensor lines"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000083D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRegrPresCompAdap
    "Status adaptive pressure compensation factor (1 = active)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000083F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRegrPresComp_mp
    "Activation status of adaptive pressure compensation (bit coded)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009839

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRegr_mp
    "State of adaptive pressure compensation"
    UBYTE
    Lsu_PresComp_St
    1
    100
    1.00000000000
    4.00000000000

    
    FORMAT "%13.11"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000983A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRiClb
    "State machine for Ri calibration sequence"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000840

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRiClbEna
    "Ri calibration enable status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000841

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRiSPICalDem
    "Demand to CJ125 to activate calibration mode for Ri"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000842

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRiValid
    "Valid status of LSU inner Resistance"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000843

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stRmp
    "Status of LSU heater ramp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000844

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stSCUNEna
    "Status whether short circuit to battery detection at UN can be carried out"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000845

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stSPIIniVal_mp
    "Value read from CJ125 INIT1/INIT2 registers"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009792

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stSrvTstDem
    "Bit coded status for LSU service test diagnosis active"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00005D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stTmrClbPerRun
    "Status of calibration timer running/or not"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000846

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stTstTrigger_mp
    "Trigger status of shunting detection test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009799

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stWireDiaChk_mp
    "Status whether heater coupling check (bit0) and shunting detection (bit1) are done in the driving cycle"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000979A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_stWireDiaErr_mp
    "Results of the heater coupling check (bit0) and shunting detection (bit1). Set bit means error."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000979B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_swtAdap
    "Switch to activate adaptation function"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000847

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_swtEna
    "Status message for enabling or disabling the whole LSU DE function"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000848

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_tAirStrt_mp
    "Measuring point to store Air temperature at start"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_tDvt
    "Deviation of sensor temperature from the setpoint"
    SWORD
    TempDiff_Kelv
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000414

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_tEGFldHtCtl_mp
    ""
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C86

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_tiState1_mp
    "Measuring point to store transition time from CHECK-OP-POINT to WAIT-FOR-OVERRUN during dynamics check"
    UWORD
    Time_s
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097CE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_tiState2_mp
    "Time to reach 30% to 60% expected rise in O2 concentration during dynamics check"
    UWORD
    Time_s
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_tiState3_mp
    "Time between over run detection and 60% rise in O2 concentration during dynamics check"
    UWORD
    Time_s
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097D2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_tiState4_mp
    ""
    UWORD
    Time_s
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_tRi
    "Temperature of lambda sensor"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000418

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_tRiCurrSetP
    "Current setpoint temperature of the sensor"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000416

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uHtBattPT1Flt_mp
    ""
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001C88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uHtPerfBattMin_mp
    ""
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2Clb
