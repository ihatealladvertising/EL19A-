		Cbx_on_pwst_cor_cfm
		"Inhibition boolean of the condition on the power steering  manostat activation for the detection of a engine speed hook"
		VALUE
		0x8005aa68
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_on_pwst_cor_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ovh_temp_cfm
		"air or oil temperature for over heating protection"
		VALUE
		0x8005b8b6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ovh_temp_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ovn_n_clu_det_cfm
		"Choice of enabling calculation strategy"
		VALUE
		0x8005885c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ovn_n_clu_det_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_avl
		"Calibration to send on can when the function is  off"
		VALUE
		0x80059114
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_avl 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_avl_2
		"Calibration to send on can when the function is  off"
		VALUE
		0x80059113
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_avl_2 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_schxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_cfm
		"OCS inhibition parameter"
		VALUE
		0x80058502
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_owe_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_dil_req_2_ena
		"Calibration to enable the dasboard alert on dilution condition"
		VALUE
		0x80059112
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_dil_req_2_ena 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_ena_1
		"Calibration of the output bits truth table"
		VALUE
		0x80059111
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_ena_1 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_ena_2
		"Calibration of the output bits truth table"
		VALUE
		0x80059110
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_ena_2 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_ena_3
		"Calibration of the output bits truth table"
		VALUE
		0x8005910f
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_ena_3 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_ena_4
		"Calibration of the output bits truth table"
		VALUE
		0x8005910e
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_ena_4 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_ena_5
		"Calibration of the output bits truth table"
		VALUE
		0x8005910d
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_ena_5 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_ena_6
		"Calibration of the output bits truth table"
		VALUE
		0x8005910c
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_ena_6 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_ena_7
		"Calibration of the output bits truth table"
		VALUE
		0x8005910b
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_ena_7 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_ena_8
		"Calibration of the output bits truth table"
		VALUE
		0x8005910a
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_ena_8 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_schxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_hmi_warn
		"Choice manager of alert pre-alert hmi"
		VALUE
		0x8004014f
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_hmi_warn 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owrstcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_mnl_ini_req_ena
		"Calibration to forbid the use of manual init by pedals (to use the can information)"
		VALUE
		0x8006b22a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_owe_mnl_ini_req_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_sat_ena
		"Calibration to enable the saturation made by the initial potential kilometer"
		VALUE
		0x800590f0
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_owe_sat_ena 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_owe_toil_tco
		"Calibration to choose between Oil and Colant temperature (0 is for oil)"
		VALUE
		0x8006b1f8
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_owe_toil_tco 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_perf_ac_dsb_cfm
		"Activation of performance restitution strategy for air conditioning"
		VALUE
		0x8005cdc1
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_perf_ac_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_perf_ptc_dsb_cfm
		"Activation of performance restitution strategy for PTC"
		VALUE
		0x8005cdc0
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_perf_ptc_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_perf_thpl_dsb_cfm
		"Activation of performance restitution strategy for coolant heaters"
		VALUE
		0x8005cdbf
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_perf_thpl_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_agb_req_ena
		"Boolean to enable the stategy to activate the automatic gearbox request for regeneration"
		VALUE
		0x8004712e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_agb_req_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_asd_utp_sp_swt
		"Switch for CSF up temp set point value"
		VALUE
		0x80045d12
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_asd_utp_sp_swt 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_clc_mod_efy
		"Boolean used to choose the calculation for the CSF efficiency"
		VALUE
		0x8005806e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_clc_mod_efy 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_clos_rgn_swi
		"Switch to disable the activation of flag indicating conditions near CSF regeneration"
		VALUE
		0x80046d17
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_clos_rgn_swi 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_cold_rgn_ena_act
		"Boolean which permits to desactivate the cold regeneration unauthorized in case of maximum failure"
		VALUE
		0x80046b9b
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_cold_rgn_ena_act 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_comb_ena_stt
		"Boolean authorizing the reset of soot mass after partial regeneration"
		VALUE
		0x80067f80
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_comb_ena_stt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_comb_mdl_ini_swi
		"Particulate filter combustion model switch."
		VALUE
		0x80046b67
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_comb_mdl_ini_swi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnsucx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ctr_rgn_rst
		"Boolean authorizing the reset of rgn success counters (hot and cold conditions)"
		VALUE
		0x80046cf8
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ctr_rgn_rst 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_diag_obd_cfm
		"Calibration data for hidden OBD management"
		VALUE
		0x80045fe0
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_diag_obd_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_dil_toil_dfl_val_cfm
		"Switch which permits to choose between the oil temperature model or the replacement value in case of default"
		VALUE
		0x8005526d
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_dil_toil_dfl_val_cfm 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_dist_min_suc_act
		"Boolean to disable condition for reseting regeneration failure and mileage counters"
		VALUE
		0x80046b9a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_dist_min_suc_act 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_doc2_pres_cfm
		"Doc2 configuration choice"
		VALUE
		0x8005825c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_doc2_pres_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_dprscsx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_dp_sens_prs_cfm
		"a_in_ati_pfi_dprscs/Switch for particulate filter pressure sensor type (upstream or differential) configuration"
		VALUE
		0x80057df7
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_dp_sens_prs_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_dsb_ms
		"Calibration data (by default to 1) for disabling soot mass corrected contribution in the OBD diag"
		VALUE
		0x80046436
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_dsb_ms 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_dtp_clc_ena
		"Switch disabling the CSF downstream temp calculation"
		VALUE
		0x8004588e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_dtp_clc_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_dtp_mes_ena
		"Boolean enabling the CSF downstream temp measure"
		VALUE
		0x8004588d
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_dtp_mes_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitdf_dtempcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_dtp_pres_cfm
		"Configuration switch if downstream temperature sensor is present"
		VALUE
		0x80058328
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_dtp_pres_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_efi_inj_rgn_ena
		"Boolean to enable regeneration if efi injection fail"
		VALUE
		0x8004712d
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_efi_inj_rgn_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_efi_off_pr_cfm
		"Manuel configuration between DOC2 up temperature and CSF up temperature"
		VALUE
		0x80067ed6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_efi_off_pr_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_eng_rest_stt_ms_lft_frz
		"Enable freeze of Vxx_pft_ms_lft at Vxx_pft_ms_lft_mem value in case of regeneration restart"
		VALUE
		0x80046b66
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_eng_rest_stt_ms_lft_frz 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_eng_sp_forc_rgn_ms_ena
		"Switch to enable forced regeneration when conditions on soot mass are reached"
		VALUE
		0x80046b99
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_eng_sp_forc_rgn_ms_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_eng_sp_max_ena
		"Bool to enable the reset of automaitc gearbox request for regeneration function engpop"
		VALUE
		0x8004712c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_eng_sp_max_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_eng_sp_max_ena2
		"Bool to enable the reset of automaitc gearbox request for regeneration function engpop in cond 2"
		VALUE
		0x8004712b
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_eng_sp_max_ena2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ext_temp_swi
		"Switch of external temperature configuration"
		VALUE
		0x80046950
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ext_temp_swi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_hot_rgn_ena_act
		"Boolean which permits to desactivate the hot regeneration unauthorized in case of maximum failure"
		VALUE
		0x80046b98
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_hot_rgn_ena_act 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_lim_dir_eng_stop_act
		"Boolean to disable direct torque limitation on engine stop"
		VALUE
		0x8004712a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_lim_dir_eng_stop_act 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_lpos_off_pr_cfm
		"Manuel configuration between DOC2 up temperature and CSF up temperature"
		VALUE
		0x80067eea
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_lpos_off_pr_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_map_wait_cdn_vld
		"Switch to disable the manifold pressure conditions on waiting mode activation"
		VALUE
		0x80047129
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_map_wait_cdn_vld 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_max_ms_tgt_ena
		"Boolean enabling soot mass target comparison for minimum distance"
		VALUE
		0x80046b97
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_max_ms_tgt_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_med_rgn_ena_act
		"Boolean which permits to desactivate the medium regeneration unauthorized in case of maximum failure"
		VALUE
		0x80046b96
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_med_rgn_ena_act 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_comb_swi
		"Switch of mass configuration"
		VALUE
		0x80046b65
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_comb_swi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_esti_ena
		"Boolean enabling Vxx_pft_ms_esti for the CSF up temp variable set point"
		VALUE
		0x8004588c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_esti_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_ini_mdl_comb_vld
		"Switch to disable soot mass left initial value validity indicator for soot combustion model"
		VALUE
		0x8004694f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_ini_mdl_comb_vld 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_lft_ena
		"Switch to select which soot mass estimation is used"
		VALUE
		0x8004588b
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_lft_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_ofs_act
		"Boolean for activation of msot offset learning strategy for cold start cond."
		VALUE
		0x8004668b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_ofs_act 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_ofs_swi
		"Boolean for activation of offset decrease computation with pressure(1)/combustion(0) model during regeneration"
		VALUE
		0x8004668a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_ofs_swi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_sim_ms_dp_cfm
		"Configuration switch indicating if simulated soot mass is taking account of the exhaust backpressure."
		VALUE
		0x80057e04
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_sim_ms_dp_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_thd_cold_rgn_ok
		"Switch to disable estimated soot mass conditions in cold conditions."
		VALUE
		0x80046b95
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_thd_cold_rgn_ok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_thd_hot_rgn_ok
		"Switch to disable estimated soot mass conditions in hot conditions."
		VALUE
		0x80046b94
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_thd_hot_rgn_ok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_thd_med_rgn_ok
		"Switch to disable estimated soot mass conditions in medium thermal conditions."
		VALUE
		0x80046b93
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_thd_med_rgn_ok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_ms_thd_spd_req_ok
		"Switch to disable minimum estimated soot mass conditions."
		VALUE
		0x80046b92
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_ms_thd_spd_req_ok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_o2_fac_vld_mdl_comb_vld
		"Switch to disable intake temperature validity indicator for soot combustion model."
		VALUE
		0x8004694e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_o2_fac_vld_mdl_comb_vld 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_oil_clc_ena
		"Calibration to disable condition on oil dilution computation"
		VALUE
		0x80068046
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_oil_clc_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_oil_dil_clc_ena
		"Switch to enable oil dilution computation"
		VALUE
		0x8005526e
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_oil_dil_clc_ena 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_pres_cfm
		"Calibration to authorize the ISR plausibility diagnosis"
		VALUE
		0x80057dca
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_pres_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_reg_act_true
		"Boolean enabling CSF up temp regulation even though late post injection command is cut-off = TRUE"
		VALUE
		0x8004588a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_reg_act_true 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_rgn_ok
		"Allows default initialization of soot mass left in the catalyst after a regeneration request"
		VALUE
		0x80046b64
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_rgn_ok 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_rgn_wio_dp_mod
		"Switch to choose emission model or distance to enable regeneration in case of ms_cor failure"
		VALUE
		0x80047128
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_rgn_wio_dp_mod 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_uprscsx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_sens_prs_cfm
		"Switch for particulate filter upstream pressure sensor configuration (1 : sensor present, 0 : no sensor)"
		VALUE
		0x80058104
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_sens_prs_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_spd_req_lght_ena
		"Boolean to disable condition on speed request light on"
		VALUE
		0x80067fab
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_spd_req_lght_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_swi_ms_comb_cfm
		"Calibration to choose between relative and absolute mass for status of combusted soot mass."
		VALUE
		0x80067faa
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_swi_ms_comb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_swi_ms_stop_cfm
		"Calibration to choose between relative and absolute mass for end of regeneration"
		VALUE
		0x80067fa9
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_swi_ms_stop_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_swi_sp_fil
		"Boolean to choose the last filtered values to initialize filters during the key on event"
		VALUE
		0x80068120
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_swi_sp_fil 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_tco_wait_cdn_vld
		"Switch to disable the coolant temperature conditions on waiting mode activation"
		VALUE
		0x80047127
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_tco_wait_cdn_vld 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_tia_cor_swi
		"Switch to select the way of computing mean value of inlet air temperature"
		VALUE
		0x80058101
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_tia_cor_swi 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_tia_mv_tenv_cfm
		"Switch to use environmental temperature if present"
		VALUE
		0x80058100
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_tia_mv_tenv_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_tia_vld_mdl_comb_vld
		"Switch to disable intake temperature validity indicator for soot combustion model."
		VALUE
		0x8004694d
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_tia_vld_mdl_comb_vld 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_toil_clc_swi
		"Configuration switch to choose between oil temperature and engine coolant temperature"
		VALUE
		0x8005526c
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_toil_clc_swi 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_dprscsx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_up_prs_sens_cfm
		"a_in_ati_pfi_uprscs/Switch for particulate filter upstream pressure sensor type (absolute or relative) configuration"
		VALUE
		0x80057df6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_up_prs_sens_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_utp_pull_up
		"with or without pull up"
		VALUE
		0x80058354
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_pft_utp_pull_up 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_utp_reg_actr_cho
		"Boolean enabling late post injection (=true) or exhaust fuel injection (=false)"
		VALUE
		0x80043d7d
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_utp_reg_actr_cho 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_vh_dist_thd_cold_rgn_ok
		"Switch to disable distance conditions in cold conditions."
		VALUE
		0x80046b91
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_vh_dist_thd_cold_rgn_ok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_vh_dist_thd_hot_rgn_ok
		"Switch to disable distance conditions in hot conditions."
		VALUE
		0x80046b90
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_vh_dist_thd_hot_rgn_ok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_vh_dist_thd_med_rgn_ok
		"Switch to disable distance conditions in medium thermal conditions."
		VALUE
		0x80046b8f
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_vh_dist_thd_med_rgn_ok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_vh_dist_thd_spd_req_ok
		"Switch to disable minimum distance conditions."
		VALUE
		0x80046b8e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_vh_dist_thd_spd_req_ok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_vs_vld_mdl_comb_vld
		"Switch to disable vehicule speed validity indicator for soot combustion model."
		VALUE
		0x8004694c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_vs_vld_mdl_comb_vld 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_wait_cdn_egr_cut
		"Boolean to activate egr cut off when waiting mode is requested by failures"
		VALUE
		0x80047126
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_wait_cdn_egr_cut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_wait_cdn_min_lvl
		"Boolean to disable waiting mode on minimum fuel level"
		VALUE
		0x80047125
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_wait_cdn_min_lvl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_wait_cdn_not_pft
		"Boolean to disable waiting mode on not present particulate filter configuration"
		VALUE
		0x80047124
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_wait_cdn_not_pft 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_pft_wait_mod_vh_dist_thd
		"Switch to enable the vehicle distance threshold for the choice of waiting mode strategy"
		VALUE
		0x80046d16
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_pft_wait_mod_vh_dist_thd 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_ptqxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ptq_ex_prs_mdl_ok_cfm
		"Exhaust manifold pressure model is considered sufficient to estimate pumping torque if the sensor is failing"
		VALUE
		0x800415e6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_ptq_ex_prs_mdl_ok_cfm 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_rbst_ptc_dsb_cfm
		"Activation of engine robustness strategy for PTC"
		VALUE
		0x8005cdbe
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_rbst_ptc_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_rbst_thpl_dsb_cfm
		"Activation of engine robustness strategy for coolant heaters"
		VALUE
		0x8005cdbd
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_rbst_thpl_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drtqexx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ref_max_pow_cfm
		"Option selecting explicit power calculation of driver torque setpoint"
		VALUE
		0x800597d7
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ref_max_pow_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_reg_cut_1_ovr_msk
		"Calibration mask for Vsx_reg_cut_1 in the overrun switch"
		VALUE
		0x80043b75
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_reg_cut_1_ovr_msk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_reg_cut_2_ovr_msk
		"Calibration mask for Vxs_reg_cut_2 in the overrun switch"
		VALUE
		0x80043b74
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_reg_cut_2_ovr_msk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_reg_cut_3_ovr_msk
		"Calibration mask for Vsx_reg_cut_3 in the overrun switch"
		VALUE
		0x80043b73
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_reg_cut_3_ovr_msk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_reg_cut_amp_dft_npu
		"Calibration for regulation shut-off on amp failure in npu mode"
		VALUE
		0x8006150a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_reg_cut_amp_dft_npu 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_reg_cut_pft_ms_dp_dft_npu
		"Calibration for regulation shut-off on pft mass failure in npu mode"
		VALUE
		0x80061509
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_reg_cut_pft_ms_dp_dft_npu 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_reg_cut_pft_ms_dp_dft_pp
		"Calibration for regulation shut-off on pft mass failure in pp mode"
		VALUE
		0x80061508
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_reg_cut_pft_ms_dp_dft_pp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_reg_cut_pft_ms_dp_dft_rij
		"Calibration for regulation shut-off on pft mass failure in rij mode"
		VALUE
		0x80061507
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_reg_cut_pft_ms_dp_dft_rij 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_reg_cut_tco_dft_npu
		"Calibration for regulation shut-off on tco failure in npu mode"
		VALUE
		0x80061506
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_reg_cut_tco_dft_npu 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_rps_bch_mod
		"Bench mode activation for rail pressure"
		VALUE
		0x80068efe
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_rps_bch_mod 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_rst_i_agb_down_shf
		"Reset integral part durnig a down shift with Automatic Gearbox"
		VALUE
		0x8005ece8
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_rst_i_agb_down_shf 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_rst_i_fedg_ex_prs_lim_ena
		"Enabling boolean of integral part initialisation on exhaust pressure limitation falling edge"
		VALUE
		0x8005ece7
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_rst_i_fedg_ex_prs_lim_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_rst_i_redg_ex_prs_lim_ena
		"Enabling boolean of integral part initialisation on exhaust pressure limitation rising edge"
		VALUE
		0x8005ece6
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_rst_i_redg_ex_prs_lim_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_run_eng_ena_inhi
		"Boolean enabling boost pressure diagnostic during engine stop requests"
		VALUE
		0x8005d059
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_run_eng_ena_inhi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_rupc_pres_cfm
		"Calibration to authorize the upstream pressure correction"
		VALUE
		0x800580c6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_rupc_pres_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_s06_fsys_cpt_old
		"(=1) Old fuel system diagnostic activated"
		VALUE
		0x80056d90
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_s06_fsys_cpt_old 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_sens_pft_prs_cfm
		"Calibration data for CSF pressure sensor configuration management"
		VALUE
		0x80045d8a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_sens_pft_prs_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dsbccxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_sl_eng_dsb_wal_1_req_cfm
		"Configuration bit for speed limiter deactivation by engine control on warning lamp level 1 request."
		VALUE
		0x80059178
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_sl_eng_dsb_wal_1_req_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_sl_max_i_cor
		"Enable (1) or disable (0) the ECE89 strategy"
		VALUE
		0x80040182
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_sl_max_i_cor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_sot_comb_stt_rst_ena
		"Enable/Disable reset of Vbx_pft_sot_comb_stt and Vbx_pft_sot_comb_esti_stt in case of regeneration restart"
		VALUE
		0x80067fa8
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_sot_comb_stt_rst_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_spc_cor_pr_cho
		"Boolean enabling the PID fuel quantity part for the pft regeneration"
		VALUE
		0x80043d7c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_spc_cor_pr_cho 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_spg_sens_pres_cfm
		"a_in_asi_iap_spgxxcs/ Presence of the boost pressure sensor"
		VALUE
		0x800576bc
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_spg_sens_pres_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_sta_thpl_dsb_cfm
		"Activation of engine start strategy for coolant heaters"
		VALUE
		0x8005cdbc
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_sta_thpl_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_stal_ac_dsb_cfm
		"Activation of anti-stall strategy for air conditioning"
		VALUE
		0x8005cdbb
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_stal_ac_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_stal_ac_max_tq_prop_cfm
		"Proportional torque limitation configuration in anti-stall strategy"
		VALUE
		0x8005cdba
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_stal_ac_max_tq_prop_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_stal_alt_dsb_cfm
		"Activation of anti-stall strategy for alternator"
		VALUE
		0x8005cdb9
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_stal_alt_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_stal_ptc_dsb_cfm
		"Activation of anti-stall strategy for PTC"
		VALUE
		0x8005cdb8
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_stal_ptc_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_stal_thpl_dsb_cfm
		"Activation of anti-stall strategy for coolant heaters"
		VALUE
		0x8005cdb7
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_stal_thpl_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_atpftou_xxxm3d_data.c' */
/begin CHARACTERISTIC
		Cbx_swi_pft_stat_stt
		"Switch to enable clog particulate filter failure display"
		VALUE
		0x8006b1fa
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_swi_pft_stat_stt 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_swlk_dsb
		"completely inhibits the immobilizer strategy for development purpose (on emulated ECM only)"
		VALUE
		0x8004336b
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_swlk_dsb 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_swlk_key_spc_req
		"indicates a specific request to learn the secret key without security tool"
		VALUE
		0x8004336a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_swlk_key_spc_req 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_swlk_req
		"set if immobilizer strategy is a base equipment"
		VALUE
		0x80043369
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_swlk_req 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1cs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tbo1_sens_pres_cfm
		"Configuration choice between temperature before doc1 sensor (1) and temperature before doc1 model (0)"
		VALUE
		0x8005812a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tbo1_sens_pres_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_sch100x_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tbt_act_off
		"Flag of regulation deactivation (1:regulation not authorized, 0:regulation authorized)"
		VALUE
		0x80047150
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tbt_act_off 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tbt_pull_up
		"with or without pull up"
		VALUE
		0x8005837c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tbt_pull_up 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tenv_sens_pres_cfm
		"Calibration for environmental air temperature sensor presence"
		VALUE
		0x800578d0
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_tenv_sens_pres_cfm 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_thpl1_not_ena_cfm
		"If output 1 is never commanded (no connection), then Cbx_thpl1_not_ena = 1"
		VALUE
		0x80059048
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_thpl1_not_ena_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_thpl2_not_ena_cfm
		"If output 2 is never commanded (no connection), then Cbx_thpl2_not_ena = 1"
		VALUE
		0x80059047
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_thpl2_not_ena_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_thpl3_not_ena_cfm
		"If output 3 is never commanded (no connection), then Cbx_thpl3_not_ena = 1"
		VALUE
		0x80059046
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_thpl3_not_ena_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_thpl_cut_ena
		"Enable thp cut"
		VALUE
		0x80059045
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_thpl_cut_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_thpl_diag_ena
		"THPL Diagnostic enable"
		VALUE
		0x80059091
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_thpl_diag_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_thpl_frz_ena
		"vf_emg_ctl_chgovxx/ Enable thp freeze"
		VALUE
		0x8005cf46
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_thpl_frz_ena 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_thr_on_off_cfm
		"Configuration calibration for on/off inlet throttle presence"
		VALUE
		0x80063c14
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_thr_on_off_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tkof_ac_dsb_cfm
		"Activation of takeoff strategy for air conditioning"
		VALUE
		0x8005cdb6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tkof_ac_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tkof_acs_dsb_rwhs_cfm
		"Rear wheel speed configuration in takeoff vehicle speed calculation"
		VALUE
		0x8005cdb5
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tkof_acs_dsb_rwhs_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tkof_alt_dsb_cfm
		"Activation of takeoff strategy for alternator"
		VALUE
		0x8005cdb4
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tkof_alt_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tkof_ass_driv_spt_fac_cfm
		"Option bit to enable sportivity criteria"
		VALUE
		0x800401f1
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tkof_ass_driv_spt_fac_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tkof_ass_ena_gear_cfm
		"Option bit to enable inibition of the strategy during Parking and Neutral gear position."
		VALUE
		0x800401f0
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tkof_ass_ena_gear_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tkof_ptc_dsb_cfm
		"Activation of takeoff strategy for PTC"
		VALUE
		0x8005cdb3
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tkof_ptc_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tkof_thpl_dsb_cfm
		"Activation of takeoff strategy for coolant heaters"
		VALUE
		0x8005cdb2
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tkof_thpl_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_cmd_typ_cfm
		"in_pci_agb_sdftaxx/Torque command type : 1 (new torque protocol) - Shift in progress : 0 (old torque protocol)"
		VALUE
		0x80058786
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_cmd_typ_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_egt_tq_lim_0_cfm
		"Activation of torque limitation on state nok of particulate filter torque limitation request validity status"
		VALUE
		0x8005b215
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_egt_tq_lim_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_egt_tq_lim_2_cfm
		"Activation of torque limitation on state fail_2 of particulate filter torque limitation request validity status"
		VALUE
		0x8005b214
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_egt_tq_lim_2_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_egt_tq_lim_3_cfm
		"Activation of torque limitation on state fail_3 of particulate filter torque limitation request validity status"
		VALUE
		0x8005b213
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_egt_tq_lim_3_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_ff_actr_0_cfm
		"Activation of torque limitation on state nok of fuel flow actuator validity status"
		VALUE
		0x8005b212
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_ff_actr_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_ff_actr_3_cfm
		"Activation of torque limitation on state fail_3 of fuel flow actuator validity status"
		VALUE
		0x8005b211
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_ff_actr_3_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_ff_actr_4_cfm
		"Activation of torque limitation on state fail_4 of fuel flow actuator validity status"
		VALUE
		0x8005b210
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_ff_actr_4_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_ff_fct_0_cfm
		"Activation of torque limitation on state nok of fuel flow regulation validity status"
		VALUE
		0x8005b20f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_ff_fct_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_ff_fct_4_cfm
		"Activation of torque limitation on state fail_4 of fuel flow regulation validity status"
		VALUE
		0x8005b20e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_ff_fct_4_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_ff_fct_5_cfm
		"Activation of torque limitation on state fail_5 of fuel flow regulation validity status"
		VALUE
		0x8005b20d
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_ff_fct_5_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_fprs_actr_cfm
		"Activation of torque limitation on fuel pressure actuator validity status"
		VALUE
		0x8005b20c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_fprs_actr_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_fprs_fct_0_cfm
		"Activation of torque limitation on state nok of fuel pressure regulation validity status"
		VALUE
		0x8005b20b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_fprs_fct_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_fprs_fct_3_cfm
		"Activation of torque limitation on state fail_3 of fuel pressure regulation validity status"
		VALUE
		0x8005b20a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_fprs_fct_3_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_fprs_fct_4_cfm
		"Activation of torque limitation on state fail_4 of fuel pressure regulation validity status"
		VALUE
		0x8005b209
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_fprs_fct_4_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_inj_0_cfm
		"Activation of torque limitation on state nok of injectors validity status"
		VALUE
		0x8005b208
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_inj_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_mpl_fail_cfm
		"Activation of torque limitation on multiple failure of fuel flow and fuel pressure regulations"
		VALUE
		0x8005b207
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_mpl_fail_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_sens_rail_prs_cfm
		"Activation of torque limitation on rail pressure sensor validity status"
		VALUE
		0x8005b206
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_sens_rail_prs_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_tbt_reg_0_cfm
		"Activation of torque limitation on state nok of temperature before turbine regulation validity status"
		VALUE
		0x8005b205
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_tbt_reg_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_tbt_reg_3_cfm
		"Activation of torque limitation on state fail_3 of temperature before turbine regulation validity status"
		VALUE
		0x8005b204
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_tbt_reg_3_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_tsta_0_cfm
		"Activation of torque limitation on state nok of electronically controlled thermostat validity status"
		VALUE
		0x8005b203
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_tsta_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_vs_ff_actr_0_cfm
		"Activation of vehicle speed limitation on state nok of fuel flow actuator validity status"
		VALUE
		0x8005b202
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_vs_ff_actr_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_vs_ff_fct_0_cfm
		"Activation of vehicle speed limitation on state nok of fuel flow regulation validity status"
		VALUE
		0x8005b201
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_vs_ff_fct_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_vs_ff_fct_5_cfm
		"Activation of vehicle speed limitation on state fail_5 of fuel flow regulation validity status"
		VALUE
		0x8005b200
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_vs_ff_fct_5_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_vs_fprs_fct_0_cfm
		"Activation of vehicle speed limitation on state nok of fuel pressure regulation validity status"
		VALUE
		0x8005b1ff
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_vs_fprs_fct_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_vs_mpl_fail_cfm
		"Activation of vehicle speed limitation on multiple failure of fuel flow and fuel pressure regulations"
		VALUE
		0x8005b1fe
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_vs_mpl_fail_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_lim_vs_sens_rail_2_cfm
		"Activation of vehicle speed limitation on state fail_2 of rail pressure sensor validity status"
		VALUE
		0x8005b1fd
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_lim_vs_sens_rail_2_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_rams_lim_act_3_bch_cfm
		"Activation of safety vehicle speed limitation converted in torque limitation level 3 (strong) bench mode"
		VALUE
		0x800431be
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_rams_lim_act_3_bch_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_trs_ctl_mux_cfm
		"Consideration of the information intersystem torque request (=0) or no (=1)"
		VALUE
		0x8005aab2
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_trs_ctl_mux_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tq_trs_ctl_mux_p_cfm
		"For minimal proportional saturation, consideration of the information intersystem torque request (=1) or no (=0)"
		VALUE
		0x8005acb8
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tq_trs_ctl_mux_p_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tqi_cor_adv_dif_cfm
		"Configuration to choose which advance corrections are taken into account for torque correction"
		VALUE
		0x8005c39e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tqi_cor_adv_dif_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tqi_ocd_egr_off_disa
		"Authorisation of specific correction for EGR off (1=not activ, 0=activ) for torque compensation calculation in ocd mode"
		VALUE
		0x8005bb0d
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tqi_ocd_egr_off_disa 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tqi_ocd_mod_ena
		"Boolean for activation of torque compensation in ocd mode : 1 = previous mode value is taken into account 0=previous mode value is
not taken into account"
		VALUE
		0x8005bb0c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tqi_ocd_mod_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tqi_raw_bch_cfm
		"Raw indicated torque bench mode"
		VALUE
		0x80043300
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tqi_raw_bch_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tqi_sp_bch_cfm
		"Setpoint indicated torque bench mode"
		VALUE
		0x800432ff
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tqi_sp_bch_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tqi_tgt_bch_cfm
		"Target indicated torque bench mode"
		VALUE
		0x800432fe
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tqi_tgt_bch_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_rubtqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tql_temp_cfm
		"Choice of water or oil temperature permited, according with technical engine definition"
		VALUE
		0x80041608
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_tql_temp_cfm 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_tra_acel_cfm
		"Bit to switch the transversal acceleration source"
		VALUE
		0x80058ab0
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tra_acel_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tran_open_ena_cfm
		"Enable calibration for opening turbocharger after transient saturation"
		VALUE
		0x800434c3
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tran_open_ena_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_ttcfmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_tt_cfm
		"Booleen to choose between temperature before turbine (0) or temperature before doc1 (1) for Vxx_tt"
		VALUE
		0x80058320
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_tt_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_up_it_temp_sens_pres_cfm
		"Calibration for upstream throttle temperature sensor presence"
		VALUE
		0x800578d4
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_up_it_temp_sens_pres_cfm 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ups_sens_pres_cfm
		"Calibration for presence of upstream proportional sensor"
		VALUE
		0x80058384
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ups_sens_pres_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_floatcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_vb_flot_ena_req
		"Battery floating activation request"
		VALUE
		0x8005d007
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_vb_flot_ena_req 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vb_vnt_pwm_fac_cfm
		"Activation of batrery voltage corection for turbocharger pwm"
		VALUE
		0x800400ec
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vb_vnt_pwm_fac_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cbx_vh_key_navl_val
		"Boolean to choose the default value when the KeyVehicle is received to an unavailable value (1 = key vehicle; 0 = without key vehicle)"
		VALUE
		0x80055c1e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vh_key_navl_val 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_ex_ctl_lih_ena
		"Activation of exhaust pressure regulation in case of boost pressure sensor failure"
		VALUE
		0x8004338c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_ex_ctl_lih_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_ex_prs_lim_cfm
		"Activation of exhaust pressure limitation strategy"
		VALUE
		0x8004338b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_ex_prs_lim_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_ex_prs_lim_tia_cold_cut
		"Boolean calibration for exhaust pres limitation shut off activation in case of cold intake aire temperatures"
		VALUE
		0x8004338a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_ex_prs_lim_tia_cold_cut 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_mnl_pwm_ena
		"Activation of manual actuator command"
		VALUE
		0x80043389
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_mnl_pwm_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_pwm_inv
		"VNT actuator operating mode for PWM signal"
		VALUE
		0x80043388
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_pwm_inv 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_sens_vld_diag_inhi_cfm
		"Inhibition of supercharger regulation deviation diagnostic in case of invalid sensor"
		VALUE
		0x8005d058
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_sens_vld_diag_inhi_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_sge_emtv_ctl_ena
		"Calibration to disable emtv control during anti-surging mode"
		VALUE
		0x80043b72
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_sge_emtv_ctl_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_sge_emtv_tia_msk
		"Calibration for masking the tia too low cut-off"
		VALUE
		0x80043b71
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_sge_emtv_tia_msk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_sge_ena_pr
		"Activation calibration of anti-surging mode during pr mode"
		VALUE
		0x8005d26a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_sge_ena_pr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_sge_ena_rij
		"Activation calibration of anti-surging mode during rij mode"
		VALUE
		0x8005d528
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_sge_ena_rij 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_tran_cfm
		"Activation of transient control strategy"
		VALUE
		0x80043387
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_tran_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_vnt_tran_lih_ena
		"Activation of transient saturation in case of exhaust pressure sensor failure"
		VALUE
		0x80043386
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vnt_tran_lih_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_mngtxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_vs_vld_bch_mod_ena
		"Boolean to enable the bench mode for vehicle speed validity indicator (1 = enable, forbidden for serial vehicle)"
		VALUE
		0x80058aaf
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_vs_vld_bch_mod_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsgihxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_wal_1_req_fs_cfm
		"Cbx_wal_1_req_fs_cfm"
		VALUE
		0x80059358
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_schedul_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_wg_abst_pres_cho_cfm
		"Fixed nozzle turbine with wastegate choice present or absent"
		VALUE
		0x80043354
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_wg_abst_pres_cho_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ac_pow_cor_val
		"Cartography to compute air conditioning power corrected value"
		MAP
		0x8006b270
		RSA_RecordLayout_MAP_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cmp_ac_pow_cor_val 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ac_pow */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ac_pow */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ac_pow */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ac_pow */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ac_pow */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_no_cor_raw_ac_pow
			euujibb_FsnwgBc_lyegbrc_W_R01oa
			9
			0.
			655350.
        AXIS_PTS_REF Ctb_ac_pow 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ac_pow_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ac_pow_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ac_pow_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ac_pow_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ac_pow_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ac_pow_cor_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_acel_pdl_fmt_fac
		"Vehicle speed and driving style map giving transition factor between 2 progressivity maps"
		MAP
		0x80059c8b
		RSA_RecordLayout_MAP_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_acel_pdl_fmt_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_acel_pdl_fmt_fac_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_acel_pdl_fmt_fac_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_acel_pdl_fmt_fac_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_acel_pdl_fmt_fac_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_acel_pdl_fmt_fac_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			9
			0.
			655.35
        AXIS_PTS_REF Ctb_acel_pdl_fmt_fac_vs 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_acel_pdl_fmt_fac_driv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_acel_pdl_fmt_fac_driv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_acel_pdl_fmt_fac_driv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_acel_pdl_fmt_fac_driv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_acel_pdl_fmt_fac_driv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_driv_spt_fac
			ecqiCpc_DaDmwla_yczccca_n_Ra5oa
			5
			0.
			1.
        AXIS_PTS_REF Ctb_acel_pdl_fmt_fac_driv 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_acel_pdl_fmt_tkof_fac
		"Vehicle speed and take off assistance factor map giving transition factor between 2 progressivity maps"
		MAP
		0x80059c72
		RSA_RecordLayout_MAP_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_acel_pdl_fmt_tkof_fac 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			5
			0.
			655.35
        AXIS_PTS_REF Ctb_acel_pdl_fmt_tkof_fac_vs 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_driv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_driv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_driv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_driv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_acel_pdl_fmt_tkof_fac_driv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tkof_ass_fac
			ltluECa_kDentwc_ulilrCa_roA_50a
			5
			0.
			1.
        AXIS_PTS_REF Ctb_acel_pdl_fmt_tkof_fac_driv 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainsta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_adv_amp_cor_sta
		"Coolant temperature and engine speed dependant advance correction"
		MAP
		0x8006ae36
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_adv_amp_cor_sta 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_adv_amp_cor_sta_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_adv_amp_cor_sta_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_adv_amp_cor_sta_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_adv_amp_cor_sta_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_adv_amp_cor_sta_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_adv_amp_cor_sta_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_adv_amp_cor_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_adv_amp_cor_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_adv_amp_cor_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_adv_amp_cor_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_adv_amp_cor_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_adv_amp_cor_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_acel_slk_dly_fac_spc
		"Specific cartography for modulation factors of the delay of action of the slack effect for vehicle acceleration"
		MAP
		0x8004097a
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_acel_slk_dly_fac_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_acel_slk_dly_spc
		"Specific cartography for selecting the delay of action of the slack effect for vehicle acceleration"
		MAP
		0x8004090a
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_acel_slk_dly_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_acel_slk_dly_t1
		"AJMOD cartography for selecting the delay of action of the slack effect for vehicle acceleration"
		MAP
		0x8005a65c
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_acel_slk_dly_t1 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_acel_slk_dly_t1_fac
		"AJMOD cartography for modulation factors of the delay of action of the slack effect for vehicle acceleration"
		MAP
		0x8005a5ec
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_acel_slk_dly_t1_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_acel_slk_t1_fac_spc
		"Specific cartography for modulation factors of the initial time constant offset added during slack effect activation for vehicle acceleration"
		MAP
		0x8004089a
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_acel_slk_t1_fac_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_acel_slk_t1_ini_max
		"AJMOD cartography for selecting the initial time constant offset added during slack effect activation for vehicle acceleration"
		MAP
		0x8005a57c
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_acel_slk_t1_ini_max 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_acel_slk_t1_ini_max_fac
		"AJMOD cartography for modulation factors of the initial time constant offset added during slack effect for vehicle acceleration"
		MAP
		0x8005a50c
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_acel_slk_t1_ini_max_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_acel_slk_t1_max_spc
		"Specific cartography for selecting the initial time constant offset added during slack effect activation for vehicle acceleration"
		MAP
		0x8004082a
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_acel_slk_t1_max_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_fast_cor_dly
		"AJCOR cartography for the maximum time to delay the fast anti-jerk correction."
		MAP
		0x80040fb4
		RSA_RecordLayout_MAP_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cmp_ajs_cor_fast_cor_dly 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			11
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_cor_driv_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_t1_acel_clos_spc
		"Specific AJCOR time constant cartography for vehicle acceleration when driveline is closed"
		MAP
		0x8004135c
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_cor_t1_acel_clos_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_t1_acel_dt_clos
		"AJCOR time constant cartography for vehicle acceleration when driveline is closed"
		MAP
		0x80040f24
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_cor_t1_acel_dt_clos 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_t1_decl_clos_spc
		"Specific AJCOR time constant cartography for vehicle deceleration when driveline is closed"
		MAP
		0x800412cc
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_cor_t1_decl_clos_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_t1_decl_dt_clos
		"AJCOR time constant cartography for vehicle deceleration when driveline is closed"
		MAP
		0x80040e94
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_cor_t1_decl_dt_clos 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_t1_fast_cor
		"AJCOR time constant cartography used during the boost of the curative anti-jerk function."
		MAP
		0x80040dce
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_cor_t1_fast_cor 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			11
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_cor_driv_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_td_acel_clos_spc
		"Specific AJCOR gain cartography for vehicle acceleration when driveline is closed (unit=(N.m/rpm)^(1/2))"
		MAP
		0x8004123c
		RSA_RecordLayout_MAP_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_ajs_cor_td_acel_clos_spc 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_td_acel_dt_clos
		"AJCOR gain cartography for vehicle acceleration when driveline is closed (unit=(N.m/rpm)^(1/2))"
		MAP
		0x80040d3e
		RSA_RecordLayout_MAP_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_ajs_cor_td_acel_dt_clos 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_td_acel_n_diff_fac
		"AJCOR Cartography of td modulation factors, for vehicle acceleration"
		MAP
		0x80040cde
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_cor_td_acel_n_diff_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n_diff */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n_diff */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n_diff */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n_diff */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n_diff */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_cor_n_diff
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n_diff 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_cor_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_td_decl_clos_spc
		"Specific AJCOR gain cartography for vehicle deceleration when driveline is closed (unit=(N.m/rpm)^(1/2))"
		MAP
		0x800411ac
		RSA_RecordLayout_MAP_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_ajs_cor_td_decl_clos_spc 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_td_decl_dt_clos
		"AJCOR gain cartography for vehicle deceleration when driveline is closed (unit=(N.m/rpm)^(1/2))"
		MAP
		0x80040c4e
		RSA_RecordLayout_MAP_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_ajs_cor_td_decl_dt_clos 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_td_decl_n_diff_fac
		"AJCOR Cartography of td modulation factors, for vehicle deceleration"
		MAP
		0x80040bee
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_cor_td_decl_n_diff_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n_diff */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n_diff */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n_diff */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n_diff */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n_diff */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_cor_n_diff
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n_diff 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_cor_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_td_fast_cor
		"AJCOR gain cartography used during the boost of the curative anti-jerk function (unit=(N.m/rpm)^(1/2))"
		MAP
		0x80040b28
		RSA_RecordLayout_MAP_UWORD
		1
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_ajs_cor_td_fast_cor 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			11
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_cor_driv_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_td_tq_fac
		"AJCOR cartography for modulation factors of the filter gain when driveline is closed"
		MAP
		0x80040a78
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_cor_td_tq_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			11
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_cor_driv_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_cor_td_tq_fac_spc
		"Specific AJCOR cartography for modulation factors of the filter gain when driveline is closed"
		MAP
		0x800410fc
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_cor_td_tq_fac_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_driv_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			11
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_cor_driv_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_decl_slk_dly_fac_spc
		"Specific cartography for modulation factors of the delay of action of the slack effect for vehicle deceleration"
		MAP
		0x800407ba
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_decl_slk_dly_fac_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_decl_slk_dly_spc
		"Specific cartography for selecting the delay of action of the slack effect for vehicle deceleration"
		MAP
		0x8004074a
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_decl_slk_dly_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_decl_slk_dly_t1
		"AJMOD cartography for selecting the delay of action of the slack effect for vehicle deceleration"
		MAP
		0x8005a49c
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_decl_slk_dly_t1 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_decl_slk_dly_t1_fac
		"AJMOD cartography for modulation factors of the delay of action of the slack effect for vehicle deceleration"
		MAP
		0x8005a42c
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_decl_slk_dly_t1_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_decl_slk_t1_fac_spc
		"Specific cartography for modulation factors of the initial time constant offset added during slack effect activation for vehicle deceleration"
		MAP
		0x800406da
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_decl_slk_t1_fac_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_decl_slk_t1_ini_max
		"AJMOD cartography for selecting the initial time constant offset added during slack effect activation for vehicle deceleration"
		MAP
		0x8005a3bc
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_decl_slk_t1_ini_max 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_decl_slk_t1_ini_max_fac
		"AJMOD cartography for modulation factors of the initial time constant offset added during slack effect activation for vehicle deceleration"
		MAP
		0x8005a34c
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_decl_slk_t1_ini_max_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_decl_slk_t1_max_spc
		"Specific cartography for selecting the initial time constant offset added during slack effect activation for vehicle deceleration"
		MAP
		0x8004066a
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_decl_slk_t1_max_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_acel_clos_spc
		"Specific time constant cartography for vehicle acceleration when driveline is closed"
		MAP
		0x800405fa
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_acel_clos_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_acel_driv_fac
		"AJMOD cartography for modulation factors of the filter time constant based on driver torque factor for vehicle acceleration"
		MAP
		0x8005a2dc
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_acel_driv_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_acel_dt_clos
		"AJMOD time constant cartography for vehicle acceleration when driveline is closed"
		MAP
		0x8005a26c
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_acel_dt_clos 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_acel_fac_spc
		"Specific cartography for modulation factors of the filter time constant based on driver torque factor for vehicle acceleration"
		MAP
		0x8004058a
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_acel_fac_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_acel_tql_fac
		"AJMOD cartography for modulation factors of filter time constant based on the torque losses due to accessories for vehicle acceleration"
		MAP
		0x8005a1ec
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_acel_tql_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_aux_tql */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_aux_tql
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_ajs_aux_tql 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_decl_clos_spc
		"Specific time constant cartography for vehicle deceleration when driveline is closed"
		MAP
		0x8004051a
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_decl_clos_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_decl_driv_fac
		"AJMOD cartography for modulation factors of the filter time constant based on driver torque factor for vehicle deceleration"
		MAP
		0x8005a17c
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_decl_driv_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_decl_dt_clos
		"AJMOD time constant cartography for vehicle deceleration when driveline is closed"
		MAP
		0x8005a10c
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_decl_dt_clos 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_decl_fac_spc
		"Specific cartography for modulation factors of the filter time constant based on driver torque factor for vehicle deceleration"
		MAP
		0x800404aa
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_decl_fac_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_t1_decl_tql_fac
		"AJMOD cartography for modulation factors of filter time constant based on the torque losses due to accessories for vehicle deceleration"
		MAP
		0x8005a08c
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_t1_decl_tql_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_aux_tql */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_aux_tql
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_ajs_aux_tql 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_acel_clos_spc
		"Specific gain cartography for vehicle acceleration when driveline is closed"
		MAP
		0x8004043a
		RSA_RecordLayout_MAP_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_acel_clos_spc 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_acel_driv_fac
		"AJMOD cartography for modulation factors of the filter gain based on driver torque factor for vehicle acceleration"
		MAP
		0x8005a01c
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_acel_driv_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_acel_dt_clos
		"AJMOD gain cartography for vehicle acceleration when driveline is closed"
		MAP
		0x80059fac
		RSA_RecordLayout_MAP_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_acel_dt_clos 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_acel_fac_spc
		"Specific cartography for modulation factors of the filter gain based on driver torque factor for vehicle acceleration"
		MAP
		0x800403ca
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_acel_fac_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_acel_tql_fac
		"AJMOD cartography for modulation factors of the filter gain based on the torque losses due to accessories for vehicle acceleration"
		MAP
		0x80059f2c
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_acel_tql_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_aux_tql */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_aux_tql
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_ajs_aux_tql 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_decl_clos_spc
		"Specific gain cartography for vehicle deceleration when driveline is closed"
		MAP
		0x8004035a
		RSA_RecordLayout_MAP_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_decl_clos_spc 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_decl_driv_fac
		"AJMOD cartography for modulation factors of the filter gain based on driver torque factor for vehicle deceleration"
		MAP
		0x80059ebc
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_decl_driv_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_decl_dt_clos
		"AJMOD gain cartography for vehicle deceleration when driveline is closed"
		MAP
		0x80059e4c
		RSA_RecordLayout_MAP_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_decl_dt_clos 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_modu_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_modu_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_modu_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_modu_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_decl_fac_spc
		"Specific cartography for modulation factors of the filter gain based on driver torque factor for vehicle deceleration"
		MAP
		0x800402ea
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_decl_fac_spc 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_tq_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_modu_td_decl_tql_fac
		"AJMOD cartography for modulation factors of the filter gain based on the torque losses due to accessories for vehicle deceleration"
		MAP
		0x80059dcc
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ajs_modu_td_decl_tql_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_aux_tql */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_aux_tql
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_ajs_aux_tql 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_slk_tqe_on_acel
		"Torque low threshold to deactivate the slack effect for vehicle acceleration"
		MAP
		0x8005a8fe
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cmp_ajs_slk_tqe_on_acel 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_aux_tql */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_aux_tql
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_ajs_aux_tql 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_slk_tqe_on_decl
		"Torque low threshold to deactivate the slack effect for vehicle deceleration"
		MAP
		0x8005a87e
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cmp_ajs_slk_tqe_on_decl 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_aux_tql */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_aux_tql */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_aux_tql
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_ajs_aux_tql 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_spd_diff_thd_on_acel
		"Speed difference low threshold to deactivate the slack effect for vehicle acceleration"
		MAP
		0x8005a80e
		RSA_RecordLayout_MAP_UWORD
		16383.75
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cmp_ajs_spd_diff_thd_on_acel 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_slk_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_slk_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_slk_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_slk_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_slk_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_slk_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_ajs_spv_fast_cor_dly
		"Cartography to select the maximum time for the application of the boost of the curative anti-jerk function."
		MAP
		0x8005a7ac
		RSA_RecordLayout_MAP_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cmp_ajs_spv_fast_cor_dly 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_spv_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_spv_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_spv_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_spv_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_spv_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_spv_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_spv_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_spv_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_spv_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_spv_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_spv_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_spv_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_alt_pow_cor_val
		"Cartography to compute alternator power corrected value"
		MAP
		0x8005899a
		RSA_RecordLayout_MAP_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cmp_alt_pow_cor_val 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_alt_pow */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_alt_pow */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_alt_pow */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_alt_pow */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_alt_pow */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_no_cor_raw_alt_pow
			euujibb_FsnwgBc_lyegbrc_W_R01oa
			9
			0.
			655350.
        AXIS_PTS_REF Ctb_alt_pow 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_alt_pow_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_alt_pow_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_alt_pow_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_alt_pow_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_alt_pow_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_alt_pow_cor_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_alt_slop_req
		"Cartography to compute alternator power gradient authorized by ECM"
		MAP
		0x8005ce52
		RSA_RecordLayout_MAP_UBYTE
		10200
		sBxEEjc_FDsdgfc_lunhtFd_WCRana0
		0.
		10200.
    DISPLAY_IDENTIFIER Cmp_alt_slop_req 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_alt */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_alt */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_alt */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_alt */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_alt */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_alt 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_amp_n_spg_sp_max
		"Boost air pressure setpoint limitation"
		MAP
		0x80043908
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_amp_n_spg_sp_max 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_amp_sp_max */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_amp_sp_max */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_amp_sp_max */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_amp_sp_max */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_amp_sp_max */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_amp_sp_max 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_amp_sp_max */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_amp_sp_max */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_amp_sp_max */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_amp_sp_max */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_amp_sp_max */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			10
			0.
			20000.
        AXIS_PTS_REF Ctb_y_amp_sp_max 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_cur_tra_acel_thd
		"Cmp_cur_tra_acel_thd"
		MAP
		0x80059282
		RSA_RecordLayout_MAP_UWORD
		13.5
		VA_F_0v0004_p0_1
		0
		13.5
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear_fs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear_fs */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			VA_F_1_p1_1
			6
			1
			6
        AXIS_PTS_REF Ctb_gear_fs 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_cur_spd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_cur_spd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_cur_spd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_cur_spd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_cur_spd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			VA_F_0v25_p0_3
			8
			0
			16383.75
        AXIS_PTS_REF Ctb_cur_spd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_cut_fil_fac
		"Cartography for torque slope limitation during injection cut"
		MAP
		0x8005b154
		RSA_RecordLayout_MAP_UWORD
		65535
		zlhAlxa_lflywEd_dCwmhyc_NsA_n0a
		-65535.
		0.
    DISPLAY_IDENTIFIER Cmp_cut_fil_fac 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_inj_cut_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_inj_cut_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_inj_cut_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_inj_cut_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_inj_cut_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_inj_cut_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_dp_egaf_ms_dp
		"Table of soot mass for differential pressure"
		MAP
		0x80057e12
		RSA_RecordLayout_MAP_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_dp_egaf_ms_dp 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ms_dp_dp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ms_dp_dp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ms_dp_dp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ms_dp_dp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ms_dp_dp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_ms_dp_dp_fil
			BhendBa_Bnmgqnd_blgaFzd_hCRa10a
			16
			-10000.
			10000.
        AXIS_PTS_REF Ctb_ms_dp_dp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ms_dp_egaf */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ms_dp_egaf */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ms_dp_egaf */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ms_dp_egaf */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ms_dp_egaf */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_ms_dp_egaf_cor
			movAqed_DtteCgd_cloonha_Bh__10a
			16
			0.
			2000.
        AXIS_PTS_REF Ctb_ms_dp_egaf 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_driv_sp_mv_fil_fac
		"Filter time constant for calculation of driver setpoint mean value"
		MAP
		0x800591d0
		RSA_RecordLayout_MAP_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cmp_driv_sp_mv_fil_fac 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_driv_sp_mv_fil_fac_pwt_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_driv_sp_mv_fil_fac_pwt_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_driv_sp_mv_fil_fac_pwt_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_driv_sp_mv_fil_fac_pwt_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_driv_sp_mv_fil_fac_pwt_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_driv_pwt_sp
			Fyedevd_rnBqacd_ulakuub_roA_00a
			2
			0.
			1.
        AXIS_PTS_REF Ctb_driv_sp_mv_fil_fac_pwt_sp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_driv_sp_mv_fil_fac_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_driv_sp_mv_fil_fac_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_driv_sp_mv_fil_fac_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_driv_sp_mv_fil_fac_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_driv_sp_mv_fil_fac_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			2
			0.
			655.35
        AXIS_PTS_REF Ctb_driv_sp_mv_fil_fac_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_driv_spt_fac_map
		"Driving style map, according to average driver setpoint and activity"
		MAP
		0x800591b7
		RSA_RecordLayout_MAP_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_driv_spt_fac_map 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_driv_spt_fac_driv_sp_mv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_driv_spt_fac_driv_sp_mv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_driv_spt_fac_driv_sp_mv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_driv_spt_fac_driv_sp_mv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_driv_spt_fac_driv_sp_mv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_driv_sp_mv
			ltluECa_kDentwc_ulilrCa_roA_50a
			5
			0.
			1.
        AXIS_PTS_REF Ctb_driv_spt_fac_driv_sp_mv 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_driv_spt_fac_driv_sp_grd_mv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_driv_spt_fac_driv_sp_grd_mv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_driv_spt_fac_driv_sp_grd_mv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_driv_spt_fac_driv_sp_grd_mv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_driv_spt_fac_driv_sp_grd_mv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_driv_sp_grd_mv
			ltluECa_kDentwc_ulilrCa_roA_50a
			5
			0.
			1.
        AXIS_PTS_REF Ctb_driv_spt_fac_driv_sp_grd_mv 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_driv_swi_fil_fac
		"Cartography for torque slope limitation during re-injection on powertrain setpoint request"
		MAP
		0x8005b0e4
		RSA_RecordLayout_MAP_UWORD
		65535
		xmoyqad_zuxgeuc_aAwwvka_NsA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cmp_driv_swi_fil_fac 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_inj_cut_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_inj_cut_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_inj_cut_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_inj_cut_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_inj_cut_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			7
			0.
			16383.75
        AXIS_PTS_REF Ctb_inj_cut_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drtqexx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_driv_tqe_map
		"Map giving effective engine torque setpoint from powertrain setpoint and engine speed (only positiv"
		MAP
		0x8005990a
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_driv_tqe_map 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_driv_tqe_map_pwt_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_driv_tqe_map_pwt_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_driv_tqe_map_pwt_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_driv_tqe_map_pwt_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_driv_tqe_map_pwt_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_driv_pwt_sp
			qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
			17
			0.
			1.
        AXIS_PTS_REF Ctb_driv_tqe_map_pwt_sp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_driv_tqe_map_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_driv_tqe_map_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_driv_tqe_map_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_driv_tqe_map_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_driv_tqe_map_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_driv_tqe_map_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_dtp_ms_pft_utp_var_sp
		"Interpolation table of CSF up temp setpoint depending on downstream temp and soot mass"
		MAP
		0x80045b9a
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_dtp_ms_pft_utp_var_sp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_dtp_pft_utp_var_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_dtp_pft_utp_var_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_dtp_pft_utp_var_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_dtp_pft_utp_var_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_dtp_pft_utp_var_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_dtp_in
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			1200.
        AXIS_PTS_REF Ctb_dtp_pft_utp_var_sp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ms_pft_utp_var_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ms_pft_utp_var_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ms_pft_utp_var_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ms_pft_utp_var_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ms_pft_utp_var_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_ms_in
			CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
			8
			0.
			655.35
        AXIS_PTS_REF Ctb_ms_pft_utp_var_sp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_efy_cpr
		"Compressor efficiency"
		MAP
		0x80057aa6
		RSA_RecordLayout_MAP_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cmp_efy_cpr 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_efy_cpr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_efy_cpr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_efy_cpr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_efy_cpr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_efy_cpr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			13
			-40.
			200.
        AXIS_PTS_REF Ctb_x_efy_cpr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_efy_cpr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_efy_cpr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_efy_cpr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_efy_cpr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_efy_cpr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_cpr_prs_rat
			AkEtvpa_Fpuekuc_Bagaoqb_n__100a
			16
			0.
			5.
        AXIS_PTS_REF Ctb_y_efy_cpr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_efy_spg_cool
		"Supercharger cooler efficiency"
		MAP
		0x80057906
		RSA_RecordLayout_MAP_UWORD
		5
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		5.
    DISPLAY_IDENTIFIER Cmp_efy_spg_cool 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_efy_spg_cool */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_efy_spg_cool */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_efy_spg_cool */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_efy_spg_cool */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_efy_spg_cool */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_kgh
			bCkDtxb_iBmhrgb_vDEgpCc_khA_10a
			13
			0.
			2000.
        AXIS_PTS_REF Ctb_x_efy_spg_cool 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_efy_spg_cool */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_efy_spg_cool */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_efy_spg_cool */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_efy_spg_cool */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_efy_spg_cool */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs_sat
			uEardjb_BFoibqb_vkamstb_khA_00a
			16
			0.
			655.35
        AXIS_PTS_REF Ctb_y_efy_spg_cool 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_egr_cut_tqi_thd_pp
		"Curve of torque threshold for EGR cut off depending on engine speed and gear ratio in pp mode"
		MAP
		0x80061720
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_egr_cut_tqi_thd_pp 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_egr_cut_tqi_thd_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_egr_cut_tqi_thd_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_egr_cut_tqi_thd_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_egr_cut_tqi_thd_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_egr_cut_tqi_thd_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_egr_cut_tqi_thd_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_egr_cut_tqi_thd_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_egr_cut_tqi_thd_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_egr_cut_tqi_thd_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_egr_cut_tqi_thd_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_egr_cut_tqi_thd_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_y_egr_cut_tqi_thd_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_egr_cut_tqi_thd_pr
		"Curve of torque threshold for EGR cut off depending on engine speed and gear ratio in pr mode"
		MAP
		0x80061620
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_egr_cut_tqi_thd_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_egr_cut_tqi_thd_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_egr_cut_tqi_thd_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_egr_cut_tqi_thd_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_egr_cut_tqi_thd_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_egr_cut_tqi_thd_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_egr_cut_tqi_thd_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_egr_cut_tqi_thd_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_egr_cut_tqi_thd_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_egr_cut_tqi_thd_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_egr_cut_tqi_thd_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_egr_cut_tqi_thd_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_y_egr_cut_tqi_thd_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_egr_cut_tqi_thd_rij
		"Curve of torque threshold for EGR cut off depending on engine speed and gear ratio in rij mode"
		MAP
		0x80061520
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_egr_cut_tqi_thd_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_egr_cut_tqi_thd_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_egr_cut_tqi_thd_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_egr_cut_tqi_thd_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_egr_cut_tqi_thd_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_egr_cut_tqi_thd_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_egr_cut_tqi_thd_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_egr_cut_tqi_thd_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_egr_cut_tqi_thd_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_egr_cut_tqi_thd_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_egr_cut_tqi_thd_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_egr_cut_tqi_thd_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_y_egr_cut_tqi_thd_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_eng_vol_efy_ex
		"The exhaust volumetric efficiency map"
		MAP
		0x8005718a
		RSA_RecordLayout_MAP_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_eng_vol_efy_ex 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_eng_vol_efy_ex */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_eng_vol_efy_ex */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_eng_vol_efy_ex */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_eng_vol_efy_ex */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_eng_vol_efy_ex */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			13
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_eng_vol_efy_ex 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_eng_vol_efy_ex */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_eng_vol_efy_ex */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_eng_vol_efy_ex */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_eng_vol_efy_ex */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_eng_vol_efy_ex */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_air_dens_ex
			yvyupqb_iFBfdid_awzApyb_kE__0a0
			16
			0.
			5.
        AXIS_PTS_REF Ctb_y_eng_vol_efy_ex 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_eng_vol_efy_in
		"The intake volumetric efficiency map"
		MAP
		0x80056fea
		RSA_RecordLayout_MAP_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_eng_vol_efy_in 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_eng_vol_efy_in */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_eng_vol_efy_in */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_eng_vol_efy_in */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_eng_vol_efy_in */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_eng_vol_efy_in */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			13
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_eng_vol_efy_in 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_eng_vol_efy_in */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_eng_vol_efy_in */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_eng_vol_efy_in */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_eng_vol_efy_in */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_eng_vol_efy_in */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_air_dens_in
			yvyupqb_iFBfdid_awzApyb_kE__0a0
			16
			0.
			5.
        AXIS_PTS_REF Ctb_y_eng_vol_efy_in 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_ex_prs_sp_pft_cor_pr
		"Exhaust pressure setpoint map correction in pft regeneration mode"
		MAP
		0x800608c8
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_ex_prs_sp_pft_cor_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_pft_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_pft_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_ex_prs_sp_pft_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_ex_prs_sp_pft_cor_rij
		"Exhaust pressure setpoint map correction in regular injection mode"
		MAP
		0x800611a4
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_ex_prs_sp_pft_cor_rij 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_pft_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_pft_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_ex_prs_sp_pft_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_ex_prs_sp_pft_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_fast_driv_spt_fac
		"Fast sportivity factor table"
		MAP
		0x8005919e
		RSA_RecordLayout_MAP_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_fast_driv_spt_fac 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fast_driv_spt_fac_pdl */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fast_driv_spt_fac_pdl */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fast_driv_spt_fac_pdl */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fast_driv_spt_fac_pdl */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fast_driv_spt_fac_pdl */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_acel_pdl_dif
			Fyedevd_rnBqacd_ulakuub_roA_00a
			5
			0.
			1.
        AXIS_PTS_REF Ctb_fast_driv_spt_fac_pdl 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fast_driv_spt_fac_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fast_driv_spt_fac_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fast_driv_spt_fac_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fast_driv_spt_fac_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fast_driv_spt_fac_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			5
			0.
			655.35
        AXIS_PTS_REF Ctb_fast_driv_spt_fac_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_fast_off_law_pdl_grd_dly
		"Cmp_fast_off_law_pdl_grd_dly"
		MAP
		0x80059315
		RSA_RecordLayout_MAP_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_law */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_law */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_law */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_law */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_law */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_law_sel
			VA_F_1_p1_2
			5
			1
			5
        AXIS_PTS_REF Ctb_law 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fast_off_pdl_grd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fast_off_pdl_grd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fast_off_pdl_grd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fast_off_pdl_grd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fast_off_pdl_grd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pdl_grd
			VA_F_0v125_m2000_5
			5
			-2000
			2000
        AXIS_PTS_REF Ctb_fast_off_pdl_grd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_ff_ms_vnt_reg_max
		"Max vnt governor pwm map function of particulate filter charge and comsuption"
		MAP
		0x8005d10a
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_ff_ms_vnt_reg_max 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_pft_max_lim */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_pft_max_lim */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_pft_max_lim */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_pft_max_lim */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_pft_max_lim */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_pft_max_lim 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_pft_max_lim */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_pft_max_lim */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_pft_max_lim */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_pft_max_lim */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_pft_max_lim */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			10
			0.
			100.
        AXIS_PTS_REF Ctb_y_vnt_pft_max_lim 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_amp_cor_pr
		"Atmospheric pressure correction for main advance during pr"
		MAP
		0x8006aa50
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_amp_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_amp_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_amp_tco_cor_rij
		"Atmospheric pressure correction for main advance"
		MAP
		0x80050bb0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_amp_tco_cor_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_amp_tco_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_amp_tco_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_amp_tco_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_amp_tco_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_amp_tco_fac_rij
		"Factor of atmospheric pressure correction for main advance"
		MAP
		0x80050b80
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_adv_amp_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_fms_adv_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_fms_adv_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_fms_adv_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_fms_adv_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_fms_adv_amp_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_fms_adv_amp_tco_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_adv_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_adv_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_adv_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_adv_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_adv_amp_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_adv_amp_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_aut_eng_cor_rij
		"Delta rail pressure correction for main advance during rij"
		MAP
		0x80050a60
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_aut_eng_cor_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_aut_eng_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_aut_eng_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_aut_eng_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_aut_eng_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_aut_eng_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_aut_eng_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_aut_eng_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_aut_eng_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_aut_eng_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_aut_eng_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_aut_eng_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_aut_eng_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_aut_eng_fac_rij
		"Factor of autnomous engine correction for main advance during rij"
		MAP
		0x800509e0
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_adv_aut_eng_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_t_fms_adv_aut_eng_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_t_fms_adv_aut_eng_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_t_fms_adv_aut_eng_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_t_fms_adv_aut_eng_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_t_fms_adv_aut_eng_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_adv_aut_eng_t
			EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
			8
			0.
			655.35
        AXIS_PTS_REF Ctb_t_fms_adv_aut_eng_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_adv_aut_eng_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_adv_aut_eng_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_adv_aut_eng_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_adv_aut_eng_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_adv_aut_eng_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_adv_aut_eng_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_bas_0p_pr
		"Basic main advance set point without pre-injection during pr"
		MAP
		0x8006a950
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_bas_0p_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_adv_0p_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_adv_0p_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_cold_tco_0p_rij
		"main advance for cold coolant temperature without pre injection"
		MAP
		0x800508e0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_cold_tco_0p_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_0p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_0p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_cold_tco_1p_rij
		"main advance for cold coolant temperature with 1 pre injection"
		MAP
		0x800506e0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_cold_tco_1p_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_1p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_1p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_cold_tco_2p_rij
		"main advance for cold coolant temperature with 2 pre injections"
		MAP
		0x800504e0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_cold_tco_2p_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_dp_map_cor_rij
		"Delta mass air pressure pressure correction for main advance during rij"
		MAP
		0x800503c0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_dp_map_cor_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_dp_map_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_dp_map_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_dp_map_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_dp_map_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_dp_map_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_dp_map_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_dp_map_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_dp_map_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_dp_map_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_dp_map_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_dp_map_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_dp_map_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_dp_rps_cor_pr
		"Delta rail pressure correction for main advance during pr"
		MAP
		0x8006a830
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_dp_rps_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_dp_rps_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_dp_rps_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_dp_rps_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_dp_rps_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_dp_rps_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_dp_rps_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_dp_rps_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_dp_rps_cor_rij
		"Deltarail pressure pressure correction for main advance during rij"
		MAP
		0x800502a0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_dp_rps_cor_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_dp_rps_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_dp_rps_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_dp_rps_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_dp_rps_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_dp_rps_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_dp_rps_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_dp_rps_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_dp_rps_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_gear_rij
		"Basic main advance set point with specific gearbox ratio."
		MAP
		0x800500a0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_gear_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_gear_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_gear_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_gear_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_gear_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_gear_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_gear_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_gear_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_gear_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_gear_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_gear_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_gear_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_gear_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_max_pr
		"Maximun main advance during pr"
		MAP
		0x8006a768
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_max_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_max_rij
		"Maximun main advance set point"
		MAP
		0x8004ffd8
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_max_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_min_pr
		"Minimum main advance during pr"
		MAP
		0x8006a6a0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_min_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_min_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_min_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_min_rij
		"Minimum main advance set point"
		MAP
		0x8004ff10
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_min_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_min_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_min_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_ms_dp_cor_pr
		"Particultate filter soot mass for main advance during pr"
		MAP
		0x8006a580
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_ms_dp_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_ms_dp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_ms_dp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_ms_dp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_ms_dp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_mv_tco_0p_rij
		"main advance for medium coolant temperature without pre injection"
		MAP
		0x8004fe10
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_mv_tco_0p_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_0p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_0p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_mv_tco_1p_rij
		"main advance for medium coolant temperature with 1 pre injection"
		MAP
		0x8004fc10
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_mv_tco_1p_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_1p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_1p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_mv_tco_2p_rij
		"main advance for medium coolant temperature with 2 pre injections"
		MAP
		0x8004fa10
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_mv_tco_2p_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_tco_cor_pr
		"Coolant temperature correction for main advance during pr"
		MAP
		0x8006a460
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_tco_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_tco_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_tia_cor_pr
		"Intake air temperature correction for main advance during pr"
		MAP
		0x8006a340
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_tia_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_tia_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_tia_tco_cor_rij
		"Intake air temperature correction for main advance"
		MAP
		0x8004f8f0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_adv_tia_tco_cor_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_tia_tco_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_tia_tco_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_tia_tco_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_tia_tco_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_adv_tia_tco_fac_rij
		"Factor of intake air temperature correction for main advance"
		MAP
		0x8004f8c0
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_adv_tia_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_fms_adv_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_fms_adv_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_fms_adv_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_fms_adv_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_fms_adv_tia_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_fms_adv_tia_tco_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_adv_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_adv_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_adv_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_adv_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_adv_tia_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_adv_tia_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_amp_cor_pr
		"Interpolation table of atmospheric pressure correction for quantity of global injection during pft regeneration"
		MAP
		0x800448b0
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_amp_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_adv_0p_pr
		""
		MAP
		0x8006a240
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_bas_adv_0p_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_adv_0p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_adv_0p_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_adv_0p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_adv_0p_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_adv_0p_rij
		"Basic main advance set point without pre-injection"
		MAP
		0x8004f7c0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_bas_adv_0p_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_0p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_0p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_adv_1p_pr
		"Basic main advance set point with 1 pre-injection during pr"
		MAP
		0x8006a040
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_bas_adv_1p_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_adv_1p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_adv_1p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_adv_1p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_adv_1p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_adv_1p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_adv_1p_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_adv_1p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_adv_1p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_adv_1p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_adv_1p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_adv_1p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_adv_1p_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_adv_1p_rij
		"Basic main advance set point with 1 pre-injection"
		MAP
		0x8004f5c0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_bas_adv_1p_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_1p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_1p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_adv_2p_pr
		"Basic main advance set point with 2 pre-injections during pr"
		MAP
		0x80069e40
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_bas_adv_2p_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_adv_2p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_adv_2p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_adv_2p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_adv_2p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_adv_2p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_adv_2p_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_adv_2p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_adv_2p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_adv_2p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_adv_2p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_adv_2p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_adv_2p_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_adv_2p_rij
		"Basic main advance set point with 2 pre-injection"
		MAP
		0x8004f3c0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_bas_adv_2p_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_adv_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_adv_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_adv_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_adv_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_faf_rij
		"Basic quantity of after injection during regular injection"
		MAP
		0x80068920
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_bas_faf_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_faf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_faf_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_faf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_faf_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_fp1_2p_pr
		"Basic quantity of pre-injection 1 with 2 pre-injection during pft regeneration"
		MAP
		0x8004ba84
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_bas_fp1_2p_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_fp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_fp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_fp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_fp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_fp1_2p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_fp1_2p_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_fp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_fp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_fp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_fp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_fp1_2p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_fp1_2p_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_fp1_2p_rij
		"Basic quantity of pre-injection 1 with 2 pre-injection during regular injection"
		MAP
		0x8004a632
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_bas_fp1_2p_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_fp1_pr
		"Basic quantity of pre-injection 1 during pft regeneration"
		MAP
		0x8004b884
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_bas_fp1_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_fp1_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_fp1_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_fp1_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_fp1_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_fp1_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_fp1_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_fp1_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_fp1_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_fp1_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_fp1_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_fp1_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_fp1_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_fp1_rij
		"Basic quantity of pre-injection 1 during regular injection"
		MAP
		0x8004a432
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_bas_fp1_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_fp2_pr
		"Basic quantity of pre-injection 2 during pft regeneration"
		MAP
		0x8004c264
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_bas_fp2_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_fp2_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_fp2_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_fp2_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_fp2_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_fp2_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_fp2_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_fp2_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_fp2_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_fp2_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_fp2_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_fp2_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_fp2_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_fp2_rij
		"Basic quantity of pre-injection 2 during regular injection"
		MAP
		0x8004b10c
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_bas_fp2_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_fpo_pr
		"Basic quantity of post injection during pft regeneration"
		MAP
		0x8004cea4
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_bas_fpo_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_fpo_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_fpo_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_fpo_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_fpo_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_fpo_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_fpo_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_fpo_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_fpo_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_fpo_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_fpo_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_fpo_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_fpo_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_taf_rij
		"Basic separation of after injection during regular injection"
		MAP
		0x80069aa0
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_bas_taf_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_taf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_taf_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_taf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_taf_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tlp_pr
		"Basic angle of late post injection during pft regeneration"
		MAP
		0x8004f020
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tlp_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_tlp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_tlp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_tlp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_tlp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_tlp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_tlp_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_tlp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_tlp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_tlp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_tlp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_tlp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_tlp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tp1_2p_pr
		"Basic separation of pre-injection 1 with 2 pre-injection during pft regeneration"
		MAP
		0x80053b30
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tp1_2p_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_tp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_tp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_tp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_tp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_tp1_2p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_tp1_2p_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_tp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_tp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_tp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_tp1_2p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_tp1_2p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_tp1_2p_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tp1_2p_rij
		"Basic separation of pre-injection 1 with 2 pre-injection during regular injection"
		MAP
		0x80051dfe
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tp1_2p_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tp1_pr
		"Basic separation of pre-injection 1 during pft regeneration"
		MAP
		0x80053930
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tp1_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_tp1_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_tp1_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_tp1_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_tp1_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_tp1_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_tp1_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_tp1_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_tp1_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_tp1_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_tp1_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_tp1_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_tp1_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tp1_rij
		"Basic separation of pre-injection 1 during regular injection"
		MAP
		0x80051bfe
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tp1_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tp2_2p_pr
		"Basic separation of pre-injection 2 with 2 pre-injection during pft regeneration"
		MAP
		0x80054608
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tp2_2p_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_tp2_2p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_tp2_2p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_tp2_2p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_tp2_2p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_tp2_2p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_tp2_2p_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_tp2_2p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_tp2_2p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_tp2_2p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_tp2_2p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_tp2_2p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_tp2_2p_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tp2_2p_rij
		"Basic separation of pre-injection 2 with 2 pre-injection during regular injection"
		MAP
		0x80053080
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tp2_2p_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tp2_pr
		"Basic separation of pre-injection 2 during pft regeneration"
		MAP
		0x80054408
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tp2_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_tp2_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_tp2_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_tp2_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_tp2_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_tp2_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_tp2_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_tp2_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_tp2_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_tp2_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_tp2_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_tp2_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_tp2_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tp2_rij
		"Basic separation of pre-injection 2 during regular injection"
		MAP
		0x80052e80
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tp2_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_bas_tpo_pr
		"Basic angle of post injection during pft regeneration"
		MAP
		0x80054ee0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_bas_tpo_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_bas_tpo_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_bas_tpo_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_bas_tpo_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_bas_tpo_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_bas_tpo_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_bas_tpo_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_bas_tpo_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_bas_tpo_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_bas_tpo_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_bas_tpo_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_bas_tpo_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_bas_tpo_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_comb_mod_swi_t
		"Transition time of combustion mode"
		MAP
		0x8004ea74
		RSA_RecordLayout_MAP_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cmp_fms_comb_mod_swi_t 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_comb_mod_req
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			0.
			15.
        AXIS_PTS_REF Ntb_req_fms_comb_mod_swi_t 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_req_fms_comb_mod_swi_t */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_comb_mod_req
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			0.
			15.
        AXIS_PTS_REF Ntb_req_fms_comb_mod_swi_t 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_efi_maf_err_fac_pr
		"Interpolation table of factor for maximum quantity of exhaust fuel injection during CSF regeneration"
		MAP
		0x80044868
		RSA_RecordLayout_MAP_UWORD
		6.5535
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cmp_fms_efi_maf_err_fac_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_efi_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_efi_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_efi_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_efi_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_efi_maf_err_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_efi_maf_err_fac_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_maf_efi_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_maf_efi_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_maf_efi_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_maf_efi_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_maf_efi_maf_err_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_efi_maf_err_fil
			tClffab_hirDflc_mxtqjrd_mtA_o00
			6
			-3000.
			3000.
        AXIS_PTS_REF Ctb_maf_efi_maf_err_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_efi_min_pr
		"Interpolation table of minimum quantity of exhaust fuel injection during pft regeneration"
		MAP
		0x800447a0
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_efi_min_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_efi_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_efi_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_efi_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_efi_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_efi_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_efi_min_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_efi_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_efi_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_efi_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_efi_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_efi_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_efi_min_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_faf_amp_cor_rij
		"Atmospheric pressure correction for quantity of after injection during regular injection"
		MAP
		0x80068800
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_faf_amp_cor_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_faf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_faf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_faf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_faf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_faf_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_faf_amp_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_faf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_faf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_faf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_faf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_faf_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_faf_amp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_faf_amp_fac_rij
		"Factor of atmospheric pressure correction for quantity of after injcetion during regular injection"
		MAP
		0x800687d0
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_faf_amp_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_faf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_faf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_faf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_faf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_faf_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_faf_amp_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_faf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_faf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_faf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_faf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_faf_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_faf_amp_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_faf_cold_tco_rij
		"Quantity of after injection for cold coolant temperature during regular injection"
		MAP
		0x800685d0
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_faf_cold_tco_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_faf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_faf_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_faf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_faf_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_faf_max_rij
		"Maximum quantity of after injection during regular injection"
		MAP
		0x80068508
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_faf_max_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_faf_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_faf_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_faf_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_faf_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_faf_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_faf_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_faf_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_faf_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_faf_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_faf_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_faf_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_faf_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_faf_mv_tco_rij
		"Quantity of after injection for medium coolant temperature during regular injection"
		MAP
		0x80068308
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_faf_mv_tco_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_faf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_faf_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_faf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_faf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_faf_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_faf_tia_cor_rij
		"Intake air temperature correction for quantity of after injection during regular injection"
		MAP
		0x800681e8
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_faf_tia_cor_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_faf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_faf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_faf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_faf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_faf_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_faf_tia_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_faf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_faf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_faf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_faf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_faf_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_faf_tia_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_faf_tia_fac_rij
		"Factor of intake air temperature correction for quantity of after injection during regular injection"
		MAP
		0x800681b8
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_faf_tia_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_faf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_faf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_faf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_faf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_faf_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_faf_tia_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_faf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_faf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_faf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_faf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_faf_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_faf_tia_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_flp2_wish_h
		"High level of activation of split late post injection"
		MAP
		0x80049810
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_flp2_wish_h 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_flp2_wish_h */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_flp2_wish_h */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_flp2_wish_h */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_flp2_wish_h */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_flp2_wish_h */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_flp2_wish_h 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_flp2_wish_h */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_flp2_wish_h */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_flp2_wish_h */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_flp2_wish_h */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_flp2_wish_h */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_flp2_wish_h 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_flp_maf_err_fac_pr
		"Interpolation table of factor for maximum quantity of late post injection during CSF regeneration"
		MAP
		0x80044758
		RSA_RecordLayout_MAP_UWORD
		6.5535
		dfzFahb_jhnifha_BagaAvb__A_100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cmp_fms_flp_maf_err_fac_pr 
    FORMAT "%6.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_flp_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_flp_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_flp_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_flp_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_flp_maf_err_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_flp_maf_err_fac_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_maf_flp_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_maf_flp_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_maf_flp_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_maf_flp_maf_err_fac_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_maf_flp_maf_err_fac_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_flp_maf_err_fil
			tClffab_hirDflc_mxtqjrd_mtA_o00
			6
			-3000.
			3000.
        AXIS_PTS_REF Ctb_maf_flp_maf_err_fac_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_flp_min_pr
		"Interpolation table of minimum quantity of late post injection during pft regeneration"
		MAP
		0x80044690
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_flp_min_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_flp_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_flp_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_flp_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_flp_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_flp_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_flp_min_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_flp_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_flp_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_flp_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_flp_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_flp_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_flp_min_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_amp_cor_pr
		"Atmospheric pressure correction for quantity of pre-injection 1 during pft regeneration"
		MAP
		0x8004b764
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_amp_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_amp_cor_rij
		"Atmospheric pressure correction for quantity of pre-injection 1 regular injection"
		MAP
		0x8004a312
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_amp_cor_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_amp_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_amp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_amp_cor_sta
		"Table of pre-injection 1 quantity correction during Starting Combustion Mode"
		MAP
		0x80068c9a
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_amp_cor_sta 
