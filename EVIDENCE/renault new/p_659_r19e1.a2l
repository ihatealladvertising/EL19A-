	/* ASAP2::Database : delete 'fm_sta_eprm_crk_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_1_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_1_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_1_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_1_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_h_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_h_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_h_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_h_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_h_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_h_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_h_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_1_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_1_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_1_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_1_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_l_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_l_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_l_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_l_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_l_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_l_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_1_l_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_2_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_2_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_2_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_2_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_h_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_h_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_h_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_h_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_h_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_h_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_h_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_2_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_2_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_2_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_2_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_l_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_l_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_l_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_l_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_l_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_l_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_2_l_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_3_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_3_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_3_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_3_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_h_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_h_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_h_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_h_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_h_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_h_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_h_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_3_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_3_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_3_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_3_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_l_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_l_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_l_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_l_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_l_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_l_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_3_l_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_4_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_4_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_4_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_4_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_h_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_h_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_h_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_h_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_h_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_h_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_h_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_4_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_4_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_4_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cyl_bal_4_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_l_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_l_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_l_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_l_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_l_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_l_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cyl_bal_4_l_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_neg_dev.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_neg_dev.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_neg_dev.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_neg_dev.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_neg_dev.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_neg_dev.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_neg_dev.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_neg_dev.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_neg_dev.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_neg_dev.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_neg_dev.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_neg_dev.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_pos_dev.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_pos_dev.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_pos_dev.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_doc2_utp_pos_dev.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_pos_dev.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_pos_dev.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_pos_dev.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_pos_dev.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_pos_dev.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_pos_dev.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_pos_dev.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_doc2_utp_pos_dev.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_itl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_itl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_itl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_itl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_itl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_itl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_itl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_itl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_itl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_itl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_itl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_itl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ecu_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ecu_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ro2_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ro2_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ro2_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ro2_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_slow_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_slow_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_slow_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_slow_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_slow_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_slow_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_slow_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_ro2_slow_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_tip_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_tip_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_tip_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_tip_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_tip_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_tip_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_tip_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_tip_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_tip_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_tip_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_tip_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_tip_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_uo2_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_uo2_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_uo2_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_dps_uo2_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_uo2_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_uo2_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_uo2_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_uo2_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_uo2_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_uo2_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_uo2_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_dps_uo2_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_adc_tron.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_adc_tron.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_adc_tron.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_adc_tron.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_adc_tron.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_adc_tron.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_adc_tron.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_adc_tron.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_adc_tron.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_adc_tron.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_adc_tron.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_adc_tron.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_cmp.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_cmp.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_cmp.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_cmp.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_cmp.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_cmp.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_cmp.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_ini.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_ini.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_ini.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_ini.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_ini.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_ini.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_ini.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_ini.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_ini.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_ini.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_ini.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_ini.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_inj_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_inj_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_it_lih_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_it_lih_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_it_lih_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_it_lih_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_lih_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_lih_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_lih_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_lih_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_lih_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_lih_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_lih_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_lih_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_it_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_it_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_it_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_it_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_it_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_clc_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_clc_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_clc_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_clc_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_clc_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_clc_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_clc_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_clc_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_clc_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_clc_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_clc_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_clc_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_seq_ctr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_seq_ctr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_seq_ctr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mcw_seq_ctr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_seq_ctr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_seq_ctr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_seq_ctr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_seq_ctr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_seq_ctr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_seq_ctr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_seq_ctr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mcw_seq_ctr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mon_tron.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mon_tron.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mon_tron.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_mon_tron.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mon_tron.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mon_tron.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mon_tron.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mon_tron.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mon_tron.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mon_tron.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mon_tron.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_mon_tron.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_temp_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_temp_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_temp_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ecm_temp_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_temp_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_temp_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_temp_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_temp_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_temp_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_temp_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_temp_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ecm_temp_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_efi_pump_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_efi_pump_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_byp_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_byp_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_cool_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_cool_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_cool_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_egr_cool_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_cool_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_cool_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_cool_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_cool_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_cool_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_cool_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_cool_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_egr_cool_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_fcap_abn_cple.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_fcap_abn_cple.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_fcap_abn_cple.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_fcap_abn_cple.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_abn_cple.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_abn_cple.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_abn_cple.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_abn_cple.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_abn_cple.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_abn_cple.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_abn_cple.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_abn_cple.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_fcap_no_lk.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_fcap_no_lk.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_fcap_no_lk.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_fcap_no_lk.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_no_lk.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_no_lk.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_no_lk.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_no_lk.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_no_lk.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_no_lk.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_no_lk.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_fcap_no_lk.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_blk_clos.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_blk_clos.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_blk_clos.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_blk_clos.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_blk_clos.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_blk_clos.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_blk_clos.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_blk_clos.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_blk_clos.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_blk_clos.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_blk_clos.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_blk_clos.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_eva_sldv_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eva_sldv_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_evap_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_evap_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_evap_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_evap_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_evap_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_evap_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_evap_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_evap_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_evap_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_crk_cmp.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_crk_cmp.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_crk_cmp.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_crk_cmp.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_crk_cmp.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_crk_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_crk_cmp.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_crk_cmp.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_l_puls.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_l_puls.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_l_puls.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_l_puls.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_l_puls.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_l_puls.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_l_puls.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_syn.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_syn.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_syn.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ex_cam_syn.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_syn.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_syn.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_syn.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_syn.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_syn.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_syn.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_syn.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ex_cam_syn.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_exh_temp_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_exh_temp_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_exh_temp_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_exh_temp_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_exh_temp_cmp.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_exh_temp_cmp.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_exh_temp_cmp.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_exh_temp_cmp.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_exh_temp_cmp.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_exh_temp_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_exh_temp_cmp.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_exh_temp_cmp.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_actr_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_actr_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_actr_blk.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_actr_blk.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_actr_blk.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_actr_blk.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_actr_blk.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_actr_blk.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_actr_blk.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_actr_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_actr_blk.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_actr_blk.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_no_norm.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_no_norm.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_no_norm.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_no_norm.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_no_norm.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_no_norm.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_no_norm.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_shp.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ff_fct_shp.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_shp.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_shp.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_shp.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_shp.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_shp.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_shp.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ff_fct_shp.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_actr_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_actr_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_actr_blk.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_actr_blk.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_actr_blk.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_actr_blk.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_actr_blk.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_actr_blk.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_actr_blk.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_actr_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_actr_blk.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_actr_blk.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_fct_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_fct_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_fct_shp.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_fct_shp.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_fct_shp.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_fct_shp.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_fct_shp.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_fct_shp.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_fct_shp.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_fct_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_fct_shp.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_fct_shp.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_h_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_h_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_h_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_h_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_h_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_h_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_h_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_h_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_h_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_h_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_h_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_h_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_l_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_l_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_l_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fprs_l_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_l_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_l_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_l_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_l_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_l_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_l_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_l_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fprs_l_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fsys_cpt.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fsys_cpt.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fsys_cpt.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fsys_cpt.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_cpt.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_cpt.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_cpt.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_cpt.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_cpt.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_cpt.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_cpt.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_cpt.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fsys_lpg_cpt.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fsys_lpg_cpt.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fsys_lpg_cpt.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fsys_lpg_cpt.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_lpg_cpt.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_lpg_cpt.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_lpg_cpt.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_lpg_cpt.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_lpg_cpt.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_lpg_cpt.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_lpg_cpt.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fsys_lpg_cpt.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_plaus.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_plaus.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_plaus.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_plaus.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_plaus.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_plaus.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_plaus.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_plaus.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_plaus.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_plaus.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_plaus.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_plaus.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_sig_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_sig_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_sig_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_fuel_temp_sig_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_sig_mcut.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_sig_mcut.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_sig_mcut.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_sig_mcut.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_sig_mcut.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_sig_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_sig_mcut.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_fuel_temp_sig_mcut.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_gas_pump_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_gas_pump_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_glow_cmd_cpt_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_glow_cmd_cpt_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_glow_cmd_cpt_blk.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_glow_cmd_cpt_blk.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_glow_cmd_cpt_blk.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_glow_cmd_cpt_blk.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_glow_cmd_cpt_blk.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_glow_cmd_cpt_blk.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_glow_cmd_cpt_blk.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_glow_cmd_cpt_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_glow_cmd_cpt_blk.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_glow_cmd_cpt_blk.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_4_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_4_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_1_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_1_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_3_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_3_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_2_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_2_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_3_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_3_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_igc_4_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_igc_4_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_frq_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_frq_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_frq_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_frq_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_frq_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_frq_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_frq_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_frq_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_frq_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_frq_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_frq_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_frq_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_l_puls.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_l_puls.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_l_puls.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_l_puls.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_l_puls.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_l_puls.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_l_puls.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_syn.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_syn.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_syn.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_cam_syn.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_syn.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_syn.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_syn.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_syn.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_syn.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_syn.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_syn.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_cam_syn.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_ad.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_ad.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_ad.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_ad.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_ad.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_ad.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_ad.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_ad.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_ad.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_ad.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_ad.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_ad.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_blk.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_blk.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_blk.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_blk.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_blk.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_blk.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_blk.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_blk.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_blk.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_in_vvtc_sldv_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_in_vvtc_sldv_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_4_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_4_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_4_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_4_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_4_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_4_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_4_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_4_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_4_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_4_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_4_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_4_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_fast_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_fast_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_fast_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_fast_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_fast_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_fast_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_fast_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_fast_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_fast_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_fast_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_fast_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_fast_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_freq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_freq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_freq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_freq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_freq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_freq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_freq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_freq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_freq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_freq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_freq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_freq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_frq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_frq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_frq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_frq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_frq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_frq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_frq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_frq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_frq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_frq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_frq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_frq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_r.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_r.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_r.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_r.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_r.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_r.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_r.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_r.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_r.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_r.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_r.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_r.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_slow_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_slow_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_slow_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj1_slow_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_slow_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_slow_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_slow_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_slow_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_slow_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_slow_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_slow_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj1_slow_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_3_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_3_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_3_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_3_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_3_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_3_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_3_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_3_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_3_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_3_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_3_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_3_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_fast_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_fast_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_fast_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_fast_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_fast_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_fast_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_fast_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_fast_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_fast_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_fast_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_fast_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_fast_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_freq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_freq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_freq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_freq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_freq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_freq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_freq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_freq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_freq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_freq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_freq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_freq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_frq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_frq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_frq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_frq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_frq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_frq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_frq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_frq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_frq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_frq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_frq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_frq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_r.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_r.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_r.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_r.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_r.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_r.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_r.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_r.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_r.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_r.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_r.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_r.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_slow_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_slow_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_slow_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj2_slow_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_slow_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_slow_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_slow_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_slow_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_slow_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_slow_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_slow_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj2_slow_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_fast_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_fast_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_fast_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_fast_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_fast_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_fast_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_fast_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_fast_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_fast_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_fast_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_fast_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_fast_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_freq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_freq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_freq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_freq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_freq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_freq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_freq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_freq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_freq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_freq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_freq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_freq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_frq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_frq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_frq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_frq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_frq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_frq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_frq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_frq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_frq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_frq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_frq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_frq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_r.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_r.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_r.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_r.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_r.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_r.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_r.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_r.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_r.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_r.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_r.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_r.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_slow_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_slow_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_slow_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj3_slow_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_slow_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_slow_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_slow_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_slow_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_slow_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_slow_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_slow_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj3_slow_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_fast_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_fast_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_fast_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_fast_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_fast_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_fast_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_fast_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_fast_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_fast_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_fast_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_fast_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_fast_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_freq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_freq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_freq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_freq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_freq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_freq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_freq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_freq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_freq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_freq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_freq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_freq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_frq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_frq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_frq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_frq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_frq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_frq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_frq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_frq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_frq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_frq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_frq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_frq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_r.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_r.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_r.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_r.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_r.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_r.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_r.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_r.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_r.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_r.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_r.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_r.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_slow_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_slow_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_slow_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj4_slow_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_slow_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_slow_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_slow_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_slow_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_slow_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_slow_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_slow_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj4_slow_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_bus_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_bus_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_bus_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_bus_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_bus_mcut.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_bus_mcut.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_bus_mcut.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_bus_mcut.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_bus_mcut.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_bus_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_bus_mcut.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_bus_mcut.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_itl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_itl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_itl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_itl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_itl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_itl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_itl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_itl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_itl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_itl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_itl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_itl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_lbdw_icp.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_lbdw_icp.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_lbdw_icp.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_lbdw_icp.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbdw_icp.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbdw_icp.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbdw_icp.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbdw_icp.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbdw_icp.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbdw_icp.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbdw_icp.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbdw_icp.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_lbup_icp.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_lbup_icp.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_lbup_icp.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_inj_ecu_lbup_icp.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbup_icp.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbup_icp.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbup_icp.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbup_icp.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbup_icp.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbup_icp.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbup_icp.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_inj_ecu_lbup_icp.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_isr_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_isr_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_isr_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_isr_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_h_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_h_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_h_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_h_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_h_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_h_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_h_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_isr_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_isr_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_isr_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_isr_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_l_lvl.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_l_lvl.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_l_lvl.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_l_lvl.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_l_lvl.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_l_lvl.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_isr_l_lvl.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_cmd_el.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_cmd_el.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_cmd_el.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_cmd_el.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_cmd_el.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_cmd_el.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_cmd_el.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_cmd_el.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_cmd_el.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_cmd_el.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_cmd_el.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_cmd_el.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_ofs_meca.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_ofs_meca.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_ofs_meca.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_ofs_meca.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_meca.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_meca.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_meca.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_meca.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_meca.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_meca.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_meca.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_meca.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_ofs_secu_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_ofs_secu_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_ofs_secu_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_ofs_secu_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_secu_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_secu_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_secu_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_secu_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_secu_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_secu_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_secu_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_ofs_secu_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_reg_ad.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_reg_ad.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_reg_ad.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_reg_ad.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_ad.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_ad.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_ad.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_ad.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_ad.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_ad.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_ad.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_ad.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_reg_el.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_reg_el.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_reg_el.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_it_reg_el.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_el.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_el.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_el.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_el.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_el.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_el.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_el.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_it_reg_el.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_knk_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_knk_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_knk_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_knk_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_knk_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_knk_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_knk_shp.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_knk_shp.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_shp.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_shp.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_shp.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_shp.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_shp.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_shp.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_knk_shp.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_hot_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_hot_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbdw_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbdw_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_cpt.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_cpt.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_cpt.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_cpt.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_cpt.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_cpt.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_cpt.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_cpt.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_cpt.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_cpt.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_cpt.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_cpt.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_apl_down.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_apl_down.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_apl_down.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_apl_down.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_apl_down.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_apl_down.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_apl_down.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_hot_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_hot_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_lbup_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_lbup_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_maf_reg_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_maf_reg_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_maf_reg_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_maf_reg_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_maf_reg_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_maf_reg_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_maf_reg_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_maf_reg_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_maf_reg_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_maf_reg_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_maf_reg_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_maf_reg_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mafs_plau_diag_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mafs_plau_diag_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mafs_plau_diag_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mafs_plau_diag_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mafs_plau_diag_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mafs_plau_diag_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mafs_plau_diag_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mafs_plau_diag_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mafs_plau_diag_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_map_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_map_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_map_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_map_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_map_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_map_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_map_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_map_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_map_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf1_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf1_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mdf2_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mdf2_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_lpg_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_lpg_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_lpg_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_lpg_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_lpg_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_lpg_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_lpg_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_lpg_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_lpg_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_1_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_1_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_lpg_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_lpg_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_lpg_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_lpg_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_lpg_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_lpg_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_lpg_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_lpg_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_lpg_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_2_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_2_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_lpg_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_lpg_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_lpg_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_lpg_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_lpg_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_lpg_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_lpg_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_lpg_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_lpg_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_3_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_3_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_lpg_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_lpg_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_lpg_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_lpg_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_lpg_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_lpg_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_lpg_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_lpg_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_lpg_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_4_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_4_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_lpg_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_lpg_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_lpg_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_lpg_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_lpg_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_lpg_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_lpg_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_lpg_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_lpg_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_min_fuel_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_min_fuel_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_min_fuel_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_min_fuel_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_min_fuel_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_min_fuel_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_min_fuel_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_min_fuel_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_min_fuel_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_lpg_cata.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_lpg_cata.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_lpg_cata.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_lpg_cata.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_cata.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_cata.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_cata.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_cata.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_cata.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_cata.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_cata.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_cata.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_lpg_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_lpg_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_lpg_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_lpg_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_lpg_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_trs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_trs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_trs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mis_unk_trs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_trs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_trs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_trs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_trs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_trs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_trs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_trs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mis_unk_trs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_pump_rly_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_pump_rly_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_pump_rly_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_pump_rly_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_pump_rly_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_pump_rly_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_pump_rly_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_pump_rly_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_pump_rly_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_sys_cpt.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_sys_cpt.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_sys_cpt.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_mvac_sys_cpt.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_sys_cpt.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_sys_cpt.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_sys_cpt.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_sys_cpt.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_sys_cpt.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_sys_cpt.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_sys_cpt.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_mvac_sys_cpt.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oil_dil_ovs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oil_dil_ovs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oil_dil_ovs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oil_dil_ovs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oil_dil_ovs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oil_dil_ovs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oil_dil_ovs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oil_dil_ovs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oil_dil_ovs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oil_dil_ovs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oil_dil_ovs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oil_dil_ovs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oit_hbdg_el.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oit_hbdg_el.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oit_hbdg_el.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oit_hbdg_el.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_el.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_el.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_el.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_el.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_el.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_el.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_el.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_el.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oit_hbdg_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oit_hbdg_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oit_hbdg_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_oit_hbdg_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_ovh.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_ovh.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_ovh.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_ovh.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_ovh.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_ovh.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_oit_hbdg_ovh.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pcv_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pcv_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dp_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dp_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dp_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dp_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dp_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dp_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dp_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dp_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dp_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_dtp_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_ovh.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_ovh.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_ovh.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_ovh.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_ovh.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_ovh.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_dtp_ovh.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_rgn_max_err.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_rgn_max_err.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_rgn_max_err.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_rgn_max_err.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_rgn_max_err.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_rgn_max_err.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_rgn_max_err.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_rgn_max_err.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_rgn_max_err.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_rgn_max_err.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_rgn_max_err.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_rgn_max_err.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_utp_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_utp_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_utp_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pft_utp_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_utp_ovh.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_utp_ovh.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_utp_ovh.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_utp_ovh.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_utp_ovh.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_utp_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_utp_ovh.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pft_utp_ovh.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pftrelprs_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pftrelprs_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pftrelprs_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pftrelprs_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pftrelprs_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pftrelprs_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pftrelprs_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_pftrelprs_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_pftrelprs_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_max_h_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_max_h_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_max_h_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_max_h_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_h_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_h_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_h_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_h_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_h_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_h_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_h_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_h_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_max_l_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_max_l_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_max_l_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_max_l_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_l_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_l_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_l_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_l_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_l_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_l_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_l_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_max_l_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_min_h_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_min_h_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_min_h_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_min_h_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_h_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_h_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_h_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_h_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_h_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_h_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_h_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_h_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_min_l_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_min_l_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_min_l_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_min_l_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_l_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_l_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_l_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_l_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_l_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_l_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_l_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_min_l_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_sig_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_sig_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_sig_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ps_toil_sig_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_sig_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_sig_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_sig_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_sig_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_sig_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_sig_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_sig_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ps_toil_sig_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_max_h_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_max_h_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_max_h_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_max_h_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_h_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_h_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_h_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_h_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_h_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_h_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_h_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_h_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_max_l_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_max_l_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_max_l_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_max_l_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_l_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_l_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_l_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_l_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_l_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_l_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_l_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_max_l_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_min_h_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_min_h_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_min_h_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_min_h_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_h_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_h_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_h_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_h_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_h_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_h_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_h_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_h_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_min_l_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_min_l_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_min_l_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_min_l_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_l_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_l_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_l_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_l_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_l_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_l_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_l_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_min_l_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_sig_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_sig_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_sig_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilprty_sig_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_sig_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_sig_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_sig_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_sig_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_sig_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_sig_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_sig_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilprty_sig_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_max_h_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_max_h_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_max_h_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_max_h_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_h_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_h_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_h_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_h_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_h_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_h_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_h_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_h_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_max_l_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_max_l_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_max_l_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_max_l_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_l_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_l_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_l_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_l_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_l_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_l_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_l_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_max_l_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_min_h_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_min_h_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_min_h_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_min_h_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_h_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_h_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_h_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_h_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_h_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_h_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_h_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_h_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_min_l_t.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_min_l_t.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_min_l_t.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_min_l_t.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_l_t.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_l_t.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_l_t.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_l_t.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_l_t.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_l_t.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_l_t.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_min_l_t.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_sig_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_sig_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_sig_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_psoilvisc_sig_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_sig_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_sig_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_sig_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_sig_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_sig_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_sig_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_sig_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_psoilvisc_sig_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc1_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc1_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc2_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc2_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc3_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc3_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ptc_rov_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ptc_rov_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_rail_prs_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_rail_prs_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_rail_prs_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_rail_prs_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_rail_prs_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_rail_prs_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_rail_prs_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_rail_prs_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_rail_prs_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_rail_prs_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_rail_prs_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_rail_prs_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_alt_pwm_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_alt_pwm_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_alt_pwm_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_alt_pwm_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_alt_pwm_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_alt_pwm_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_alt_pwm_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_alt_pwm_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_alt_pwm_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_reg_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_reg_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_reg_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_reg_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_reg_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_reg_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_reg_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_reg_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_reg_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_reg_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_reg_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_reg_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_amp_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_amp_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_ovh.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_ovh.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_ovh.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_ovh.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_ovh.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_ovh.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_ovh.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_heat_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_heat_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_lamb_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_lamb_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_lamb_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_lamb_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_lamb_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_lamb_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_lamb_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_lamb_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_lamb_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_lamb_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_lamb_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_lamb_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_pump_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_pump_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_pump_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_pump_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_pump_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_pump_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_pump_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_pump_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_pump_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_pump_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_pump_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_pump_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_virt_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_virt_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_virt_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_virt_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_virt_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_virt_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_virt_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_virt_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_virt_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_virt_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_virt_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_virt_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_wire_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_wire_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_wire_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_wire_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_wire_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_wire_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_wire_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_dps_wire_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_dps_wire_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_no_lk.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_no_lk.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_no_lk.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_no_lk.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_no_lk.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_no_lk.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_no_lk.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_no_lk.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ex_prs_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ex_prs_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ex_prs_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ex_prs_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ex_prs_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_1_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_1_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_1_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_1_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_1_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_1_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_1_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_1_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_1_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_1_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_1_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_1_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_2_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_2_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_2_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_2_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_2_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_2_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_2_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_2_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_2_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_2_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_2_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_2_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_sig_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_sig_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_sig_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_it_sig_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_sig_mcut.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_sig_mcut.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_sig_mcut.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_sig_mcut.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_sig_mcut.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_sig_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_sig_mcut.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_it_sig_mcut.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_maf_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_maf_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_map_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_map_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pft_dp_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pft_dp_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_pftrelprs_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_pftrelprs_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_sig_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_sig_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_sig_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_rvc_sig_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_sig_mcut.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_sig_mcut.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_sig_mcut.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_sig_mcut.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_sig_mcut.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_sig_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_sig_mcut.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_rvc_sig_mcut.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_spg_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_spg_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_tia_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_tia_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_toil_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_toil_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_toil_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_toil_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_toil_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_toil_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_toil_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_toil_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_toil_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ups_wire_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ups_wire_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ups_wire_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_ups_wire_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ups_wire_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ups_wire_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ups_wire_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ups_wire_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ups_wire_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ups_wire_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ups_wire_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_ups_wire_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_wfl_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_wfl_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_wfl_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_wfl_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_wfl_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_wfl_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_wfl_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_wfl_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_wfl_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sfty_tq_lih_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sfty_tq_lih_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sfty_tq_lih_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sfty_tq_lih_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lih_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lih_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lih_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lih_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lih_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lih_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lih_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lih_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sfty_tq_lim.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sfty_tq_lim.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sfty_tq_lim.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sfty_tq_lim.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lim.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lim.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lim.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lim.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lim.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lim.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lim.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sfty_tq_lim.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_hbdg_el.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_hbdg_el.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_hbdg_el.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_hbdg_el.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_el.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_el.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_el.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_el.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_el.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_el.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_el.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_el.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_hbdg_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_hbdg_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_hbdg_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_hbdg_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_ovh.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_ovh.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_ovh.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_ovh.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_ovh.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_ovh.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_hbdg_ovh.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_blk.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_blk.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk_open.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk_open.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk_open.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk_open.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk_open.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk_open.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_blk_open.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_el.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_el.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_el.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sit_reg_el.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_el.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_el.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_el.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_el.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_el.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_el.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_el.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sit_reg_el.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_oor.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_oor.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_oor.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_oor.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_oor.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_oor.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_oor.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_oor.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_oor.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_reg_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_reg_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_reg_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_reg_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_neg_err.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_neg_err.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_neg_err.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_neg_err.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_neg_err.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_neg_err.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_neg_err.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_reg_pos_err.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_reg_pos_err.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_reg_pos_err.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_spg_reg_pos_err.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_pos_err.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_pos_err.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_pos_err.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_pos_err.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_pos_err.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_pos_err.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_pos_err.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_spg_reg_pos_err.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tbt_reg_pos_err.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tbt_reg_pos_err.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tbt_reg_pos_err.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tbt_reg_pos_err.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tbt_reg_pos_err.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tbt_reg_pos_err.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tbt_reg_pos_err.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tbt_reg_pos_err.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tbt_reg_pos_err.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tbt_reg_pos_err.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tbt_reg_pos_err.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tbt_reg_pos_err.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tco_cl_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tco_cl_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tco_cl_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tco_cl_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tco_cl_no_norm.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tco_cl_no_norm.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tco_cl_no_norm.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tco_cl_no_norm.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tco_cl_no_norm.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tco_cl_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tco_cl_no_norm.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tco_cl_no_norm.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tlz_ad_b_cpt.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tlz_ad_b_cpt.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tlz_ad_b_cpt.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tlz_ad_b_cpt.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tlz_ad_b_cpt.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tlz_ad_b_cpt.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tlz_ad_b_cpt.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tlz_ad_b_cpt.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tlz_ad_b_cpt.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tlz_ad_b_cpt.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tlz_ad_b_cpt.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tlz_ad_b_cpt.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tsta_reg_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tsta_reg_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tsta_reg_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_tsta_reg_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tsta_reg_no_norm.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tsta_reg_no_norm.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tsta_reg_no_norm.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tsta_reg_no_norm.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tsta_reg_no_norm.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tsta_reg_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tsta_reg_no_norm.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_tsta_reg_no_norm.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_crt_intv.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_crt_intv.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_crt_intv.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_crt_intv.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_crt_intv.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_crt_intv.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_crt_intv.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_crt_intv.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_crt_intv.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_crt_intv.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_crt_intv.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_crt_intv.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_heat_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_heat_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_heat_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_heat_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_heat_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_heat_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_heat_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_heat_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_heat_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_hot_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_hot_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_hot_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_hot_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_hot_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_hot_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_hot_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_hot_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_hot_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_hot_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_hot_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_hot_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_lamb_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_lamb_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_pump_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_pump_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_shp.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_shp.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_shp.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_shp.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_shp.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_shp.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_shp.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_shp.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_shp.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_slow_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_slow_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_slow_trs.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_slow_trs.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_slow_trs.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_slow_trs.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_slow_trs.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_slow_trs.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_slow_trs.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_slow_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_slow_trs.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_slow_trs.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_trim_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_trim_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_virt_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_virt_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_virt_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_virt_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_virt_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_virt_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_virt_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ups_virt_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ups_virt_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vb_clc_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vb_clc_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vb_clc_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vb_clc_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vb_clc_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vb_clc_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vb_clc_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vb_clc_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vb_clc_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vb_clc_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vb_clc_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vb_clc_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vcv_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vcv_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_vnt_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_vnt_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wgc_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wgc_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_freq_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_freq_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_freq_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_freq_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_freq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_freq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_freq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_freq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_freq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_no_sig.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_no_sig.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_no_sig.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_no_sig.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_no_sig.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_no_sig.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_no_sig.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_no_sig.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_no_sig.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_no_sig.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_no_sig.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_no_sig.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_2_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_2_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_freq_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_freq_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_freq_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_freq_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_freq_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_freq_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_freq_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_freq_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_freq_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_no_sig.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_no_sig.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_no_sig.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_no_sig.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_no_sig.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_no_sig.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_no_sig.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_no_sig.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_no_sig.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_no_sig.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_no_sig.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_no_sig.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_wpmp_egr_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_wpmp_egr_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : 4560 referenced entries deleted */
	/begin OUT_MEASUREMENT
			DgDftMng_NVM.Sbx_obd_rdn_cata_cpt_NVM
			DgDftMng_NVM.Sbx_obd_rdn_lbup_cpt_NVM
			DgDftMng_NVM.Sbx_obd_rdn_egr_NVM
			DgDftMng_NVM.Sbx_obd_rdn_cata_NVM
			DgDftMng_NVM.Sbx_obd_rdn_heat_NVM
			DgDftMng_NVM.Sbx_obd_rdn_evap_NVM
			DgDftMng_NVM.Sbx_obd_rdn_pft_NVM
			fm_sta_eprm_ac_prs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ac_prs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ac_prs_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ac_prs_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ac_prs_h.Vxx_dfctr_xxx
			fm_sta_ac_prs_h.Vxx_rdn_xxx
			fm_sta_ac_prs_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ac_prs_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ac_prs_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ac_prs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ac_prs_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ac_prs_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_ac_prs_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ac_prs_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ac_prs_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ac_prs_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ac_prs_l.Vxx_dfctr_xxx
			fm_sta_ac_prs_l.Vxx_rdn_xxx
			fm_sta_ac_prs_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ac_prs_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ac_prs_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ac_prs_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ac_prs_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ac_prs_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_acel_pdl_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_acel_pdl_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_acel_pdl_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_acel_pdl_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_acel_pdl_chr.Vxx_dfctr_xxx
			fm_sta_acel_pdl_chr.Vxx_rdn_xxx
			fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_acel_pdl_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_acel_pdl_secu_1.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_acel_pdl_secu_1.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_acel_pdl_secu_1.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_acel_pdl_secu_1.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_acel_pdl_secu_1.Vxx_dfctr_xxx
			fm_sta_acel_pdl_secu_1.Vxx_rdn_xxx
			fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_acel_pdl_secu_1.Vxx_dtc_stt_xxx
			fm_sta_eprm_acel_pdl_secu_2.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_acel_pdl_secu_2.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_acel_pdl_secu_2.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_acel_pdl_secu_2.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_acel_pdl_secu_2.Vxx_dfctr_xxx
			fm_sta_acel_pdl_secu_2.Vxx_rdn_xxx
			fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_acel_pdl_secu_2.Vxx_dtc_stt_xxx
			fm_sta_eprm_acel_pdl_tot.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_acel_pdl_tot.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_acel_pdl_tot.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_acel_pdl_tot.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_acel_pdl_tot.Vxx_dfctr_xxx
			fm_sta_acel_pdl_tot.Vxx_rdn_xxx
			fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_acel_pdl_tot.Vxx_dtc_stt_xxx
			fm_sta_eprm_acel_pdl_v1_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_acel_pdl_v1_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_acel_pdl_v1_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_acel_pdl_v1_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_acel_pdl_v1_h.Vxx_dfctr_xxx
			fm_sta_acel_pdl_v1_h.Vxx_rdn_xxx
			fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_acel_pdl_v1_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_acel_pdl_v1_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_acel_pdl_v1_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_acel_pdl_v1_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_acel_pdl_v1_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_acel_pdl_v1_l.Vxx_dfctr_xxx
			fm_sta_acel_pdl_v1_l.Vxx_rdn_xxx
			fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_acel_pdl_v1_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_acel_pdl_v2_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_acel_pdl_v2_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_acel_pdl_v2_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_acel_pdl_v2_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_acel_pdl_v2_h.Vxx_dfctr_xxx
			fm_sta_acel_pdl_v2_h.Vxx_rdn_xxx
			fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_acel_pdl_v2_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_acel_pdl_v2_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_acel_pdl_v2_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_acel_pdl_v2_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_acel_pdl_v2_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_acel_pdl_v2_l.Vxx_dfctr_xxx
			fm_sta_acel_pdl_v2_l.Vxx_rdn_xxx
			fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_acel_pdl_v2_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_actr_rly_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_actr_rly_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_actr_rly_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_actr_rly_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_actr_rly_oc.Vxx_dfctr_xxx
			fm_sta_actr_rly_oc.Vxx_rdn_xxx
			fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_actr_rly_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_actr_rly_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_actr_rly_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_actr_rly_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_actr_rly_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_actr_rly_scg.Vxx_dfctr_xxx
			fm_sta_actr_rly_scg.Vxx_rdn_xxx
			fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_actr_rly_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_actr_rly_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_actr_rly_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_actr_rly_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_actr_rly_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_actr_rly_scw.Vxx_dfctr_xxx
			fm_sta_actr_rly_scw.Vxx_rdn_xxx
			fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_actr_rly_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_agb_data_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_agb_data_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_agb_data_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_agb_data_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_agb_data_chr.Vxx_dfctr_xxx
			fm_sta_agb_data_chr.Vxx_rdn_xxx
			fm_sta_agb_data_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_agb_data_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_agb_data_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_agb_data_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_agb_data_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_agb_data_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_agb_data_seq_ctr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_agb_data_seq_ctr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_agb_data_seq_ctr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_agb_data_seq_ctr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_agb_data_seq_ctr.Vxx_dfctr_xxx
			fm_sta_agb_data_seq_ctr.Vxx_rdn_xxx
			fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_agb_data_seq_ctr.Vxx_dtc_stt_xxx
			fm_sta_eprm_agb_data_tout.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_agb_data_tout.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_agb_data_tout.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_agb_data_tout.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_agb_data_tout.Vxx_dfctr_xxx
			fm_sta_agb_data_tout.Vxx_rdn_xxx
			fm_sta_agb_data_tout.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_agb_data_tout.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_agb_data_tout.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_agb_data_tout.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_agb_data_tout.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_agb_data_tout.Vxx_dtc_stt_xxx
			fm_sta_eprm_agb_no_frm.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_agb_no_frm.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_agb_no_frm.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_agb_no_frm.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_agb_no_frm.Vxx_dfctr_xxx
			fm_sta_agb_no_frm.Vxx_rdn_xxx
			fm_sta_agb_no_frm.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_agb_no_frm.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_agb_no_frm.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_agb_no_frm.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_agb_no_frm.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_agb_no_frm.Vxx_dtc_stt_xxx
			fm_sta_eprm_amp_reg_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_amp_reg_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_amp_reg_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_amp_reg_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_amp_reg_chr.Vxx_dfctr_xxx
			fm_sta_amp_reg_chr.Vxx_rdn_xxx
			fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_amp_reg_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_bgin_clu_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_bgin_clu_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_bgin_clu_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_bgin_clu_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_bgin_clu_cmp.Vxx_dfctr_xxx
			fm_sta_bgin_clu_cmp.Vxx_rdn_xxx
			fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_bgin_clu_cmp.Vxx_dtc_stt_xxx
			fm_sta_eprm_bgin_clu_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_bgin_clu_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_bgin_clu_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_bgin_clu_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_bgin_clu_nok.Vxx_dfctr_xxx
			fm_sta_bgin_clu_nok.Vxx_rdn_xxx
			fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_bgin_clu_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_brk_pdl_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_brk_pdl_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_brk_pdl_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_brk_pdl_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_brk_pdl_cmp.Vxx_dfctr_xxx
			fm_sta_brk_pdl_cmp.Vxx_rdn_xxx
			fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_brk_pdl_cmp.Vxx_dtc_stt_xxx
			fm_sta_eprm_cata_nok_cge.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_cata_nok_cge.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_cata_nok_cge.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_cata_nok_cge.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_cata_nok_cge.Vxx_dfctr_xxx
			fm_sta_cata_nok_cge.Vxx_rdn_xxx
			fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_cata_nok_cge.Vxx_dtc_stt_xxx
			fm_sta_eprm_clu_cnt_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_clu_cnt_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_clu_cnt_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_clu_cnt_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_clu_cnt_nok.Vxx_dfctr_xxx
			fm_sta_clu_cnt_nok.Vxx_rdn_xxx
			fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_clu_cnt_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_crk_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_crk_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_crk_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_crk_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_crk_chr.Vxx_dfctr_xxx
			fm_sta_crk_chr.Vxx_rdn_xxx
			fm_sta_crk_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_crk_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_crk_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_crk_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_crk_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_crk_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_crk_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_crk_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_crk_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_crk_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_crk_cmp.Vxx_dfctr_xxx
			fm_sta_crk_cmp.Vxx_rdn_xxx
			fm_sta_crk_cmp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_crk_cmp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_crk_cmp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_crk_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_crk_cmp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_crk_cmp.Vxx_dtc_stt_xxx
			fm_sta_eprm_crk_cyc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_crk_cyc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_crk_cyc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_crk_cyc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_crk_cyc.Vxx_dfctr_xxx
			fm_sta_crk_cyc.Vxx_rdn_xxx
			fm_sta_crk_cyc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_crk_cyc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_crk_cyc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_crk_cyc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_crk_cyc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_crk_cyc.Vxx_dtc_stt_xxx
			fm_sta_eprm_crk_no_sig.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_crk_no_sig.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_crk_no_sig.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_crk_no_sig.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_crk_no_sig.Vxx_dfctr_xxx
			fm_sta_crk_no_sig.Vxx_rdn_xxx
			fm_sta_crk_no_sig.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_crk_no_sig.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_crk_no_sig.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_crk_no_sig.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_crk_no_sig.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_crk_no_sig.Vxx_dtc_stt_xxx
			fm_sta_eprm_crk_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_crk_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_crk_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_crk_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_crk_oc.Vxx_dfctr_xxx
			fm_sta_crk_oc.Vxx_rdn_xxx
			fm_sta_crk_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_crk_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_crk_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_crk_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_crk_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_crk_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_crk_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_crk_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_crk_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_crk_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_crk_shp.Vxx_dfctr_xxx
			fm_sta_crk_shp.Vxx_rdn_xxx
			fm_sta_crk_shp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_crk_shp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_crk_shp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_crk_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_crk_shp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_crk_shp.Vxx_dtc_stt_xxx
			fm_sta_eprm_cru_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_cru_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_cru_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_cru_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_cru_cmp.Vxx_dfctr_xxx
			fm_sta_cru_cmp.Vxx_rdn_xxx
			fm_sta_cru_cmp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_cru_cmp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_cru_cmp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_cru_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_cru_cmp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_cru_cmp.Vxx_dtc_stt_xxx
			fm_sta_eprm_cru_sl_swi_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_cru_sl_swi_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_cru_sl_swi_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_cru_sl_swi_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_cru_sl_swi_chr.Vxx_dfctr_xxx
			fm_sta_cru_sl_swi_chr.Vxx_rdn_xxx
			fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_cru_sl_swi_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_cru_sl_tot.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_cru_sl_tot.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_cru_sl_tot.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_cru_sl_tot.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_cru_sl_tot.Vxx_dfctr_xxx
			fm_sta_cru_sl_tot.Vxx_rdn_xxx
			fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_cru_sl_tot.Vxx_dtc_stt_xxx
			fm_sta_eprm_cru_vs_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_cru_vs_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_cru_vs_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_cru_vs_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_cru_vs_cmp.Vxx_dfctr_xxx
			fm_sta_cru_vs_cmp.Vxx_rdn_xxx
			fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_cru_vs_cmp.Vxx_dtc_stt_xxx
			fm_sta_eprm_cru_whl_cmd_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_cru_whl_cmd_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_cru_whl_cmd_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_cru_whl_cmd_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_cru_whl_cmd_nok.Vxx_dfctr_xxx
			fm_sta_cru_whl_cmd_nok.Vxx_rdn_xxx
			fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_cru_whl_cmd_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_cru_whl_cmd_oc_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_cru_whl_cmd_oc_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_cru_whl_cmd_oc_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_cru_whl_cmd_oc_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_cru_whl_cmd_oc_scw.Vxx_dfctr_xxx
			fm_sta_cru_whl_cmd_oc_scw.Vxx_rdn_xxx
			fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_cru_whl_cmd_oc_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_cru_whl_cmd_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_cru_whl_cmd_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_cru_whl_cmd_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_cru_whl_cmd_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_cru_whl_cmd_oor.Vxx_dfctr_xxx
			fm_sta_cru_whl_cmd_oor.Vxx_rdn_xxx
			fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_cru_whl_cmd_oor.Vxx_dtc_stt_xxx
			fm_sta_eprm_doc1_utp_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_doc1_utp_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_doc1_utp_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_doc1_utp_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_doc1_utp_chr.Vxx_dfctr_xxx
			fm_sta_doc1_utp_chr.Vxx_rdn_xxx
			fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_doc1_utp_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_doc1_utp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_doc1_utp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_doc1_utp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_doc1_utp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_doc1_utp_h.Vxx_dfctr_xxx
			fm_sta_doc1_utp_h.Vxx_rdn_xxx
			fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_doc1_utp_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_doc1_utp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_doc1_utp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_doc1_utp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_doc1_utp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_doc1_utp_l.Vxx_dfctr_xxx
			fm_sta_doc1_utp_l.Vxx_rdn_xxx
			fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_doc1_utp_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_ecm_err_itl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ecm_err_itl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ecm_err_itl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ecm_err_itl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ecm_err_itl.Vxx_dfctr_xxx
			fm_sta_ecm_err_itl.Vxx_rdn_xxx
			fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ecm_err_itl.Vxx_dtc_stt_xxx
			fm_sta_eprm_ecm_err_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ecm_err_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ecm_err_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ecm_err_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ecm_err_no_norm.Vxx_dfctr_xxx
			fm_sta_ecm_err_no_norm.Vxx_rdn_xxx
			fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ecm_err_no_norm.Vxx_dtc_stt_xxx
			fm_sta_eprm_ecm_inj_bus_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ecm_inj_bus_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ecm_inj_bus_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ecm_inj_bus_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ecm_inj_bus_mcut.Vxx_dfctr_xxx
			fm_sta_ecm_inj_bus_mcut.Vxx_rdn_xxx
			fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ecm_inj_bus_mcut.Vxx_dtc_stt_xxx
			fm_sta_eprm_ecm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ecm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ecm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ecm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ecm_inj_cpt_blk.Vxx_dfctr_xxx
			fm_sta_ecm_inj_cpt_blk.Vxx_rdn_xxx
			fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ecm_inj_cpt_blk.Vxx_dtc_stt_xxx
			fm_sta_eprm_ecm_inj_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ecm_inj_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ecm_inj_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ecm_inj_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ecm_inj_no_norm.Vxx_dfctr_xxx
			fm_sta_ecm_inj_no_norm.Vxx_rdn_xxx
			fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ecm_inj_no_norm.Vxx_dtc_stt_xxx
			fm_sta_eprm_ecm_mon_secu_1.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ecm_mon_secu_1.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ecm_mon_secu_1.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ecm_mon_secu_1.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ecm_mon_secu_1.Vxx_dfctr_xxx
			fm_sta_ecm_mon_secu_1.Vxx_rdn_xxx
			fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ecm_mon_secu_1.Vxx_dtc_stt_xxx
			fm_sta_eprm_ecm_mon_secu_2.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ecm_mon_secu_2.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ecm_mon_secu_2.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ecm_mon_secu_2.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ecm_mon_secu_2.Vxx_dfctr_xxx
			fm_sta_ecm_mon_secu_2.Vxx_rdn_xxx
			fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ecm_mon_secu_2.Vxx_dtc_stt_xxx
			fm_sta_eprm_efi_inj_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_efi_inj_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_efi_inj_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_efi_inj_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_efi_inj_oc.Vxx_dfctr_xxx
			fm_sta_efi_inj_oc.Vxx_rdn_xxx
			fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_efi_inj_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_efi_inj_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_efi_inj_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_efi_inj_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_efi_inj_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_efi_inj_scg.Vxx_dfctr_xxx
			fm_sta_efi_inj_scg.Vxx_rdn_xxx
			fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_efi_inj_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_efi_inj_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_efi_inj_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_efi_inj_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_efi_inj_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_efi_inj_scw.Vxx_dfctr_xxx
			fm_sta_efi_inj_scw.Vxx_rdn_xxx
			fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_efi_inj_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_efi_sldv_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_efi_sldv_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_efi_sldv_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_efi_sldv_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_efi_sldv_oc.Vxx_dfctr_xxx
			fm_sta_efi_sldv_oc.Vxx_rdn_xxx
			fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_efi_sldv_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_efi_sldv_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_efi_sldv_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_efi_sldv_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_efi_sldv_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_efi_sldv_scg.Vxx_dfctr_xxx
			fm_sta_efi_sldv_scg.Vxx_rdn_xxx
			fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_efi_sldv_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_efi_sldv_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_efi_sldv_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_efi_sldv_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_efi_sldv_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_efi_sldv_scw.Vxx_dfctr_xxx
			fm_sta_efi_sldv_scw.Vxx_rdn_xxx
			fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_efi_sldv_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_egr_byp_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_egr_byp_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_egr_byp_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_egr_byp_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_egr_byp_blk.Vxx_dfctr_xxx
			fm_sta_egr_byp_blk.Vxx_rdn_xxx
			fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_egr_byp_blk.Vxx_dtc_stt_xxx
			fm_sta_eprm_egr_byp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_egr_byp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_egr_byp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_egr_byp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_egr_byp_h.Vxx_dfctr_xxx
			fm_sta_egr_byp_h.Vxx_rdn_xxx
			fm_sta_egr_byp_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_egr_byp_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_egr_byp_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_egr_byp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_egr_byp_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_egr_byp_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_egr_byp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_egr_byp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_egr_byp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_egr_byp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_egr_byp_l.Vxx_dfctr_xxx
			fm_sta_egr_byp_l.Vxx_rdn_xxx
			fm_sta_egr_byp_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_egr_byp_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_egr_byp_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_egr_byp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_egr_byp_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_egr_byp_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_emtv_flow_meca.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_emtv_flow_meca.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_emtv_flow_meca.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_emtv_flow_meca.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_emtv_flow_meca.Vxx_dfctr_xxx
			fm_sta_emtv_flow_meca.Vxx_rdn_xxx
			fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_emtv_flow_meca.Vxx_dtc_stt_xxx
			fm_sta_eprm_emtv_hbdg_el.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_emtv_hbdg_el.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_emtv_hbdg_el.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_emtv_hbdg_el.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_emtv_hbdg_el.Vxx_dfctr_xxx
			fm_sta_emtv_hbdg_el.Vxx_rdn_xxx
			fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_emtv_hbdg_el.Vxx_dtc_stt_xxx
			fm_sta_eprm_emtv_hbdg_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_emtv_hbdg_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_emtv_hbdg_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_emtv_hbdg_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_emtv_hbdg_ovh.Vxx_dfctr_xxx
			fm_sta_emtv_hbdg_ovh.Vxx_rdn_xxx
			fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_emtv_hbdg_ovh.Vxx_dtc_stt_xxx
			fm_sta_eprm_emtv_ofs_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_emtv_ofs_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_emtv_ofs_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_emtv_ofs_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_emtv_ofs_no_norm.Vxx_dfctr_xxx
			fm_sta_emtv_ofs_no_norm.Vxx_rdn_xxx
			fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_emtv_ofs_no_norm.Vxx_dtc_stt_xxx
			fm_sta_eprm_emtv_reg_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_emtv_reg_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_emtv_reg_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_emtv_reg_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_emtv_reg_blk.Vxx_dfctr_xxx
