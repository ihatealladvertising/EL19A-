			Cmp_smk_rich_lim_cor_pp_2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_smk_rich_lim_pp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Smkprxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_smk_rich_lim_maf_pr
			Ctb_smk_tkof_rich_maf_pr
			Ctb_smk_tkof_rich_n_pr
			Cmp_smk_rich_lim_n_maf_pr
			Ctb_smk_rich_lim_n_pr
			Ctb_smk_tkof_ass_fac_pr
			Cmp_smk_tkof_ofs_pr
			Ctp_smk_tkof_fac_pr
			Cxx_smk_pft_med_fac_pr
			Cxx_smk_pft_nul_fac_pr
			Cxx_smk_pft_cold_fac_pr
			Cxx_smk_tkof_pos_slop_pr
			Cxx_smk_tkof_neg_slop_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_smk_tkof_ofs_pr
			Vxx_smk_rich_lim_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Smkrijx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_smk_rich_lim_fac_vs_rij
			Cmp_smk_rich_lim_cor_rij_2
			Ctb_smk_rich_lim_n_rij_1
			Cmp_smk_rich_lim_n_maf_rij_1
			Cmp_smk_rich_lim_n_maf_rij_2
			Ctb_smk_rich_lim_cor_n_2
			Ctb_smk_rich_lim_cor_tco
			Cmp_smk_rich_lim_n_maf_rij_amp
			Ctb_smk_rich_lim_fac_vs
			Ctb_smk_rich_lim_fac_amp
			Ctb_smk_rich_lim_maf_rij_amp
			Ctb_smk_rich_lim_maf_rij_3
			Ctb_smk_rich_lim_n_rij_3
			Ctb_smk_rich_lim_n_rij_amp
			Ctb_smk_rich_lim_cor_rail_prs
			Ctb_gear
			Ctd_gear_smk
			Ctb_smk_rich_lim_cor_n_1
			Ctb_smk_tkof_rich_n_rij
			Ctb_smk_rich_lim_maf_rij_2
			Ctb_smk_tkof_rich_maf_rij
			Cmp_smk_rich_lim_n_maf_rij_3
			Cmp_smk_tkof_ofs_rij
			Ctb_smk_rich_lim_maf_rij_1
			Ctb_smk_tkof_ass_fac_rij
			Ctb_smk_rich_lim_n_rij_2
			Ctb_smk_tkof_pft_load_rij
			Ctp_smk_rich_lim_fac_amp_rij
			Ctp_smk_pft_load_cold_fac
			Ctp_smk_pft_load_med_fac
			Ctp_smk_pft_load_nul_fac
			Cmp_smk_rich_lim_cor_rij_1
			Ctp_smk_tkof_fac_rij
			Cxx_smk_tkof_neg_slop_rij
			Cxx_smk_tkof_pos_slop_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_smk_rich_lim_rij
			Vxx_smk_tkof_ofs_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Smokexx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_smk_rich_agb_ofs
			Cxx_smk_rich_agb_t
			Cxx_smk_rich_agb_vs_thd
			Cxx_smk_rich_lim_comb_neg_slop
			Cxx_smk_rich_lim_comb_pos_slop
			Cxx_smk_rich_lim_sta
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_smk_rich_lim_slop_on
			Vxx_smk_fim
			Vxx_smk_fim_bas
			Vxx_smk_rich_agb_ofs
			Vxx_smk_rich_lim
			Vxx_smk_rich_lim_bas
			Vsx_smk_fim_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Statlxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_max_pow_gear
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_max_pow_tqe
			Vxx_max_stat_avl_tqe
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Tqramsx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_max_rams_tqe_3
			Ctb_max_rams_tqi_1
			Ctb_max_rams_tqi_2
			Ctp_max_rams_tqe_3
			Ctp_max_rams_tqi_1
			Ctp_max_rams_tqi_2
			Cxx_max_rams_tqe_1_slop
			Cxx_max_rams_tqe_2_slop
			Cxx_max_rams_tqe_3_srs
			Cbx_tq_rams_lim_act_3_bch_cfm
			Cxx_max_rams_tqe_3_slop
			Cxx_max_rams_tqe_sta_slop
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_lim_max_rams_tqe
			Vsx_tq_rams_lim_vld
			Vbx_max_rams_tqe_1_on
			Vbx_max_rams_tqe_2_on
			Vbx_max_rams_tqe_3_on
			Vxx_max_rams_tqe_1
			Vxx_max_rams_tqe_2
			Vxx_max_rams_tqe_3
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimpmx.xml' */
/begin FUNCTION
		TqLimPmx
		""
	/begin SUB_FUNCTION
			TqLimPmx_Fstqprj_xxxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimpmx.xml' */
/begin FUNCTION
		TqLimPmx_Fstqprj_xxxxxx
		""
	/begin OUT_MEASUREMENT
			Vbx_tq_rams_lim_spc_act_1
			Vbx_tq_rams_lim_spc_act_2
			Vbx_tq_rams_lim_spc_act_3
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp
		""
	/begin SUB_FUNCTION
			TqMdlFsp_Aftrxxx
			TqMdlFsp_Mainrij
			TqMdlFsp_Mainxxx
			TqMdlFsp_Mainprx
			TqMdlFsp_Postprx
			TqMdlFsp_Sloponx
			TqMdlFsp_Ivltqxx
			TqMdlFsp_Mxiflxx
			TqMdlFsp_Postxxx
			TqMdlFsp_Xxwiont
			TqMdlFsp_Mainocd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Aftrxxx
		""
	/begin OUT_MEASUREMENT
			Vbx_tqi_aftr_efy_slop_on
			Vxx_tqi_aftr_efy
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Ivltqxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_n_tq_fct_vld2_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_tq_fct_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Mainocd
		""
	/begin DEF_CHARACTERISTIC
			Cbx_tqi_ocd_egr_off_disa
			Cbx_tqi_ocd_mod_ena
			Ctb_tqi_bas_lp_n_ocd
			Ctb_tqi_bas_lp_tqi_ocd
			Cmp_tqi_bas_lp_ocd
			Ctb_tqi_maf_fac_ocd
			Ctb_tqi_t_fil_down_ocd
			Ctb_tqi_t_fil_up_ocd
			Ctp_tqi_maf_fac_ocd
			Ctp_tqi_t_fil_down_ocd
			Ctp_tqi_t_fil_up_ocd
			Cxx_tqi_cor_maf_dif_t_fil_ocd
			Cxx_tqi_egr_off_fac
			Cxx_tqi_ocd_ena_amp_h_thd
			Cxx_tqi_ocd_ena_amp_l_thd
			Cxx_tqi_ocd_ena_n_h_thd_h
			Cxx_tqi_ocd_ena_n_h_thd_l
			Cxx_tqi_ocd_ena_n_l_thd_h
			Cxx_tqi_ocd_ena_n_l_thd_l
			Cxx_tqi_ocd_ena_tco_h_thd
			Cxx_tqi_ocd_ena_tco_l_thd
			Cxx_tqi_ocd_ena_tia_h_thd
			Cxx_tqi_ocd_ena_tia_l_thd
			Cxx_tqi_ocd_ena_tqi_h_thd_h
			Cxx_tqi_ocd_ena_tqi_h_thd_l
			Cxx_tqi_ocd_ena_tqi_l_thd_h
			Cxx_tqi_ocd_ena_tqi_l_thd_l
			Cxx_tqi_ocd_fim_lim_max
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_tqi_ocd_ena
			Vbx_tqi_rst_ocd
			Vxx_tqi_cor_fac_ocd
			Vxx_tqi_cor_fil_ocd
			Vxx_tqi_cor_ocd
			Vxx_tqi_maf_err_fil_ocd
			Vxx_tqi_t_fil_ocd
			Vxx_tqi_cor_fim_tot_ocd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Mainprx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_tqi_cor_maf_dif_t_fil_pr
			Cxx_tqi_fim_tot_cor_max_pr
			Cxx_tqi_fim_tot_cor_min_pr
			Ctb_tqi_adv_cor_n_pr
			Ctb_tqi_adv_cor_tqi_pr
			Ctb_tqi_adv_fac_pr
			Ctb_tqi_bas_fim_tot_n_pr
			Ctb_tqi_bas_fim_tot_tqi_pr
			Ctb_tqi_maf_cor_n_pr
			Ctb_tqi_maf_cor_tqi_pr
			Ctb_tqi_maf_fac_pr
			Cmp_tqi_adv_cor_pr
			Cmp_tqi_bas_fim_tot_pr
			Cmp_tqi_maf_cor_pr
			Ctp_tqi_adv_fac_pr
			Ctp_tqi_maf_fac_pr
			Cmp_tqi_bas_fim_tot_inv_pr
			Ctb_tqi_bas_fim_tot_inv_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tqi_fim_tot_cor_pr
			Vxx_tqi_cor_fim_tot_pr
			Vxx_tqi_smk_pr
			Vxx_tqi_max_fim_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Mainrij
		""
	/begin DEF_CHARACTERISTIC
			Cxx_tqi_cor_maf_dif_t_fil_rij
			Cxx_tqi_fim_tot_cor_max_rij
			Cxx_tqi_fim_tot_cor_min_rij
			Ctb_tqi_adv_cor_n_rij
			Ctb_tqi_adv_cor_tqi_rij
			Ctb_tqi_adv_fac_rij
			Ctb_tqi_bas_fim_tot_n_rij
			Ctb_tqi_maf_cor_n_rij
			Ctb_tqi_maf_cor_tqi_rij
			Ctb_tqi_maf_fac_rij
			Cmp_tqi_adv_cor_rij
			Cmp_tqi_maf_cor_rij
			Ctp_tqi_adv_fac_rij
			Ctp_tqi_maf_fac_rij
			Ctb_tqi_bas_fim_tot_tqi_rij
			Cmp_tqi_bas_fim_tot_rij
			Cmp_tqi_bas_fim_tot_inv_rij
			Ctb_tqi_bas_fim_tot_inv_rij
			Cbx_tqi_cor_adv_dif_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tqi_cor_fim_tot_rij
			Vxx_tqi_fim_tot_cor_rij
			Vxx_tqi_smk_rij
			Vxx_tqi_max_fim_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Mainxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_comb_efy_sta
			Ctb_amp_comb_efy_sta
			Cmp_tco_amp_comb_efy_sta_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_tqi_fim_tot_slop_on
			Vbx_tqi_smk_slop_on
			Vxx_comb_efy
			Vxx_esti_tqe
			Vxx_tqi_fim_tot
			Vxx_tqi_smk
			Vbx_tqi_max_fim_slop_on
			Vxx_esti_tqi
			Vxx_tqi_max_fim
			Vxx_cor_comb_efy_sta
			Vbx_tqi_fms_lp_efy_slop_on
			Vxx_fms_lp_efy
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Mxiflxx
		""
	/begin OUT_MEASUREMENT
			Vxx_fms_fim_tot_max
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Postprx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tqi_bas_post_efy_n_pr
			Ctb_tqi_bas_post_efy_tqi_pr
			Ctb_tqi_post_efy_phi_cor_n_pr
			Ctb_tqi_post_efy_phi_cor_tqi_pr
			Ctb_tqi_post_efy_phi_fac_pr
			Ctb_tqi_post_efy_ti_cor_n_pr
			Ctb_tqi_post_efy_ti_cor_tqi_pr
			Ctb_tqi_post_efy_ti_dif_fac_pr
			Cmp_tqi_bas_post_efy_pr
			Cmp_tqi_post_efy_phi_cor_pr
			Cmp_tqi_post_efy_ti_dif_cor_pr
			Ctp_tqi_post_efy_phi_fac_pr
			Ctp_tqi_post_efy_ti_dif_fac_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tqi_cor_post_efy_pr
			Vxx_tqi_post_efy_cor_pr
			Vxx_tqi_post_efy_phi_cor_pr
			Vxx_tqi_post_efy_ti_dif_cor_pr
			Vxx_tqi_tpo_dif_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Postxxx
		""
	/begin OUT_MEASUREMENT
			Vbx_tqi_post_efy_slop_on
			Vxx_tqi_post_efy
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Sloponx
		""
	/begin OUT_MEASUREMENT
			Vbx_tq_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin FUNCTION
		TqMdlFsp_Xxwiont
		""
	/begin OUT_MEASUREMENT
			Vxx_tqi_cor_aftr_efy_npu
			Vxx_tqi_cor_aftr_efy_spu
			Vxx_tqi_cor_fim_tot_npu
			Vxx_tqi_cor_fim_tot_spu
			Vxx_tqi_cor_post_efy_npu
			Vxx_tqi_cor_post_efy_spu
			Vxx_tqi_smk_npu
			Vxx_tqi_smk_spu
			Vxx_tqi_max_fim_npu
			Vxx_tqi_max_fim_spu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin FUNCTION
		TqSetAcs
		""
	/begin SUB_FUNCTION
			TqSetAcs_Tqreqxx
			TqSetAcs_Mngtxbc
			TqSetAcs_Mngtxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin FUNCTION
		TqSetAcs_Mngtxbc
		""
	/begin OUT_MEASUREMENT
			Vbx_eng_spc_acs_dsb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin FUNCTION
		TqSetAcs_Mngtxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_acel_is_ac_dsb_cfm
			Cbx_eng_spc_ac_dsb_cfm
			Cbx_eng_spc_alt_dsb_cfm
			Cbx_eng_spc_ptc_dsb_cfm
			Cbx_perf_ac_dsb_cfm
			Cbx_perf_ptc_dsb_cfm
			Cbx_stal_alt_dsb_cfm
			Cbx_tkof_ac_dsb_cfm
			Cbx_tkof_acs_dsb_rwhs_cfm
			Cbx_tkof_alt_dsb_cfm
			Cmp_alt_slop_req
			Cbx_tkof_ptc_dsb_cfm
			Ctp_sta_ac_ptc_dsb_dly
			Ctp_sta_alt_dsb_dly
			Ctp_stal_ac_dsb_n_ofs
			Ctp_stal_acs_dsb_n
			Cxx_acel_is_ac_dsb_rat
			Cxx_acel_is_ac_dsb_dly
			Cxx_alt_min_pow_ena
			Cxx_perf_acs_dsb_l_gear
			Cxx_perf_acs_dsb_pdl_grd
			Cxx_perf_acs_dsb_tqe_dif
			Cxx_perf_acs_ena_pdl_rat
			Cxx_stal_ac_max_tq_d
			Cxx_stal_ac_max_tq_p
			Cxx_stal_ac_max_tq_slop
			Cxx_stal_ac_max_tq_dft_val
			Cxx_stal_ac_max_tq_thd
			Cxx_acs_ena_dly
			Cxx_perf_acs_dsb_dly
			Cxx_tkof_acs_dsb_dly
			Cxx_perf_acs_dsb_h_gear
			Cxx_perf_acs_ena_n
			Cxx_tkof_acs_dsb_n
			Cxx_perf_acs_dsb_pdl_rat
			Cxx_tkof_acs_dsb_pwt_sp
			Cxx_perf_acs_dsb_pdl_grd_t
			Cxx_tkof_acs_dsb_rwhs_t
			Cxx_tkof_acs_dsb_vs
			Cxx_tkof_acs_dsb_vs_pos_slop
			Cxx_stal_acs_dsb_dly
			Cxx_tkof_acs_ena_vs
			Cbx_stal_ptc_dsb_cfm
			Cbx_stal_ac_dsb_cfm
			Cbx_stal_ac_max_tq_prop_cfm
			Cxx_stal_ac_max_tq_ref
			Cxx_tkof_acs_dsb_coup_dly
			Cxx_tkof_acs_dsb_tqe_sp_rat
			Cxx_tkof_acs_ena_pwt_sp
			Cxx_tkof_acs_ena_zero_vs
			Cbx_ac_max_pow_ena_cfm
			Cbx_eng_spc_thpl_dsb_cfm
			Cbx_perf_thpl_dsb_cfm
			Cbx_rbst_ptc_dsb_cfm
			Cbx_rbst_thpl_dsb_cfm
			Cbx_sta_thpl_dsb_cfm
			Cbx_stal_thpl_dsb_cfm
			Cbx_tkof_thpl_dsb_cfm
			Ctb_n_alt
			Ctb_rbst_el_csm_dsb_amp
			Ctd_rbst_el_csm_dsb_gear
			Cxx_perf_acs_dsb_n
			Cxx_rbst_el_csm_dsb_gear_dly
			Cxx_rbst_el_csm_dsb_n
			Cxx_rbst_el_csm_dsb_tco_hys
			Cxx_rbst_el_csm_ena_n
			Ctp_perf_acs_dsb_max_avl_tqe
			Ctp_rbst_el_csm_dsb_tco_thd
			Cxx_acs_amp_dft_val
			Cxx_perf_ac_amp_h_thd
			Cxx_perf_ac_amp_l_thd
			Cxx_stal_alt_ac_amp_h_thd
			Cxx_stal_alt_ac_amp_l_thd
			Cxx_tkof_alt_ac_amp_h_thd
			Cxx_tkof_alt_ac_amp_l_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ac_eng_dsb
			Vbx_ac_eng_frz
			Vbx_ptc_cut
			Vxx_ac_max_pow_ena
			Vxx_alt_max_pow_ena
			Vxx_alt_slop_req
			Vxx_ptc_max_pow_ena
			Vbx_ac_dsb_req
			Vbx_acel_is_ac_dsb
			Vbx_acs_frz
			Vbx_alt_dsb_req
			Vbx_alt_eng_dsb
			Vbx_perf_acs_dsb
			Vbx_ptc_dsb_req
			Vbx_sfty_acs_dsb
			Vbx_sta_ac_ptc_dsb
			Vbx_sta_alt_dsb
			Vbx_stal_acs_dsb
			Vbx_tkof_acs_dsb
			Vsx_stal_acs_dsb_stt
			Vxx_acel_pdl_grd
			Vxx_acs_ena_dly
			Vxx_stal_ac_ant_dsb_n
			Vxx_stal_ac_max_pow_ena
			Vxx_stal_ac_max_pow_ena_clc
			Vxx_stal_ac_max_tq
			Vxx_stal_ac_max_tq_clc
			Vxx_stal_acs_dsb_dly
			Vxx_stal_acs_dsb_n
			Vxx_tkof_acs_dsb_vs
			Vbx_thpl_eng_dsb
			Vbx_thpl_eng_frz
			Vbx_rbst_el_csm_dsb
			Vbx_ptc_frz
			Vbx_thpl_dsb_req
			Vbx_perf_ac_dsb
			Vbx_perf_el_csm_dsb
			Vbx_stal_alt_ac_dsb
			Vbx_stal_el_csm_dsb
			Vbx_tkof_alt_ac_dsb
			Vbx_tkof_el_csm_dsb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin FUNCTION
		TqSetAcs_Tqreqxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_thpl_n
			Ctb_tqi_thpl_err
			Cxx_thpl_pft_tco_h
			Cxx_thpl_pft_tco_l
			Cxx_thpl_pft_tco_ofs_h
			Cxx_thpl_pft_tco_ofs_l
			Cxx_thpl_tqi_err_max
			Cxx_thpl_tqi_err_min
			Cxx_tqi_thpl_ig_neg
			Cxx_tqi_thpl_ig_pos
			Ctd_thpl_max_nr
			Ctp_thpl_air_heat_tqi_min
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tqi_err
			Vxx_tqi_thpl_err_lim
			Vxx_tqi_thpl_gov
			Vxx_thpl_tqi_nr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/begin FUNCTION
		TqSetFtr
		""
	/* ASAP2::Database : delete 'TqSetFtr_Flcdnxx' */
	/* ASAP2::Database : delete 'TqSetFtr_Knkscxx' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin SUB_FUNCTION
			TqSetFtr_Ajsisxx
			TqSetFtr_Drcutxx
			TqSetFtr_Checkxx
			TqSetFtr_Schedul
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/begin FUNCTION
		TqSetFtr_Ajsisxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_tqi_raw_bch_cfm
			Cbx_tqi_sp_bch_cfm
			Cbx_tqi_tgt_bch_cfm
			Cxx_ajs_cor_lim_tq_ofs
			Cxx_tqi_raw_bch
			Cxx_tqi_sp_bch
			Cxx_tqi_tgt_bch
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tqi_tgt
			Vxx_tqi_rat_tgt
			Vxx_tqi_sp
			Vxx_tqi_sp_no_ajs
			Vxx_tqi_raw
			Vxx_max_dyn_avl_tqi
			Vxx_max_stat_avl_tqi_ovn
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		TqSetFtr_Checkxx
		""
	/* ASAP2::Database : delete 'Vxx_iga_arb_tqi_tgt' */
	/* ASAP2::Database : delete 'Vxx_knk_arb_tqi_tgt' */
	/* ASAP2::Database : delete 'Vxx_raw_min_bas_tq_cor' */
	/* ASAP2::Database : delete 'Vxx_wup_arb_tqi_tgt' */
	/* ASAP2::Database : 4 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_chk_arb_tqi_raw
			Vxx_chk_arb_tqi_sp
			Vxx_chk_arb_tqi_tgt
			Vxx_sta_tq_raw
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/begin FUNCTION
		TqSetFtr_Drcutxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_cut_decl_tco_thd
			Cxx_swi_drv_is_ofs
			Cxx_swi_drv_n_thd
			Ctb_tco_cut
			Ctp_tco_cut_decl_off_dly
			Cxx_aut_swi_is_ofs
			Cxx_aut_swi1_is_ofs
			Cxx_decl_cut_n_ofs
			Cxx_cut_decl_dly_tq_rat
			Cxx_cut_n_ofs
			Cxx_cut_n_ofs2
			Cxx_kd_decl_cut_n_ofs
			Ctp_cut_decl_dly
			Cxx_cut_decl_tqi_thd
			Cxx_decl_cut_n_ac_ofs
			Cxx_kd_decl_cut_n_ac_ofs
			Cbx_ant_gear_coup_cut_ct_ena
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_cut_cdn
			Vbx_cut_dly_on_trs_2
			Vbx_cut_off_dly_trs_1
			Vxx_ena_cut_n_ofs
			Vxx_swi_cut_n_ofs
			Vxx_swi_drv_cut_n_ofs
			Vsx_driv_cut_req
			Vbx_cut_dly_off_trs_3
			Vbx_ant_gear_coup_cut_ct_1
			Vbx_cut_ct
			Vbx_swi_drv_cut
			Vbx_swi_drv_cut_n
			Vbx_swi_drv_n
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/begin FUNCTION
		TqSetFtr_Schedul
		""
	/begin DEF_CHARACTERISTIC
			Cbx_wg_abst_pres_cho_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_wg_abst_pres_cfm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/begin FUNCTION
		VfAcoMng
		""
	/begin SUB_FUNCTION
			VfAcoMng_Acfanxx_xxxxxx
			VfAcoMng_Compxxx_xxxxxx
			VfAcoMng_Noacvxx_xxxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/begin FUNCTION
		VfAcoMng_Acfanxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_ac_mdf_prs_hys
			Cxx_ac_mdf_prs_thd1
			Cxx_ac_mdf_prs_thd2
			Cxx_ac_mdf_prs_thd3
			Cxx_ac_mdf_secu_prs_hys
			Cxx_ac_mdf_secu_prs_thd
			Cxx_ac_mdf_vs_hys
			Cxx_ac_mdf_vs_thd1
			Cxx_ac_mdf_vs_thd2
			Cxx_ac_mdf_vs_thd3
			Cxx_ac_mdf_vs_thd4
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ac_mdf2_req_int
			Vbx_ac_mdf1_req_int
			Vxx_ac_prs_lvl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/begin FUNCTION
		VfAcoMng_Compxxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_ac_bfr_clu_dly
			Cxx_ac_clu_dly
			Cxx_ac_dclu_dly
			Cxx_ac_rly_prot_dly
			Cxx_ac_ext_clu_dly
			Cxx_ac_ext_dclu_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_acr_stt
			Vbx_ac_clu_ena
			Vbx_ac_clu_dsb
			Vbx_ac_dclu_dsb
			Vbx_ac_dsb
			Vsx_ac_cmd
			Vxx_ac_cmd_dly
			Vxx_ac_stt_dly
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/begin FUNCTION
		VfAcoMng_Noacvxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_h_prs_ac_dsb_dly
			Cxx_h_prs_ac_dsb_hys
			Cxx_h_prs_ac_dsb_thd
			Cxx_l_prs_ac_dsb_hys
			Cxx_l_prs_ac_dsb_thd
			Cxx_n_ac_clu_dsb_thd
			Cxx_n_ac_dsb_hys
			Cxx_n_ac_dsb_thd
			Cxx_prmt_n_ac_dsb_hys
			Cxx_prmt_n_ac_dsb_thd
			Cxx_prmt_n_ac_dsb_dly
			Cxx_vs_ac_clu_dsb_thd
			Cxx_ac_vs_nok_dly
			Cbx_ac_cold_loop_in_ecm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_n_vs_ac_clu_dsb
			Vxx_ac_vs
			Vxx_l_prs_ac_diag
			Vbx_ac_secu_dsb
			Vbx_h_prs_ac_dsb
			Vbx_l_prs_ac_dsb
			Vbx_n_ac_dsb
			Vbx_prmt_n_ac_dsb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/begin FUNCTION
		VfCrkMng
		""
	/begin SUB_FUNCTION
			VfCrkMng_Mngtxxx
			VfCrkMng_Engreqx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/begin FUNCTION
		VfCrkMng_Engreqx
		""
	/begin OUT_MEASUREMENT
			Vbx_eng_crk_wait
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/begin FUNCTION
		VfCrkMng_Mngtxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_fct_tco_crkm
			Ctp_fct_tco_dly
			Cxx_ena_sta_agb_vld_dly
			Cxx_frst_sta_dly
			Cxx_sta_stt_vld_dly
			Cxx_wait_sta_fail_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_dft_sta
			Vsx_ena_sta_agb_ecm
			Vsx_ena_sta_ecm
			Vbx_long_crk_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/begin FUNCTION
		VfEmgCtl
		""
	/begin SUB_FUNCTION
			VfEmgCtl_Floatcs
			VfEmgCtl_Floatxx
			VfEmgCtl_Chgovxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/begin FUNCTION
		VfEmgCtl_Chgovxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tco_thpl
			Ctb_thpl_alt_n
			Cxx_eng_alt_rat
			Cxx_thpl_alt_pwm_sp
			Cxx_thpl_alt_pwm_sp_ptc
			Cxx_thpl_ptc_dly
			Cxx_thpl_thd_h_conf1
			Cxx_thpl_thd_h_conf2
			Cxx_thpl_thd_h_conf3
			Cxx_thpl_thd_h_conf4
			Cxx_thpl_thd_h_conf5
			Cxx_thpl_thd_h_conf6
			Cxx_thpl_thd_h_conf7
			Cxx_thpl_thd_l_conf1
			Cxx_thpl_thd_l_conf2
			Cxx_thpl_thd_l_conf3
			Cxx_thpl_thd_l_conf4
			Cxx_thpl_thd_l_conf5
			Cxx_thpl_thd_l_conf6
			Cxx_thpl_thd_l_conf7
			Cxx_thpl_vb_err_neg
			Cxx_thpl_vb_err_pos
			Cxx_thpl_vb_sp
			Cxx_thpl_vb_sp_ptc
			Ctp_thpl_alt_pwm_err_pos
			Ctp_thpl_alt_pwm_ig_neg
			Ctp_thpl_alt_pwm_ig_neg_ptc
			Ctp_thpl_alt_pwm_ig_pos
			Ctp_thpl_alt_pwm_ig_pos_ptc
			Ctp_thpl_alt_pwm_pg_neg
			Ctp_thpl_alt_pwm_pg_neg_ptc
			Ctp_thpl_alt_pwm_pg_pos
			Ctp_thpl_alt_pwm_pg_pos_ptc
			Ctp_thpl_vb_ig_neg
			Ctp_thpl_vb_ig_neg_ptc
			Ctp_thpl_vb_ig_pos
			Ctp_thpl_vb_ig_pos_ptc
			Ctp_thpl_vb_pg_neg
			Ctp_thpl_vb_pg_neg_ptc
			Ctp_thpl_vb_pg_pos
			Ctp_thpl_vb_pg_pos_ptc
			Cbx_thpl_frz_ena
			Ctp_thpl_alt_pwm_err_neg
			Cxx_alt_pwm_fil_fac
			Cbx_alt_pwm_pres
			Cbx_alt_typ
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_thpl_alt_pwm_err_sgn
			Vbx_thpl_err_sgn
			Vbx_thpl_int_lim
			Vbx_thpl_vb_err_sgn
			Vxx_thpl_alt_pwm_err_lim_reg
			Vxx_thpl_alt_pwm_err_reg
			Vxx_thpl_alt_pwm_reg
			Vxx_thpl_alt_pwm_reg_ig
			Vxx_thpl_alt_pwm_reg_pg
			Vxx_thpl_alt_pwm_sp
			Vxx_thpl_cmd_nr
			Vxx_thpl_reg
			Vxx_thpl_vb_err_lim_reg
			Vxx_thpl_vb_err_reg
			Vxx_thpl_vb_reg
			Vxx_thpl_vb_reg_ig
			Vxx_thpl_vb_reg_pg
			Vxx_thpl_vb_sp
			Vxx_thpl_alt_n
			Vxx_VfEmgCtl_thpl_alt_n
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/begin FUNCTION
		VfEmgCtl_Floatcs
		""
	/begin DEF_CHARACTERISTIC
			Ctp_vb_flot_min_n_ena
			Ctp_vb_flot_sta_ena_dly
			Cbx_vb_flot_ena_req
			Cxx_vb_flot_ena_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_vb_flot_dsb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/begin FUNCTION
		VfEmgCtl_Floatxx
		""
	/begin OUT_MEASUREMENT
			Vbx_vb_flot_dsb_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/begin FUNCTION
		VfSlkMng
		""
	/begin SUB_FUNCTION
			VfSlkMng_Lockxv4_xxxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/begin FUNCTION
		VfSlkMng_Lockxv4_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_swlk_dsb
			Cbx_swlk_key_spc_req
			Cbx_swlk_req
			Cxx_swlk_chlg_dly
			Cxx_swlk_diag_dly
			Cxx_swlk_id_forb_dly
			Cxx_swlk_id_nok_ctr_dec
			Cxx_swlk_id_nr_ena
			Cxx_swlk_key_dlt_dly
			Cxx_swlk_key_dly
			Cxx_swlk_noi[0]
			Cxx_swlk_noi[1]
			Cxx_swlk_noi[2]
			Cxx_swlk_noi[3]
			Cxx_swlk_noi[4]
			Cxx_swlk_noi[5]
			Cxx_swlk_pwl_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			SLockRequestControl
			SoftwareLockRequest[0]
			SoftwareLockRequest[1]
			SoftwareLockRequest[2]
			SoftwareLockRequest[3]
			SoftwareLockRequest[4]
			SoftwareLockRequest[5]
			Vbx_swlk_cnt_tool_req
			Vbx_swlk_diag_avl
			Vbx_swlk_diag_ccu
			Vbx_swlk_diag_ecm
			Vbx_swlk_diag_mux
			Vbx_swlk_diag_tool
			Vbx_swlk_ecm_prot_stt
			Vbx_swlk_pwl_rtn_req
			Vxx_eng_run_ena_swlk
			Vxx_swlk_diag_1
			Vxx_swlk_diag_2
			Vxx_swlk_diag_3
			Vxx_swlk_key_mem_stt
			Vbx_swlk_dsb_ena
			Vbx_supl_key_bkup_ok
			Vbx_supl_key_norm_ok
			Vsx_swlk_stt
			Vxx_swlk_nok_id_ctr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin FUNCTION
		atcatdgn
		""
	/* ASAP2::Database : delete 'atcatdgn_schxxxx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			atcatdgn_catdiag
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin FUNCTION
		atcatdgn_catdiag
		"Oxidation Catalyst OBD Diagnosis"
	/begin DEF_CHARACTERISTIC
			Ctb_ocd_t_fct_egaf
			Ctp_ocd_t_fct_egaf
			Ctb_ocd_dly_fct_egaf
			Ctp_ocd_dly_fct_egaf
			Cmp_ocd_tlp
			Cmp_ocd_flp
			Ctb_ocd_n_mv
			Ctb_ocd_tqi_sp
			Cbx_doc_dtp_cfm
			Cbx_ocd_ena_cfm
			Cxx_aftr_eng_sta_dly
			Cxx_aftr_long_idle_dly
			Cxx_aftr_long_idle_dly_ena
			Cxx_aftr_ofs_ad_dly
			Cxx_dfdec_cata_nok_cge
			Cxx_dfinc_cata_nok_cge
			Cxx_ocd_ad_dly_bfr_resu
			Cxx_ocd_dlp_dly
			Cxx_ocd_dly_bfr_ena
			Cxx_ocd_dly_bfr_resu
			Cxx_ocd_ena_dtp_max
			Cxx_ocd_ena_dtp_min
			Cxx_ocd_ena_n_h_thd_1
			Cxx_ocd_ena_n_h_thd_2
			Cxx_ocd_ena_n_l_thd_1
			Cxx_ocd_ena_n_l_thd_2
			Cxx_ocd_ena_tqi_h_thd_1
			Cxx_ocd_ena_tqi_h_thd_2
			Cxx_ocd_ena_tqi_l_thd_1
			Cxx_ocd_ena_tqi_l_thd_2
			Cxx_ocd_ena_utp_max
			Cxx_ocd_ena_utp_min
			Cxx_ocd_gear_min
			Cxx_ocd_idle_n_thd
			Cxx_ocd_idle_t_thd
			Cxx_ocd_n_dev_max
			Cxx_ocd_ofs_ad_n_h_thd_1
			Cxx_ocd_ofs_ad_n_h_thd_2
			Cxx_ocd_ofs_ad_n_l_thd_1
			Cxx_ocd_ofs_ad_n_l_thd_2
			Cxx_ocd_ofs_ad_t_h_thd
			Cxx_ocd_ofs_ad_t_l_thd
			Cxx_ocd_ofs_ad_tqi_h_thd_1
			Cxx_ocd_ofs_ad_tqi_h_thd_2
			Cxx_ocd_ofs_ad_tqi_l_thd_1
			Cxx_ocd_ofs_ad_tqi_l_thd_2
			Cxx_ocd_t_comb_mod_ok
			Cxx_ocd_t_h_thd
			Cxx_ocd_t_l_thd
			Cxx_ocd_tco_max
			Cxx_ocd_tco_min
			Cxx_ocd_test_dly
			Cxx_ocd_test_dly_bfr_resu
			Cxx_ocd_test_egaf_max
			Cxx_ocd_test_egaf_min
			Cxx_ocd_test_min_thd
			Cxx_ocd_test_max_thd
			Cxx_ocd_test_utp_max
			Cxx_ocd_test_utp_min
			Cxx_ocd_tia_min
			Cxx_ocd_tpst_esti_dly
			Cxx_ocd_tqi_dev_max
			Cxx_ofs_ad_dly
			Cxx_ofs_ad_gear_min
			Cxx_pft_utp_ofs_sat_max
			Cxx_pft_utp_ofs_sat_min
			Cxx_ocd_ofs_ad_tco_min
			Cxx_ocd_ofs_ad_tco_max
			Cxx_post_chk_n_l_thd_1
			Cxx_post_chk_n_l_thd_2
			Cxx_post_chk_n_h_thd_1
			Cxx_post_chk_n_h_thd_2
			Cxx_post_chk_tqi_h_thd_1
			Cxx_post_chk_tqi_h_thd_2
			Cxx_post_chk_tqi_l_thd_1
			Cxx_post_chk_tqi_l_thd_2
			Cxx_ocd_ofs_ad_t
			Cxx_post_chk_gear_min
			Cxx_post_chk_dly_bfr_resu
			Cxx_ocd_vh_dist_ena_min_h_thd
			Cxx_ocd_vh_dist_ena_min_l_thd
	/end DEF_CHARACTERISTIC
	/begin LOC_MEASUREMENT
			Vbx_comb_mod_act_ok
			Vbx_df_cata_nok_cge
			Vbx_diag_ena_cata_nok_cge
			Vbx_ocd_cond_ok
			Vbx_ocd_ena
			Vbx_ocd_ena_temp_swi
			Vbx_ocd_long_idle_det
			Vbx_ocd_mdl_err_ok
			AtCatDgn_NVM.Vbx_ocd_ofs_ad_done_NVM
			Vbx_ocd_ofs_ad_done_clr
			Vbx_ocd_ofs_ad_ok
			Vbx_ocd_stab_stt_det
			Vbx_ocd_stop_eve
			Vbx_ocd_sys_vld_swi
			Vbx_ocd_test_cond_ok
			Vbx_ocd_test_ok
			Vbx_ofs_ad_cond_ok
			Vbx_ofs_ad_long_idle_det
			Vbx_ofs_ad_mdl_err_stab_ok
			Vbx_ofs_ad_run
			Vbx_ox_cata_diag_done
			Vsx_doc_dtp_vld
			Vsx_ocd_cond_stt
			Vsx_ocd_stt
			Vsx_ocd_test_cond_stt
			Vsx_ofs_ad_cond_stt
			Vxx_doc_dtp
			Vxx_inrt_doc_mdl_dly
			Vxx_ocd_dlp_dly
			Vxx_ocd_dly_bfr_ena
			Vxx_ocd_flp
			Vxx_ocd_int_err_out
			Vxx_ocd_mdl_esti_err
			Vxx_ocd_t_comb_mod_ok
			Vxx_ocd_test_dly
			Vxx_ocd_tlp
			AtCatDgn_NVM.Vxx_ocd_vh_dist_frz_NVM
			Vxx_ocd_vh_dist_frz_clr
			Vxx_ofs_ad_dly
			Vxx_pft_utp_esti
			Vxx_pft_utp_esti_dly
			AtCatDgn_NVM.Vxx_pft_utp_ofs_NVM
			Vxx_pft_utp_ofs_ad
			Vxx_ocd_int_err_out_clr
			Vxx_ocd_int_err_min_thd_clr
			Vxx_ocd_int_err_max_thd_clr
			Vxx_cata_nok_cge_val_nom
			Vxx_cata_nok_cge_min_nom
			Vxx_cata_nok_cge_max_nom
			Vxx_ocd_int_err_min_thd
			Vxx_ocd_int_err_max_thd
			Vsx_post_chk_cond_stt
			Vbx_ocd_ofs_ad_sys_vld_swi
			Vbx_post_chk_cond_ok
	/end LOC_MEASUREMENT
	/begin OUT_MEASUREMENT
			Vbx_comb_ocd_req
			Vxx_fms_cor_flp_ocd
			Vxx_fms_cor_tlp_ocd
			AtCatDgn_NVM.Vxx_cata_nok_cge_val_NVM
			AtCatDgn_NVM.Vxx_cata_nok_cge_min_NVM
			AtCatDgn_NVM.Vxx_cata_nok_cge_max_NVM
			AtCatDgn_NVM.Vbx_cata_nok_cge_dis_NVM
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin FUNCTION
		atpftafs
		""
	/* ASAP2::Database : delete 'atpftafs_schxxxx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			atpftafs_asdcsfx
			atpftafs_asdhist
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin FUNCTION
		atpftafs_asdcsfx
		"After-Sale CSF Regeneration"
	/begin DEF_CHARACTERISTIC
			Cbx_pft_asd_utp_sp_swt
			Ctb_pft_asd_n_is_prct
			Ctp_pft_asd_cool_n_is
			Ctp_pft_asd_rgn_n_is
			Cxx_pft_asd_cool_t
			Cxx_pft_asd_dp_min
			Cxx_pft_asd_hot_max_t
			Cxx_pft_asd_hot_min_t
			Cxx_pft_asd_lpos_fim_ena_t
			Cxx_pft_asd_n_hot
			Cxx_pft_asd_n_prct
			Cxx_pft_asd_n_prct_t
			Cxx_pft_asd_rgn_ena
			Cxx_pft_asd_rgn_heat_ena
			Cxx_pft_asd_rgn_stop
			Cxx_pft_asd_rgn_t
			Cxx_pft_asd_tt_thd
			Cxx_pft_asd_tt_thd_t
			Cxx_pft_asd_utp_lim
			Cxx_pft_asd_utp_lim_t
			Cxx_pft_asd_utp_sp
			Cxx_pft_asd_utp_thd_t
	/end DEF_CHARACTERISTIC
	/begin LOC_MEASUREMENT
			Vbx_asd_pft_dp_thd
			Vbx_asd_pft_n_mv_thd
			Vbx_asd_pft_tco_thd
			Vbx_asd_pft_utp_ovh
			Vbx_diag_sta_rpft_abrt
			Vbx_diag_sta_rpft_ena
			Vbx_diag_sta_rpft_end
			Vbx_pft_asd_lpos_fim_ena
			Vbx_pft_asd_req_lpos_ena
			Vbx_pft_asd_temp_thd
			Vbx_pft_asd_trs_cool_cdn
			Vbx_pft_asd_trs_fail_cdn
			Vbx_pft_asd_trs_ok_cdn
			Vbx_pft_asd_trs_rgn_cdn
			Vbx_pft_asd_ttr_thd
			Vbx_pft_asd_utp_thd
			Vxx_pft_asd_cool_t_ctr
			Vxx_pft_asd_cool_t_lft_prct
			Vxx_pft_asd_hot_t_ctr
			Vxx_pft_asd_hot_t_lft_prct
			Vxx_pft_asd_n_cool
			Vxx_pft_asd_n_rgn
			Vxx_pft_asd_rgn_t_ctr
			Vxx_pft_asd_rgn_t_lft_prct
			Vxx_pft_asd_cln_prev
			Vxx_pft_asd_rgn_prev
	/end LOC_MEASUREMENT
	/begin OUT_MEASUREMENT
			Vbx_pft_asd_rgn_on
			Vsx_diag_sta_rpft_stt
			Vsx_pft_asd_stt
			Vxx_pft_accel_is_sp
			Vxx_pft_asd_cln
			Vxx_pft_asd_dp_aftr
			Vxx_pft_asd_dp_bfr
			Vxx_pft_asd_egaf_aftr
			Vxx_pft_asd_egaf_bfr
			Vxx_pft_asd_inj_mod
			Vxx_pft_asd_rgn
			Vxx_pft_asd_t_lft_prct
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin FUNCTION
		atpftafs_asdhist
		"Aftersale CSF history"
	/begin DEF_CHARACTERISTIC
			Cxx_pft_asd_csm_fil_t
			Cxx_pft_asd_dist_step
	/end DEF_CHARACTERISTIC
	/begin LOC_MEASUREMENT
			Vsx_pft_stt_rgn_asd
			Vxx_csm_fil
			AtPftAfs_1_NVM.Vxx_pft_asd_dist_old_NVM
	/end LOC_MEASUREMENT
	/begin OUT_MEASUREMENT
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[0]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[1]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[2]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[3]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[4]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[5]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[6]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[7]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[8]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[9]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[10]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[11]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[12]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[13]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[14]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[15]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[16]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[17]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[18]
			AtPftAfs_1_NVM.Vxx_pft_asd_dist_ref_NVM
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[0]
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[1]
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[2]
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[3]
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[4]
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[5]
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[6]
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[7]
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[8]
			AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[9]
			AtPftAfs_1_NVM.Vxx_pft_asd_dist_chk_ref_NVM
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[0]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[1]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[2]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[3]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[4]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[5]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[6]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[7]
			AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[8]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[0]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[1]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[2]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[3]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[4]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[5]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[6]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[7]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[8]
			AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[9]
			AtPftAfs_1_NVM.Vxx_pft_asd_err_nr_NVM
			AtPftAfs_1_NVM.Vbx_pft_asd_spd_req_trg_NVM
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[0]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[1]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[2]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[3]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[3]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[4]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[5]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[6]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[7]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[8]
			AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[9]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[0]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[1]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[2]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[3]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[4]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[5]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[6]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[7]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[8]
			AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[9]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[0]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[1]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[2]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[3]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[4]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[5]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[6]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[7]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[8]
			AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[9]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[0]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[1]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[2]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[3]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[4]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[5]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[6]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[7]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[8]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[9]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[0]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[1]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[2]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[3]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[4]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[5]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[6]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[7]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[8]
			AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[9]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[0]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[1]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[2]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[3]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[4]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[5]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[6]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[7]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[8]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[9]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[0]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[1]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[2]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[3]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[4]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[5]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[6]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[7]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[8]
			AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[9]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[0]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[1]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[2]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[3]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[4]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[5]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[6]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[7]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[8]
			AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[9]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[0]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[1]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[2]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[3]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[4]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[5]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[6]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[7]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[8]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[9]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[10]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[11]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[12]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[13]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[14]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[15]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[16]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[17]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[18]
			AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[19]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[0]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[1]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[2]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[3]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[4]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[5]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[6]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[7]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[8]
			AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[9]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[0]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[1]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[2]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[3]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[4]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[5]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[6]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[7]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[8]
			AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[9]
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin FUNCTION
		cllubwea
		""
	/* ASAP2::Database : delete 'cllubwea_schxxxx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			cllubwea_owhisxx
			cllubwea_oildilx
			cllubwea_owzoncs
			cllubwea_oxixxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin FUNCTION
		cllubwea_oildilx
		"Oil dilution model"
	/begin DEF_CHARACTERISTIC
			Cbx_oil_dil_ini_mnl
			Cbx_pft_oil_dil_clc_ena
			Cbx_pft_dil_toil_dfl_val_cfm
			Cbx_pft_toil_clc_swi
			Cmp_pft_flp_pr_bas_oil_dil
			Cmp_pft_flp_pr_fac_cor_dil
			Cmp_pft_n_tqi_sp_oil_dil
			Cmp_pft_n_tqi_sp_oil_rij
			Csx_pft_oil_dil_nt
			Csx_pft_oil_dil_pft_cat_heat
			Csx_pft_oil_dil_pft_rgn
			Ctb_oil_dil_max_oil_eva
			Ctb_pft_n_oil_1
			Ctb_pft_n_oil_3
			Ctb_pft_n_oil_flp_bas
			Ctb_pft_n_oil_rij_bas
			Ctb_pft_tqi_sp_flp_bas
			Ctb_pft_tqi_sp_oil_1
			Ctb_pft_tqi_sp_rij_bas
			Ctb_tco_oil_1
			Ctb_tco_oil_rij
			Ctb_tia_oil_dil_spd
			Ctb_tia_oil_dil_spd_rij
			Ctb_toil_oil_2
			Ctb_toil_oil_3
			Ctp_dil_max_eva_kin_fac_cor
			Ctp_pft_n_tqi_sp_oil_eva
			Ctp_pft_tco_oil_dil_cor
			Ctp_pft_tco_oil_dil_cor_rij
			Ctp_pft_tia_oil_dil_spd_cor
			Ctp_pft_tia_oil_dil_spd_rij
			Ctp_pft_toil_eva_kin_fac_cor
			Ctp_pft_toil_oil_eva_cor
			Cxx_dfdec_oil_dil_nok
			Cxx_dfinc_oil_dil_nok
			Cxx_oil_chg_dil_max_mnl_ini
			Cxx_oil_chg_ini
			Cxx_oil_chg_mnl_ini
			Cxx_oil_csm_oil_dil_clc
			Cxx_oil_dil_min_max_clc
			Cxx_oil_dil_rij_fac
			Cxx_oil_dist_min_oil_dil_ovs
			Cxx_oil_rat_max_1
			Cxx_oil_rat_max_2
			Cxx_oil_rij_chg_ini
			Cxx_oil_rij_mnl_chg_ini
			Cxx_oil_vol
			Cxx_pft_dil_cor_flp_pr_max
			Cxx_pft_dil_cor_flp_pr_min
			Cxx_pft_oil_dil_fac
			Cxx_pft_oil_dil_tco_dfl_val
			Cxx_pft_oil_dil_toil_dfl_val
			Cxx_pft_oil_eva_fac
			Cxx_pft_oil_eva_n_min
			Cxx_pft_oil_eva_t
	/end DEF_CHARACTERISTIC
	/begin LOC_MEASUREMENT
			Vbx_df_oil_dil_nok
			Vbx_diag_ena_oil_dil_nok
			Vbx_pft_stt_oil
			Vsx_pft_toil_clc_vld
			Vxx_dil_mod_sta_oil_dil
			ClLubWea_NVM.Vxx_oil_dil_rij_NVM
			Vxx_oil_dil_rij_spd
			Vxx_oil_dil_tco
			Vxx_pft_dil_spd
			Vxx_pft_eva_sat
			Vxx_pft_eva_sat_rat
			Vxx_pft_flp_cor_oil_dil
			Vxx_pft_flp_pr_rat_oil_dil
			Vxx_pft_oil_dil_dec
			Vxx_pft_oil_dil_dev
			Vxx_pft_oil_dil_inc
			Vxx_pft_oil_eva_kin_fac
	/end LOC_MEASUREMENT
	/begin OUT_MEASUREMENT
			Vbx_pft_oil_dil_clc_ena
			Vbx_pft_oil_rgn_ena
			Vsx_oil_dil_ovs_vld
			Vxx_oil_dil
			Vxx_pft_toil_clc
			ClLubWea_NVM.Vxx_oil_dil_raw_NVM
			ClLubWea_NVM.Vxx_pft_oil_dil_max_NVM
			Vxx_oil_dil_rij_ofs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin FUNCTION
		cllubwea_owhisxx
		"Oil Wear Estimation History function"
	/* ASAP2::Database : delete 'Vtx_owe_eng_rev_act_sum' */
	/* ASAP2::Database : delete 'Vtx_owe_km' */
	/* ASAP2::Database : delete 'Vtx_owe_pot_km' */
	/* ASAP2::Database : 3 referenced entries deleted */
	/begin OUT_MEASUREMENT
			ClLubWea_NVM.Vbx_owe_ini_0_NVM
			Vbx_owe_ini_0_trg
			ClLubWea_NVM.Vbx_owe_ini_1_NVM
			Vbx_owe_ini_1_trg
			ClLubWea_NVM.Vbx_owe_ini_2_NVM
			Vbx_owe_ini_2_trg
			ClLubWea_NVM.Vbx_owe_ini_3_NVM
			Vbx_owe_ini_3_trg
			ClLubWea_NVM.Vbx_owe_ini_prev_NVM
			ClLubWea_NVM.Vxx_owe_ctr_stt_NVM
			ClLubWea_NVM.Vxx_owe_dil_req_km_NVM
			ClLubWea_NVM.Vxx_owe_eng_rev_act_sum_0_NVM
			ClLubWea_NVM.Vxx_owe_eng_rev_act_sum_1_NVM
			ClLubWea_NVM.Vxx_owe_eng_rev_act_sum_2_NVM
			ClLubWea_NVM.Vxx_owe_eng_rev_act_sum_3_NVM
			Vxx_owe_ini
			Vxx_owe_eng_rev_act_sum_mem
			ClLubWea_NVM.Vxx_owe_km_0_NVM
			ClLubWea_NVM.Vxx_owe_km_1_NVM
			ClLubWea_NVM.Vxx_owe_km_2_NVM
			ClLubWea_NVM.Vxx_owe_km_3_NVM
			ClLubWea_NVM.Vxx_owe_pot_km_0_NVM
			ClLubWea_NVM.Vxx_owe_pot_km_1_NVM
			ClLubWea_NVM.Vxx_owe_pot_km_2_NVM
			ClLubWea_NVM.Vxx_owe_pot_km_3_NVM
			Vxx_owe_prev_drn_dist
			ClLubWea_NVM.Vxx_owe_prev_ini_km_NVM
			ClLubWea_NVM.Vxx_owe_warn_req_km_NVM
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin FUNCTION
		cllubwea_owzoncs
		"Oil Wear Estimation Geographic area selection"
	/begin DEF_CHARACTERISTIC
			Cxx_owe_km_pot_1
			Cxx_owe_km_pot_2
			Cxx_owe_km_pot_3
			Cxx_owe_km_pot_4
			Cxx_owe_max_drn_km_1
			Cxx_owe_max_drn_km_2
			Cxx_owe_max_drn_km_3
			Cxx_owe_max_drn_km_4
			Cxx_owe_min_drn_km_1
			Cxx_owe_min_drn_km_2
			Cxx_owe_min_drn_km_3
			Cxx_owe_min_drn_km_4
			Cxx_owe_n_mnl_asd_1
			Cxx_owe_n_mnl_asd_2
			Cxx_owe_n_mnl_asd_3
			Cxx_owe_n_mnl_asd_4
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_owe_off
			Vbx_owe_zon_writ
			ClLubWea_NVM.Vsx_owe_act_zon_NVM
			Vxx_owe_km_pot
			Vxx_owe_max_drn_km
			Vxx_owe_min_drn_km
			Vxx_owe_n_mnl_asd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin FUNCTION
		cllubwea_oxixxxx
		"Oil Wear Estimation lubricant oxydation with engine revolutions count"
	/begin DEF_CHARACTERISTIC
			Cbx_owe_toil_tco
			Cmp_owe_toil_prev_sta
			Ctb_owe_oil_dil
			Ctb_owe_toil
			Ctb_owe_toil_fac
			Ctb_owe_toil_off
			Ctb_owe_toil_sta
			Ctp_owe_dil
			Ctp_owe_toil
			Ctp_owe_toil_fac
			Cxx_owe_eng_aut_dly
			Cxx_owe_tco_sub
			Cxx_owe_toil_sub
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_owe_eng_aut
			Vbx_owe_eng_aut_dly
			Vbx_owe_fac_toil_act
			Vxx_owe_cmp_toil
			Vxx_owe_ctp_dil
			Vxx_owe_ctp_toil
			Vxx_owe_eng_rev_act_sum
			ClLubWea_NVM.Vxx_owe_eng_rev_prev_sum_NVM
			Vxx_owe_fac_toil_act
			Vxx_owe_fac_toil_tot
			Vxx_owe_n_aut
			Vxx_owe_n_toil_dil_u32
			ClLubWea_NVM.Vxx_owe_toil_eng_off_prev_NVM
			Vxx_owe_toil_sta
			Vxx_owe_toil_tco
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/begin FUNCTION
		oucboueg
		""
	/* ASAP2::Database : delete 'oucboueg_schxxxx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			oucboueg_upshtdg
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/begin FUNCTION
		oucboueg_upshtdg
		"Upstream proportional sensor heater powerstage diagnosis"
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_sens_ups_heat_oc
			Cxx_dfdec_sens_ups_heat_ovh
			Cxx_dfdec_sens_ups_heat_scg
			Cxx_dfdec_sens_ups_heat_scw
			Cxx_dfdec_ups_tip_oor
			Cxx_dfinc_sens_ups_heat_oc
			Cxx_dfinc_sens_ups_heat_ovh
			Cxx_dfinc_sens_ups_heat_scg
			Cxx_dfinc_sens_ups_heat_scw
			Cxx_dfinc_ups_tip_oor
	/end DEF_CHARACTERISTIC
	/begin LOC_MEASUREMENT
			Vbx_df_sens_ups_heat
			Vbx_df_ups_tip
	/end LOC_MEASUREMENT
	/begin OUT_MEASUREMENT
			Vbx_df_ups_heat
			Vsx_sens_ups_heat_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin FUNCTION
		oucloluo
		""
	/* ASAP2::Database : delete 'oucloluo_ptcgixx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			oucloluo_owkmdil
			oucloluo_schxxxx
			oucloluo_owkmwir
			oucloluo_owihmcs
			oucloluo_owihmpa
			oucloluo_owihmkm
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin FUNCTION
		oucloluo_owihmcs
		"Oil Wear Estimation Dashboard interface configuration"
	/begin DEF_CHARACTERISTIC
			Cbx_owe_sat_ena
			Cxx_owe_avl
			Cxx_owe_km7
			Cxx_owe_oil_dil_max_km
			Cxx_owe_oil_dil_min_km
			Cxx_owe_oil_dil_thd
	/end DEF_CHARACTERISTIC
	/begin LOC_MEASUREMENT
			Vbx_owe_req_km_2_clc
			Vxx_owe_km_sat_max
			Vxx_owe_pot_km_clc_2
	/end LOC_MEASUREMENT
	/begin OUT_MEASUREMENT
			OuCloLuo_NVM.Vbx_owe_dil_req_km_2_clc_NVM
			Vbx_owe_dil_req_km
			Vbx_owe_oil_drn_req_2_mux
			Vbx_owe_oil_drn_req_mux
			Vbx_owe_warn_req
			Vxx_owe_pot_km
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin FUNCTION
		oucloluo_owihmkm
		"Oil Wear Estimation remaining kilometers interface"
	/begin DEF_CHARACTERISTIC
			Cxx_owe_km_slop_max
			Cxx_owe_km_slop_min
			Cxx_owe_km1
			Cxx_owe_km2
			Cxx_owe_km3
			Cxx_owe_km4
			Cxx_owe_km5
	/end DEF_CHARACTERISTIC
	/begin LOC_MEASUREMENT
			Vbx_owe_ini_req_tmp
			Vbx_owe_ref_2_ok
			Vbx_owe_ref_2_upd
			Vxx_owe_ant
			Vxx_owe_km1_prev
			Vxx_owe_km2_prev
			Vxx_owe_km_slop
			Vxx_owe_km_var1
			Vxx_owe_km_var2
			Vxx_owe_km_var3
			Vxx_owe_pot_km_prev
			Vxx_owe_pot_km_rnd
			Vxx_owe_pot_km_step
			Vxx_owe_prev_drn_dist_prev
			Vxx_owe_raw_pot_km
			Vxx_owe_raw_pot_km_prev
			Vxx_owe_wea1_prev
			Vxx_owe_wea2_prev
			Vxx_owe_wea_act
			Vxx_owe_wea_act_pot
			Vxx_owe_wea_act_prev
			Vxx_owe_wea_spd
	/end LOC_MEASUREMENT
	/begin OUT_MEASUREMENT
			OuCloLuo_NVM.Vxx_owe_km1_NVM
			OuCloLuo_NVM.Vxx_owe_km2_NVM
			Vxx_owe_pot_km_clc
			OuCloLuo_NVM.Vxx_owe_pot_km_pot_NVM
			OuCloLuo_NVM.Vxx_owe_wea1_NVM
			OuCloLuo_NVM.Vxx_owe_wea2_NVM
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin FUNCTION
		oucloluo_owihmpa
		"Oil Wear Estimation pre-alert/alert interface"
	/begin DEF_CHARACTERISTIC
			Cbx_owe_avl
			Cbx_owe_avl_2
			Cbx_owe_dil_req_2_ena
			Cbx_owe_ena_1
			Cbx_owe_ena_2
			Cbx_owe_ena_3
			Cbx_owe_ena_4
			Cbx_owe_ena_5
			Cbx_owe_ena_6
			Cbx_owe_ena_7
			Cbx_owe_ena_8
			Cxx_owe_drn_req_dly
			Cxx_owe_oil_dil_min_km
			Cxx_owe_oil_dil_thd
			Cxx_owe_drn_dist_max_prg
	/end DEF_CHARACTERISTIC
	/begin LOC_MEASUREMENT
			Vbx_owe_drn_req
			Vbx_owe_drn_req_ok_2
			Vbx_owe_drn_req_rst
			Vbx_owe_n_drn_req
			Vbx_owe_oil_drn_req_2_mux_raw
			Vbx_owe_oil_drn_req_mux_raw
			Vbx_owe_prg
	/end LOC_MEASUREMENT
	/begin OUT_MEASUREMENT
			OuCloLuo_NVM.Vbx_owe_oil_drn_req_2_NVM
			OuCloLuo_NVM.Vbx_owe_oil_drn_req_NVM
			Vbx_owe_dil_req_km_1_clc
			Vbx_owe_oil_drn_req_2_clc
			Vbx_owe_oil_drn_req_clc
			Vbx_owe_warn_req_km_clc
			OuCloLuo_NVM.Vbx_owe_warn_req_km_mem_NVM
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin FUNCTION
		oucloluo_owkmdil
		"Oil Wear Estimation remaining kilometers interface with dilution parameters"
	/begin DEF_CHARACTERISTIC
			Cxx_owe_frst_km_dil_thd
			Cxx_owe_km_dil_intv
			Cxx_owe_km_oxi_dil_intrp
			Cxx_owe_km_slop_max_dil
			Cxx_owe_km_slop_min_dil
			Cxx_owe_km4_dil
			Cxx_owe_km5_dil
			Cxx_owe_oil_km_dil_thd
	/end DEF_CHARACTERISTIC
	/begin LOC_MEASUREMENT
			Vbx_owe_dil_wea_rmax_ovs
			Vbx_owe_oxi_dil_comp
			Vbx_owe_ref1_upd
			Vbx_owe_ref2_avl_dil
			Vbx_owe_ref2_upd
			Vbx_owe_trans_zon
			Vbx_owe_wea_nul
			Vxx_owe_ant_dil
			Vxx_owe_dil_intrp_fac
			Vxx_owe_dil_wea_pot
			Vxx_owe_km_oxi_dil
			Vxx_owe_km_oxi_dil_zon_1
			Vxx_owe_km_oxi_dil_zon_2
			Vxx_owe_km_oxi_dil_zon_3
			Vxx_owe_km_slop_dil
			Vxx_owe_km_var1_dil
			Vxx_owe_km_var2_dil
			Vxx_owe_km_var3_dil
			Vxx_owe_oil_km_dil
			Vxx_owe_oil_km_upd
			Vxx_owe_oxy_dil_km_fac
			Vxx_owe_pot_km_pot_dil
			Vxx_owe_pot_km_prev_dil
			Vxx_owe_raw_pot_km_dil
			Vxx_owe_raw_pot_km_dil_1
			Vxx_owe_prev_drn_dist_prev_2
			Vxx_owe_sat_km_slop_dil
			Vxx_owe_wea_act_dil
			Vxx_owe_wea_dil_dif
			Vxx_owe_wea_spd_dil
	/end LOC_MEASUREMENT
	/begin OUT_MEASUREMENT
			OuCloLuo_NVM.Vxx_owe_dil_NVM
			OuCloLuo_NVM.Vxx_owe_km1_dil_NVM
			OuCloLuo_NVM.Vxx_owe_km2_dil_NVM
			OuCloLuo_NVM.Vxx_owe_oxy_dil_fac_raw_NVM
			OuCloLuo_NVM.Vxx_owe_pot_km_rnd_dil_NVM
			Vxx_owe_pot_km_pot_oxy_dil
			OuCloLuo_NVM.Vxx_owe_wea1_dil_NVM
			OuCloLuo_NVM.Vxx_owe_wea2_dil_NVM
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin FUNCTION
		oucloluo_owkmwir
		"Oil wear estimation wire"
	/begin OUT_MEASUREMENT
			Vxx_owe_pot_km_pot_oxy_dil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin FUNCTION
		oucloluo_schxxxx
		"Output cooling lubrification schedulers"
	/begin DEF_CHARACTERISTIC
			Cbx_oil_heat_abst_pres_cho
			Cbx_owe_hmi_warn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_owe_hmi_warn_emb_cho
			Vbx_oil_heat_abst_pres_cho
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ABSinRegulation
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ABSinRegulation 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001efd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfacxou_xxxm3x_data.c' */
/begin MEASUREMENT
		ACCompAuthorized
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ACCompAuthorized 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001aff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfacxou_xxxm3x_data.c' */
/begin MEASUREMENT
		ACCompClutchActivation
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ACCompClutchActivation 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001b00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ACCompClutchRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ACCompClutchRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002437 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ACCompClutchStatus
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ACCompClutchStatus 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001efe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqacxou_xxxm3x_data.c' */
/begin MEASUREMENT
		ACCompMaximumPower
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ACCompMaximumPower 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ad9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ACCompPowerUsed
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ACCompPowerUsed 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001eff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ACCompRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ACCompRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ACCoolingFanSpeedRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER ACCoolingFanSpeedRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f01 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txp50ou_xxxm3x_data.c' */
/begin MEASUREMENT
		ACHighPressureSensor
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		511.
    DISPLAY_IDENTIFIER ACHighPressureSensor 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000d02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ACMinEngineIdleSpeedRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER ACMinEngineIdleSpeedRequest 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001f02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AIRBAGCrash[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER AIRBAGCrash_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000211f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AIRBAGCrash[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER AIRBAGCrash_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002120 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ASRDynamicTorqueRequest
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER ASRDynamicTorqueRequest 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000188e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ASRStaticTorqueRequest
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER ASRStaticTorqueRequest 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001890 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctqeou_xxxm3x_data.c' */
/begin MEASUREMENT
		ASR_MSRAcknowledgement
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ASR_MSRAcknowledgement 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ef9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ASRinRegulation
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ASRinRegulation 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f03 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ATCoolingFanSpeedRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER ATCoolingFanSpeedRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AT_Clock
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER AT_Clock 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001f05 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AT_MILRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER AT_MILRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AT_Minimum_IdleSpeedRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER AT_Minimum_IdleSpeedRequest 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001f07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctqeou_xxxm3x_data.c' */
/begin MEASUREMENT
		AT_TorqueAcknowledgement
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER AT_TorqueAcknowledgement 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001efa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AT_TorqueControlType
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER AT_TorqueControlType 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AT_TorqueLosses
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER AT_TorqueLosses 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001f09 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AYCinRegulation
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER AYCinRegulation 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002438 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AccurateOdometer
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		31.
    DISPLAY_IDENTIFIER AccurateOdometer 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0002439 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AirbagCrashOrder
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER AirbagCrashOrder 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007ad8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqapgou_xxxm3x_data.c' */
/begin MEASUREMENT
		AllowedPowerGradient
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER AllowedPowerGradient 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001adb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AlternatorLoad
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER AlternatorLoad 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001f0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqampou_xxxm3x_data.c' */
/begin MEASUREMENT
		AlternatorMaximumPower
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER AlternatorMaximumPower 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ada 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		AnticipatedCurrentShift
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER AnticipatedCurrentShift 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001f0b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_data.c' */
/begin MEASUREMENT
		AsEgrCtl_NVM.Vxx_egr_byp_blk_val_NVM
		""
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_egr_byp_blk_val_NVM 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0004dac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_data.c' */
/begin MEASUREMENT
		AsEgrCtl_NVM.Vxx_egr_byp_veh_dist_mem_NVM
		""
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_egr_byp_veh_dist_mem 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0004da8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin MEASUREMENT
		AsMafCtl_NVM.Vxx_maf_reg_neg_err_dyn_val_NVM
		"OBD memorized status for maf reg neg err"
		SBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		-128.
		127.
    DISPLAY_IDENTIFIER Vxx_maf_reg_neg_err_dyn_val 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000a70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin MEASUREMENT
		AsMafCtl_NVM.Vxx_maf_reg_neg_err_val_NVM
		"Memorized value of the maf error regulator for OBD service 06"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_reg_neg_err_val 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0000a6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_data.c' */
/begin MEASUREMENT
		AtCatDgn_NVM.Vbx_cata_nok_cge_dis_NVM
		"Request to prevent the diagnosis from being performed"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cata_nok_cge_dis 
    ECU_ADDRESS 0xd000529d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_data.c' */
/begin MEASUREMENT
		AtCatDgn_NVM.Vbx_ocd_ofs_ad_done_NVM
		"Logic indicating if offset learning has done at least once"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_ofs_ad_done 
    ECU_ADDRESS 0xd000529c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_data.c' */
/begin MEASUREMENT
		AtCatDgn_NVM.Vxx_cata_nok_cge_max_NVM
		"Diagnosis maximum threshold for mod6"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_cata_nok_cge_max 
    ECU_ADDRESS 0xd0005296 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_data.c' */
/begin MEASUREMENT
		AtCatDgn_NVM.Vxx_cata_nok_cge_min_NVM
		"Diagnosis minimum threshold for mod6"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_cata_nok_cge_min 
    ECU_ADDRESS 0xd0005298 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_data.c' */
/begin MEASUREMENT
		AtCatDgn_NVM.Vxx_cata_nok_cge_val_NVM
		"Diagnosis criterion for mod6"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_cata_nok_cge_val 
    ECU_ADDRESS 0xd000529a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_data.c' */
/begin MEASUREMENT
		AtCatDgn_NVM.Vxx_ocd_vh_dist_frz_NVM
		"End diagnosis freeze value of total vehicle distance"
		ULONG
		RB_CONV_AtCatDgn_km_1
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_ocd_vh_dist_frz 
    ECU_ADDRESS 0xd0005290 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_data.c' */
/begin MEASUREMENT
		AtCatDgn_NVM.Vxx_pft_utp_ofs_NVM
		"Offset ie averaged value of error in a sampled time window"
		UWORD
		RB_CONV_AtCatDgn_DegC_1200
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_ofs 
    ECU_ADDRESS 0xd0005294 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vbx_pft_asd_spd_req_trg_NVM
		"Initial value of sr flip flop for ecu init"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_spd_req_trg 
    ECU_ADDRESS 0xd0004e39 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[0]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[0] 
    ECU_ADDRESS 0xd0004dec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[10]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[10] 
    ECU_ADDRESS 0xd0004e00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[11]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[11] 
    ECU_ADDRESS 0xd0004e02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[12]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[12] 
    ECU_ADDRESS 0xd0004e04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[13]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[13] 
    ECU_ADDRESS 0xd0004e06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[14]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[14] 
    ECU_ADDRESS 0xd0004e08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[15]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[15] 
    ECU_ADDRESS 0xd0004e0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[16]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[16] 
    ECU_ADDRESS 0xd0004e0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[17]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[17] 
    ECU_ADDRESS 0xd0004e0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[18]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[18] 
    ECU_ADDRESS 0xd0004e10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[1]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[1] 
    ECU_ADDRESS 0xd0004dee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[2]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[2] 
    ECU_ADDRESS 0xd0004df0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[3]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[3] 
    ECU_ADDRESS 0xd0004df2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[4]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[4] 
    ECU_ADDRESS 0xd0004df4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[5]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[5] 
    ECU_ADDRESS 0xd0004df6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[6]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[6] 
    ECU_ADDRESS 0xd0004df8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[7]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[7] 
    ECU_ADDRESS 0xd0004dfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[8]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[8] 
    ECU_ADDRESS 0xd0004dfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_NVM[9]
		"Offset of vehicle mileage for each during each CSF statemachine transition"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist[9] 
    ECU_ADDRESS 0xd0004dfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[0]
		"Offset of vehicle mileage for each check temperature request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_chk[0] 
    ECU_ADDRESS 0xd0004e12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[1]
		"Offset of vehicle mileage for each check temperature request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_chk[1] 
    ECU_ADDRESS 0xd0004e14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[2]
		"Offset of vehicle mileage for each check temperature request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_chk[2] 
    ECU_ADDRESS 0xd0004e16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[3]
		"Offset of vehicle mileage for each check temperature request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_chk[3] 
    ECU_ADDRESS 0xd0004e18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[4]
		"Offset of vehicle mileage for each check temperature request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_chk[4] 
    ECU_ADDRESS 0xd0004e1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[5]
		"Offset of vehicle mileage for each check temperature request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_chk[5] 
    ECU_ADDRESS 0xd0004e1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[6]
		"Offset of vehicle mileage for each check temperature request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_chk[6] 
    ECU_ADDRESS 0xd0004e1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[7]
		"Offset of vehicle mileage for each check temperature request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_chk[7] 
    ECU_ADDRESS 0xd0004e20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_dist_chk_NVM[8]
		"Offset of vehicle mileage for each check temperature request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_chk[8] 
    ECU_ADDRESS 0xd0004e22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[0]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[0] 
    ECU_ADDRESS 0xd0004e24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[1]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[1] 
    ECU_ADDRESS 0xd0004e25 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[2]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[2] 
    ECU_ADDRESS 0xd0004e26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[3]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[3] 
    ECU_ADDRESS 0xd0004e27 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[4]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[4] 
    ECU_ADDRESS 0xd0004e28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[5]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[5] 
    ECU_ADDRESS 0xd0004e29 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[6]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[6] 
    ECU_ADDRESS 0xd0004e2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[7]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[7] 
    ECU_ADDRESS 0xd0004e2b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[8]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[8] 
    ECU_ADDRESS 0xd0004e2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_load_chk_NVM[9]
		"Vsx_load_stop_req for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_load_chk[9] 
    ECU_ADDRESS 0xd0004e2d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[0]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[0] 
    ECU_ADDRESS 0xd0004e2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[1]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[1] 
    ECU_ADDRESS 0xd0004e2f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[2]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[2] 
    ECU_ADDRESS 0xd0004e30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[3]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[3] 
    ECU_ADDRESS 0xd0004e31 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[4]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[4] 
    ECU_ADDRESS 0xd0004e32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[5]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[5] 
    ECU_ADDRESS 0xd0004e33 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[6]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[6] 
    ECU_ADDRESS 0xd0004e34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[7]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[7] 
    ECU_ADDRESS 0xd0004e35 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[8]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[8] 
    ECU_ADDRESS 0xd0004e36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vtx_pft_asd_ms_chk_NVM[9]
		"Soot mass for each check temperature request"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_chk[9] 
    ECU_ADDRESS 0xd0004e37 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vxx_pft_asd_dist_chk_ref_NVM
		"Actual Vehicle mileage during each check temperature request"
		ULONG
		RB_CONV_length_km
		1
		100
		0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_dist_chk_ref 
    ECU_ADDRESS 0xd0004de8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vxx_pft_asd_dist_old_NVM
		"Indicates the vehicle mileage just after the old storage"
		ULONG
		RB_CONV_length_km
		1
		100
		0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_dist_old 
    ECU_ADDRESS 0xd0004de0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vxx_pft_asd_dist_ref_NVM
		"Actual Vehicle mileage during each CSF statemachine transition"
		ULONG
		RB_CONV_length_km
		1
		100
		0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_dist_ref 
    ECU_ADDRESS 0xd0004de4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_1_NVM.Vxx_pft_asd_err_nr_NVM
		"Number of speed request state activation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		63.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_err_nr 
    ECU_ADDRESS 0xd0004e38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[0]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[0] 
    ECU_ADDRESS 0xd000168e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[1]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[1] 
    ECU_ADDRESS 0xd0001690 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[2]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[2] 
    ECU_ADDRESS 0xd0001692 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[3]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[3] 
    ECU_ADDRESS 0xd0001694 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[4]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[4] 
    ECU_ADDRESS 0xd0001696 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[5]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[5] 
    ECU_ADDRESS 0xd0001698 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[6]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[6] 
    ECU_ADDRESS 0xd000169a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[7]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[7] 
    ECU_ADDRESS 0xd000169c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[8]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[8] 
    ECU_ADDRESS 0xd000169e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_csm_fail_NVM[9]
		"filtered fuel consumption for each failure of regeneration"
		UWORD
		RB_CONV_flconsum_1
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_csm_fail[9] 
    ECU_ADDRESS 0xd00016a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[0]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[0] 
    ECU_ADDRESS 0xd00016a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[1]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[1] 
    ECU_ADDRESS 0xd00016a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[2]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[2] 
    ECU_ADDRESS 0xd00016a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[3]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[3] 
    ECU_ADDRESS 0xd00016a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[4]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[4] 
    ECU_ADDRESS 0xd00016aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[5]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[5] 
    ECU_ADDRESS 0xd00016ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[6]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[6] 
    ECU_ADDRESS 0xd00016ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[7]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[7] 
    ECU_ADDRESS 0xd00016b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[8]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[8] 
    ECU_ADDRESS 0xd00016b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_fail_NVM[9]
		"10 last values of vehicle mileage for each failure of regeneration"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_fail[9] 
    ECU_ADDRESS 0xd00016b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[0]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[0] 
    ECU_ADDRESS 0xd00016b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[1]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[1] 
    ECU_ADDRESS 0xd00016b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[2]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[2] 
    ECU_ADDRESS 0xd00016ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[3]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[3] 
    ECU_ADDRESS 0xd00016bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[4]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[4] 
    ECU_ADDRESS 0xd00016be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[5]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[5] 
    ECU_ADDRESS 0xd00016c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[6]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[6] 
    ECU_ADDRESS 0xd00016c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[7]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[7] 
    ECU_ADDRESS 0xd00016c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[8]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[8] 
    ECU_ADDRESS 0xd00016c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_dist_spd_NVM[9]
		"Values of vehicle mileage for each speed request"
		UWORD
		RB_CONV_length_km
		1
		100
		0
		65535.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_dist_spd[9] 
    ECU_ADDRESS 0xd00016c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[0]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[0] 
    ECU_ADDRESS 0xd00016ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[1]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[1] 
    ECU_ADDRESS 0xd00016cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[2]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[2] 
    ECU_ADDRESS 0xd00016cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[3]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[3] 
    ECU_ADDRESS 0xd00016cd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[4]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[4] 
    ECU_ADDRESS 0xd00016ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[5]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[5] 
    ECU_ADDRESS 0xd00016cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[6]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[6] 
    ECU_ADDRESS 0xd00016d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[7]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[7] 
    ECU_ADDRESS 0xd00016d1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[8]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[8] 
    ECU_ADDRESS 0xd00016d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_eng_sp_chk_NVM[9]
		"Values of engine operating point for each check temperature request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		7
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_sp_chk[9] 
    ECU_ADDRESS 0xd00016d3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[0]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[0] 
    ECU_ADDRESS 0xd00016e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[1]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[1] 
    ECU_ADDRESS 0xd00016e9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[2]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[2] 
    ECU_ADDRESS 0xd00016ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[3]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[3] 
    ECU_ADDRESS 0xd00016eb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[4]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[4] 
    ECU_ADDRESS 0xd00016ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[5]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[5] 
    ECU_ADDRESS 0xd00016ed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[6]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[6] 
    ECU_ADDRESS 0xd00016ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[7]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[7] 
    ECU_ADDRESS 0xd00016ef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[8]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[8] 
    ECU_ADDRESS 0xd00016f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_NVM[9]
		"Values of soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms[9] 
    ECU_ADDRESS 0xd00016f1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[0]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[0] 
    ECU_ADDRESS 0xd00016de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[1]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[1] 
    ECU_ADDRESS 0xd00016df 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[2]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[2] 
    ECU_ADDRESS 0xd00016e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[3]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[3] 
    ECU_ADDRESS 0xd00016e1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[4]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[4] 
    ECU_ADDRESS 0xd00016e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[5]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[5] 
    ECU_ADDRESS 0xd00016e3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[6]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[6] 
    ECU_ADDRESS 0xd00016e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[7]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[7] 
    ECU_ADDRESS 0xd00016e5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[8]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[8] 
    ECU_ADDRESS 0xd00016e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_ms_sim_NVM[9]
		"Relative soot mass for step of distance"
		UBYTE
		RB_CONV_Mass_g
		1
		100
		0
		100.8
    DISPLAY_IDENTIFIER Vtx_pft_asd_ms_sim[9] 
    ECU_ADDRESS 0xd00016e7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[0]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[0] 
    ECU_ADDRESS 0xd00016d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[1]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[1] 
    ECU_ADDRESS 0xd00016d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[2]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[2] 
    ECU_ADDRESS 0xd00016d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[3]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[3] 
    ECU_ADDRESS 0xd00016d7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[4]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[4] 
    ECU_ADDRESS 0xd00016d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[5]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[5] 
    ECU_ADDRESS 0xd00016d9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[6]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[6] 
    ECU_ADDRESS 0xd00016da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[7]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[7] 
    ECU_ADDRESS 0xd00016db 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[8]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[8] 
    ECU_ADDRESS 0xd00016dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_2_NVM.Vtx_pft_asd_spd_vh_fail_NVM[9]
		"filtered vehicle speed at failure of regeneration"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_spd_vh_fail[9] 
    ECU_ADDRESS 0xd00016dd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[0]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[0] 
    ECU_ADDRESS 0xd0001ea6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[1]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[1] 
    ECU_ADDRESS 0xd0001ea7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[2]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[2] 
    ECU_ADDRESS 0xd0001ea8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[3]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[3] 
    ECU_ADDRESS 0xd0001ea9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[4]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[4] 
    ECU_ADDRESS 0xd0001eaa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[5]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[5] 
    ECU_ADDRESS 0xd0001eab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[6]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[6] 
    ECU_ADDRESS 0xd0001eac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[7]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[7] 
    ECU_ADDRESS 0xd0001ead 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[8]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[8] 
    ECU_ADDRESS 0xd0001eae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_eng_stt_NVM[9]
		"engine statemachine status for each failure of regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_eng_stt[9] 
    ECU_ADDRESS 0xd0001eaf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[0]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[0] 
    ECU_ADDRESS 0xd0001e88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[10]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[10] 
    ECU_ADDRESS 0xd0001e92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[11]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[11] 
    ECU_ADDRESS 0xd0001e93 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[12]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[12] 
    ECU_ADDRESS 0xd0001e94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[13]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[13] 
    ECU_ADDRESS 0xd0001e95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[14]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[14] 
    ECU_ADDRESS 0xd0001e96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[15]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[15] 
    ECU_ADDRESS 0xd0001e97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[16]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[16] 
    ECU_ADDRESS 0xd0001e98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[17]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[17] 
    ECU_ADDRESS 0xd0001e99 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[18]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[18] 
    ECU_ADDRESS 0xd0001e9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[19]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[19] 
    ECU_ADDRESS 0xd0001e9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[1]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[1] 
    ECU_ADDRESS 0xd0001e89 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[2]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[2] 
    ECU_ADDRESS 0xd0001e8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[3]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[3] 
    ECU_ADDRESS 0xd0001e8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[4]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[4] 
    ECU_ADDRESS 0xd0001e8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[5]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[5] 
    ECU_ADDRESS 0xd0001e8d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[6]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[6] 
    ECU_ADDRESS 0xd0001e8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[7]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[7] 
    ECU_ADDRESS 0xd0001e8f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[8]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[8] 
    ECU_ADDRESS 0xd0001e90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_stt_NVM[9]
		"CSF state transitions stored in EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vtx_pft_asd_stt[9] 
    ECU_ADDRESS 0xd0001e91 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[0]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[0] 
    ECU_ADDRESS 0xd0001eb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[1]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[1] 
    ECU_ADDRESS 0xd0001eb1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[2]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[2] 
    ECU_ADDRESS 0xd0001eb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[3]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[3] 
    ECU_ADDRESS 0xd0001eb3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[4]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[4] 
    ECU_ADDRESS 0xd0001eb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[5]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[5] 
    ECU_ADDRESS 0xd0001eb5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[6]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[6] 
    ECU_ADDRESS 0xd0001eb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[7]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[7] 
    ECU_ADDRESS 0xd0001eb7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[8]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[8] 
    ECU_ADDRESS 0xd0001eb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_thd_temp_fail_NVM[9]
		"regeneration failure status due to insuficient temperature"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_thd_temp_fail[9] 
    ECU_ADDRESS 0xd0001eb9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[0]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[0] 
    ECU_ADDRESS 0xd0001e9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[1]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[1] 
    ECU_ADDRESS 0xd0001e9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[2]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[2] 
    ECU_ADDRESS 0xd0001e9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[3]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[3] 
    ECU_ADDRESS 0xd0001e9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[4]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[4] 
    ECU_ADDRESS 0xd0001ea0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[5]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[5] 
    ECU_ADDRESS 0xd0001ea1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[6]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[6] 
    ECU_ADDRESS 0xd0001ea2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[7]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[7] 
    ECU_ADDRESS 0xd0001ea3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[8]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[8] 
    ECU_ADDRESS 0xd0001ea4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		AtPftAfs_3_NVM.Vtx_pft_asd_vs_NVM[9]
		"value of vehicle speed for step of distance"
		UBYTE
		RB_CONV_VehSpd
		1
		100
		0
		252.0
    DISPLAY_IDENTIFIER Vtx_pft_asd_vs[9] 
    ECU_ADDRESS 0xd0001ea5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_data.c' */
/begin MEASUREMENT
		AtPftDgn_NVM.Vxx_pft_diag_err_ctr_NVM
		"Accumulator value to detect broken filter"
		SLONG
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		-65535.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_diag_err_ctr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00052d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_data.c' */
/begin MEASUREMENT
		AtPftDgn_NVM.Vxx_pft_nok_cge_max_NVM
		"Maximum threshold for Malfunctioning CSF Diagnosis on mod6"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_nok_cge_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00052dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_data.c' */
/begin MEASUREMENT
		AtPftDgn_NVM.Vxx_pft_nok_cge_val_NVM
		"Diagnosis criterion for Malfunctioning CSF Diagnosis on mod6"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_nok_cge_val 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00052de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vbx_pft_ms_ofs_clc_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_ofs_clc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00078f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vxx_ms_ofs_clc_t_ofs_NVM
		""
		UWORD
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_ms_ofs_clc_t_ofs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00078ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vxx_pft_comb_ok_ms_thd_NVM
		""
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_comb_ok_ms_thd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00078ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vxx_pft_ms_NVM
		""
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00078f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vxx_pft_ms_lft_mem_NVM
		""
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_lft_mem 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00078e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vxx_pft_ms_ofs_NVM
		""
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_ofs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00078f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vxx_pft_ms_sim_fail_t_NVM
		""
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_ms_sim_fail_t 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00078e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vxx_pft_ms_sim_ofs_NVM
		""
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_sim_ofs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00078e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vxx_pft_ref_ms_NVM
		""
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ref_ms 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00078ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_data.c' */
/begin MEASUREMENT
		AtPftMdl_NVM.Vxx_pft_rgn_stop_ms_thd_NVM
		""
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_rgn_stop_ms_thd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00078e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vbx_pft_load_spd_vld_ok_1_NVM
		"boolean indicating if dft value is used for load speed estimation, or currently measured"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_load_spd_vld_ok_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000504e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vbx_pft_rgn_eng_rest_stt_NVM
		"Engine restart state activated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_eng_rest_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000504f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vbx_pft_rgn_ok_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000504d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vbx_pft_spd_req_lght_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_lght 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000504c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vsx_pft_load_spd_clc_stt_NVM
		"soot load speed calculation status"
		UBYTE
		nngBqjb_bunueAa_okABDAa_nft_Nc_
		1
		100
		1.
		4.
    DISPLAY_IDENTIFIER Vsx_pft_load_spd_clc_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000504b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vsx_pft_load_spd_ms_ref_stt_NVM
		"Status of the reference soot mass (value of Vsx_pft_sot_ms_cor_stt) stored for load speed calculation"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_load_spd_ms_ref_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0005048 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vsx_pft_rgn_cdn_tgt_NVM
		""
		UBYTE
		ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_rgn_cdn_tgt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0005047 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_ctr_cold_rgn_ok_NVM
		"Indicates the number of regeneration success in cold condition"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_cold_rgn_ok 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0005036 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_ctr_hot_rgn_ok_NVM
		"indicates the number of regeneration success in hot condition"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_hot_rgn_ok 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0005038 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_ctr_med_rgn_ok_NVM
		"Indicates the number of regeneration success in mediuml thermal condition"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_med_rgn_ok 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000503a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_ctr_rgn_err_NVM
		""
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_rgn_err 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0005049 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_ctr_rgn_err_cold_NVM
		"Indicates the number of regeneration failures in cold oportunity since the last sucess"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_rgn_err_cold 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0005044 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_ctr_rgn_err_hot_NVM
		"Indicates the number of regeneration failures in hot oportunity since the last sucess"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_rgn_err_hot 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0005046 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_ctr_rgn_err_med_NVM
		"Indicates the number of regeneration failures in medium oportunity since the last sucess"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_rgn_err_med 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0005045 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_dist_load_frst_NVM
		"Indicates the vehicle mileage just after a successful regeneration"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_dist_load_frst 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0005018 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_hot_cold_ref_dist_NVM
		"Ref distance (position) of last hot or med or cold opp (be careful: that variable has not the same min and max val as vehicle dist)"
		ULONG
		Ddbkgla_gwagdrc_gFhapic_kCRa10a
		1
		100
		-10000.
		16767215.
    DISPLAY_IDENTIFIER Vxx_pft_hot_cold_ref_dist 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0005020 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_hot_med_ref_dist_NVM
		"Ref distance (position) of last hot or med opportunity (be careful: that variable has not the same min and max val as vehicle dist)"
		ULONG
		Ddbkgla_gwagdrc_gFhapic_kCRa10a
		1
		100
		-10000.
		16767215.
    DISPLAY_IDENTIFIER Vxx_pft_hot_med_ref_dist 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0005024 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_hot_ref_dist_NVM
		"Reference distance (position) of last hot opportunity (be careful: that variable has not the same min and max val as vehicle dist)"
		ULONG
		Ddbkgla_gwagdrc_gFhapic_kCRa10a
		1
		100
		-10000.
		16767215.
    DISPLAY_IDENTIFIER Vxx_pft_hot_ref_dist 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd000501c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_load_spd_dist_ref_NVM
		"Reference value of particle fliter mileage, used for soot load speed calculation"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_load_spd_dist_ref 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0005028 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_load_spd_ms_ref_NVM
		"Reference soot mass, used for load speed calculation"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_load_spd_ms_ref 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0005032 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_mv_raw_sot_load_spd_NVM
		"average raw soot load speed"
		UBYTE
		ophrhBc_punivya_jtmurnb_g__005a
		1
		100
		-0.15
		0.35
    DISPLAY_IDENTIFIER Vxx_pft_mv_raw_sot_load_spd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000504a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_rgn_ena_t_ctr_NVM
		""
		UWORD
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_rgn_ena_t_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0005034 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_rgn_err_t_ctr_NVM
		"Useful time for oil evaporation since last regeneration failure to allow regeneration"
		ULONG
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_rgn_err_t_ctr 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd000502c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_rgn_err_vh_dist_NVM
		""
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_rgn_err_vh_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0005030 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_rgn_req_t_ctr_lft_NVM
		""
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_rgn_req_t_ctr_lft 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000503c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_vh_dist_rgn_err_cold_NVM
		"Vehicule distance stored at the maximum regeneration failure to disable regeneration in cold condition"
		UWORD
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		1
		100
		0.
		1048560.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_rgn_err_cold 
    FORMAT "%7.0" 
    ECU_ADDRESS 0xd000503e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_vh_dist_rgn_err_hot_NVM
		"Vehicule distance stored at the maximum regeneration failure to disable regeneration in hot condition"
		UWORD
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		1
		100
		0.
		1048560.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_rgn_err_hot 
    FORMAT "%7.0" 
    ECU_ADDRESS 0xd0005040 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_data.c' */
/begin MEASUREMENT
		AtPftMng_NVM.Vxx_pft_vh_dist_rgn_err_med_NVM
		"Vehicule distance stored at the maximum regeneration failure to disable regeneration in medium condition"
		UWORD
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		1
		100
		0.
		1048560.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_rgn_err_med 
    FORMAT "%7.0" 
    ECU_ADDRESS 0xd0005042 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_data.c' */
/begin MEASUREMENT
		AtSpvArb_NVM.Vxx_pft_dfl_vh_dist_aut_NVM
		"Vehicle distance memorized at the begining of autonomy strategy"
		UWORD
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		1
		100
		0.
		1048560.
    DISPLAY_IDENTIFIER Vxx_pft_dfl_vh_dist_aut 
    FORMAT "%7.0" 
    ECU_ADDRESS 0xd0007a2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_data.c' */
/begin MEASUREMENT
		AtSpvExc_NVM.Vxx_pft_fim_sp_NVM
		""
		UWORD
		uztFExb_owBhqra_ykamwda_l__000a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_fim_sp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007a30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_data.c' */
/begin MEASUREMENT
		AtSpvExc_NVM.Vxx_pft_spd_vh_sp_NVM
		""
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_spd_vh_sp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007a32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_data.c' */
/begin MEASUREMENT
		AtSpvExc_NVM.Vxx_pft_utp_eng_sp_NVM
		""
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_eng_sp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007a2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a21 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a23 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_01[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_01_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a25 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_01[6]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_01_6_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_01[7]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_01_7_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a27 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_02[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_02_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002121 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_02[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_02_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002122 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_02[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_02_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002123 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_02[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_02_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002124 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_02[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_02_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002125 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_02[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_02_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002126 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_02[6]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_02_6_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002127 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_CANHS_RNr_02[7]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_CANHS_RNr_02_7_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002128 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_VERLOG[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_VERLOG_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002129 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_VERLOG[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_VERLOG_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000212a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_VERLOG[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_VERLOG_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000212b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_VERLOG[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_VERLOG_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000212c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BCM_VERLOG[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BCM_VERLOG_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000212d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a29 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a2b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_01[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_01_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a2d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_01[6]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_01_6_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_02[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_02_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a2f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_02[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_02_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_02[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_02_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a31 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_02[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_02_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_02[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_02_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a33 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_02[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_02_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_03[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_03_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a35 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_03[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_03_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_03[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_03_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a37 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_03[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_03_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_03[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_03_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a39 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_03[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_03_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_04[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_04_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a3b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_04[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_04_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_04[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_04_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a3d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_04[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_04_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_04[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_04_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a3f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_04[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_04_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_04[6]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_04_6_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a41 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_RNr_04[7]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_RNr_04_7_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_R_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_R_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000212e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_R_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_R_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000212f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_R_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_R_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002130 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_R_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_R_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002131 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_R_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_R_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002132 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_R_01[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_R_01_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002133 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BRAKE_CANHS_R_01[6]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER BRAKE_CANHS_R_01_6_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002134 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BrakeInfoStatus
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER BrakeInfoStatus 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		BrakeSwitchFailure
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER BrakeSwitchFailure 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f0d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txp50ou_xxxm3x_data.c' */
/begin MEASUREMENT
		CCSpeedReachedDisplayReq
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER CCSpeedReachedDisplayReq 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000216f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLIM_CANHS_R_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLIM_CANHS_R_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a43 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLIM_CANHS_R_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLIM_CANHS_R_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLIM_CANHS_R_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLIM_CANHS_R_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a45 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLIM_CANHS_R_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLIM_CANHS_R_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLIM_CANHS_R_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLIM_CANHS_R_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a47 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLIM_CANHS_R_01[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLIM_CANHS_R_01_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_RNr_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_RNr_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002135 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_RNr_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_RNr_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002136 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_RNr_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_RNr_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002137 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_RNr_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_RNr_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002138 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_RNr_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_RNr_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002139 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_R_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_R_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000213a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_R_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_R_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000213b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_R_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_R_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000213c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_R_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_R_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000213d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_R_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_R_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000213e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_R_01[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_R_01_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000213f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_R_01[6]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_R_01_6_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002140 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CLUSTER_CANHS_R_01[7]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER CLUSTER_CANHS_R_01_7_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002141 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_data.c' */
/begin MEASUREMENT
		ClCooCtl_NVM.Sbx_eng_off_mdf1_on_NVM
		"Mdf1 state saved(engine stop)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_eng_off_mdf1_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ead 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vbx_owe_ini_0_NVM
		"Type of initialisation when the state of the counter is  0"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_0 
    ECU_ADDRESS 0xd00053aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vbx_owe_ini_1_NVM
		"Type of initialisation when the state of the counter is  1"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_1 
    ECU_ADDRESS 0xd00053ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vbx_owe_ini_2_NVM
		"Type of initialisation when the state of the counter is  2"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_2 
    ECU_ADDRESS 0xd00053ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vbx_owe_ini_3_NVM
		"Type of initialisation when the state of the counter is  3"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_3 
    ECU_ADDRESS 0xd00053ad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vbx_owe_ini_prev_NVM
		"State of the previous initialisation of the strategy (0 = after sales department)"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_prev 
    ECU_ADDRESS 0xd00053ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vsx_owe_act_zon_NVM
		"Actual geographical zon"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		1
		5
    DISPLAY_IDENTIFIER Vsx_owe_act_zon 
    ECU_ADDRESS 0xd00053a9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_oil_dil_raw_NVM
		"Current oil dilution rate"
		ULONG
		RB_CONV_000001_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_oil_dil_raw 
    ECU_ADDRESS 0xd0005394 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_oil_dil_rij_NVM
		"Current normal mode oil dilution rate"
		ULONG
		RB_CONV_00000001_Prc
		1
		100
		0.0
		42.94
    DISPLAY_IDENTIFIER Vxx_oil_dil_rij 
    ECU_ADDRESS 0xd0005398 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_ctr_stt_NVM
		"Counter state stored on EEPROM"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3
    DISPLAY_IDENTIFIER Vxx_owe_ctr_stt 
    ECU_ADDRESS 0xd00053a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_dil_req_km_NVM
		"Total vehicle distance when the oil dilution becomes to high stored on EEPROM"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_owe_dil_req_km 
    ECU_ADDRESS 0xd0005368 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_eng_rev_act_sum_0_NVM
		"Number of engine turns on initialisation when the state of the counter is 0 (on EEPROM)"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vxx_owe_eng_rev_act_sum_0 
    ECU_ADDRESS 0xd0005380 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_eng_rev_act_sum_1_NVM
		"Number of engine turns on initialisation when the state of the counter is 1 (on EEPROM)"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vxx_owe_eng_rev_act_sum_1 
    ECU_ADDRESS 0xd0005384 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_eng_rev_act_sum_2_NVM
		"Number of engine turns on initialisation when the state of the counter is 2 (on EEPROM)"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vxx_owe_eng_rev_act_sum_2 
    ECU_ADDRESS 0xd0005388 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_eng_rev_act_sum_3_NVM
		"Number of engine turns on initialisation when the state of the counter is 3 (on EEPROM)"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vxx_owe_eng_rev_act_sum_3 
    ECU_ADDRESS 0xd000538c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_eng_rev_prev_sum_NVM
		"Previous engine revolutions sum stored in EEPROM"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vxx_owe_eng_rev_prev_sum 
    ECU_ADDRESS 0xd0005390 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_km_0_NVM
		"Number of kilometers travelled on initialisation when the state of the counter is 0 (on EEPROM)"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_owe_km_0 
    ECU_ADDRESS 0xd0005370 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_km_1_NVM
		"Number of kilometers travelled on initialisation when the state of the counter is 1 (on EEPROM)"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_owe_km_1 
    ECU_ADDRESS 0xd0005374 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_km_2_NVM
		"Number of kilometers travelled on initialisation when the state of the counter is  2  (on EEPROM)"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_owe_km_2 
    ECU_ADDRESS 0xd0005378 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_km_3_NVM
		"Number of kilometers travelled on initialisation when the state of the counter is  3  (on EEPROM)"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_owe_km_3 
    ECU_ADDRESS 0xd000537c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_pot_km_0_NVM
		"Potential kilometer storred when the counter is 0 (on EEPROM)"
		UWORD
		RB_CONV_OneToOne
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_0 
    ECU_ADDRESS 0xd000539e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_pot_km_1_NVM
		"Potential kilometer storred when the counter is 1 (on EEPROM)"
		UWORD
		RB_CONV_OneToOne
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_1 
    ECU_ADDRESS 0xd00053a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_pot_km_2_NVM
		"Potential kilometer storred when the counter is 2 (on EEPROM)"
		UWORD
		RB_CONV_OneToOne
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_2 
    ECU_ADDRESS 0xd00053a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_pot_km_3_NVM
		"Potential kilometer storred when the counter is 3 (on EEPROM)"
		UWORD
		RB_CONV_OneToOne
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_3 
    ECU_ADDRESS 0xd00053a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_prev_ini_km_NVM
		"Vehicle kilometers on the previous oil drain"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_owe_prev_ini_km 
    ECU_ADDRESS 0xd0005364 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_toil_eng_off_prev_NVM
		"Oil temperature for oil wear estimation strategy (with saturation) on previous engine off"
		UWORD
		RB_CONV_DegC
		1
		100
		-40
		200
    DISPLAY_IDENTIFIER Vxx_owe_toil_eng_off_prev 
    ECU_ADDRESS 0xd000539c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_owe_warn_req_km_NVM
		"Vehilcle kilometers when the pre alert appear"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vxx_owe_warn_req_km 
    ECU_ADDRESS 0xd000536c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_data.c' */
/begin MEASUREMENT
		ClLubWea_NVM.Vxx_pft_oil_dil_max_NVM
		"Maximum oil dilution rate during the calibrated distance"
		UWORD
		RB_CONV_100_65535_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_pft_oil_dil_max 
    ECU_ADDRESS 0xd00053a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ClimateCoolingRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ClimateCoolingRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000243a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ClutchSwitchMaximumTravel
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER ClutchSwitchMaximumTravel 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ClutchSwitchMinimumTravel
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER ClutchSwitchMinimumTravel 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f0f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_abs_lk_stt_NVM
		"Mux Network configuration detection : Brake Control Unit status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_abs_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a15 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_ac_lk_stt_NVM
		"Mux Network configuration detection : Air Conditioning Control Unit Status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a1b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_acc_lk_stt_NVM
		"ACC frame presence detection with security on configuration detection. Stored in E²PROM"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acc_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_agb_lk_stt_NVM
		"The transmission is automatic (known as soon as an AT frame is received)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_ccu_lk_stt_NVM
		"Mux Network configuration detection : BCM Control Unit Status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ccu_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a17 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_ddcm_lk_stt_NVM
		"Mux Network configuration detection : Driver Door Control Module status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ddcm_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_ip_lk_stt_NVM
		"Mux Network configuration detection : Cluster Control Unit Status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ip_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_sdl_lk_stt_NVM
		"Detect the Speed Distance Limiter option. Stored in E²PROM."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sdl_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_swa_lk_stt_NVM
		"Mux Network configuration detection: Steering Wheel Angle Unit status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swa_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a1d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vbx_usm_lk_stt_NVM
		"Mux Network configuration detection : USM Control Unit Status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_usm_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a19 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_abs_ecu_stt_ctr_mem_NVM
		"Brake Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_abs_ecu_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_ac_ecu_stt_ctr_mem_NVM
		"Climate Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ac_ecu_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_acc_ecu_stt_ctr_mem_NVM
		"Automatic Cruise Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_acc_ecu_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a13 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_agb_ecu_stt_ctr_mem_NVM
		"Automatic Gear Box Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_agb_ecu_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a0d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_bus_off_stt_ctr_mem_NVM
		"Bus Off Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_bus_off_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_ccu_ecu_stt_ctr_mem_NVM
		"BCM Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ccu_ecu_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_ddcm_ecu_stt_ctr_mem_NVM
		"DDCM Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ddcm_ecu_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a0f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_ip_ecu_stt_ctr_mem_NVM
		"Cluster Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ip_ecu_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_mute_stt_ctr_mem_NVM
		"Mute : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mute_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a0b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_swa_ecu_stt_ctr_mem_NVM
		"Steering Wheel Angle Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_swa_ecu_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		CmMuxSer_NVM.Vxx_usm_ecu_stt_ctr_mem_NVM
		"USM Control Unit : current failures non-volatile counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_usm_ecu_stt_ctr_mem 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_clkmxou_xxxm3x_data.c' */
/begin MEASUREMENT
		ComputedOilDrainingRange
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER ComputedOilDrainingRange 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007ad6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txp50ou_xxxm3x_data.c' */
/begin MEASUREMENT
		CrankingAuthorization_ECM
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER CrankingAuthorization_ECM 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001afa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txp50ou_xxxm3x_data.c' */
/begin MEASUREMENT
		CruiseControlStatusDisplay
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER CruiseControlStatusDisplay 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000216c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txp50ou_xxxm3x_data.c' */
/begin MEASUREMENT
		CruiseControlStatus_forTM
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER CruiseControlStatus_forTM 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001afb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DDCM_CANLSFT_R_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER DDCM_CANLSFT_R_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a49 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DDCM_CANLSFT_R_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER DDCM_CANLSFT_R_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DDCM_CANLSFT_R_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER DDCM_CANLSFT_R_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a4b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DDCM_CANLSFT_R_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER DDCM_CANLSFT_R_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DDCM_CANLSFT_R_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER DDCM_CANLSFT_R_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a4d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_data.c' */
/begin MEASUREMENT
		DgDftMng_NVM.Sbx_obd_rdn_cata_NVM
		""
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_obd_rdn_cata 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000244d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_data.c' */
/begin MEASUREMENT
		DgDftMng_NVM.Sbx_obd_rdn_cata_cpt_NVM
		""
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_obd_rdn_cata_cpt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000244a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_data.c' */
/begin MEASUREMENT
		DgDftMng_NVM.Sbx_obd_rdn_egr_NVM
		""
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_obd_rdn_egr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000244c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_data.c' */
/begin MEASUREMENT
		DgDftMng_NVM.Sbx_obd_rdn_evap_NVM
		""
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_obd_rdn_evap 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000244f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_data.c' */
/begin MEASUREMENT
		DgDftMng_NVM.Sbx_obd_rdn_heat_NVM
		""
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_obd_rdn_heat 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000244e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_data.c' */
/begin MEASUREMENT
		DgDftMng_NVM.Sbx_obd_rdn_lbup_cpt_NVM
		""
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_obd_rdn_lbup_cpt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000244b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_data.c' */
/begin MEASUREMENT
		DgDftMng_NVM.Sbx_obd_rdn_pft_NVM
		""
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_obd_rdn_pft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002450 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[0]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[0] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002292 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[10]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[10] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000229c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[11]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[11] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000229d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[12]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[12] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000229e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[13]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[13] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000229f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[14]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[14] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[15]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[15] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022a1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[16]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[16] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[17]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[17] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022a3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[18]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[18] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[1]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[1] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002293 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[2]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[2] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002294 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[3]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[3] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002295 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[4]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[4] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002296 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[5]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[5] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002297 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[6]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[6] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002298 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[7]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[7] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002299 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[8]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[8] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000229a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[9]
		"Value of VIN and CRC data"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_vin_crc_data[9] 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000229b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DiagMuxOn_BCM
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER DiagMuxOn_BCM 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DiagnoseFuelLow
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER DiagnoseFuelLow 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000243b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbxxxou_xxxm3d_data.c' */
/begin MEASUREMENT
		DieselFilterWaterDetection
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER DieselFilterWaterDetection 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002425 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbxxxou_xxxm3d_data.c' */
/begin MEASUREMENT
		DieselPreHeating
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER DieselPreHeating 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002426 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DisplayedSpeed
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER DisplayedSpeed 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007ada 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DisplayedSpeedUnit
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER DisplayedSpeedUnit 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000243c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		DistanceTotalizer
		"Received CAN parameter"
		ULONG
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		268435455.
    DISPLAY_IDENTIFIER DistanceTotalizer 
    FORMAT "%9.0" 
    ECU_ADDRESS 0xd00053f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_clspoou_xxxm3x_data.c' */
/begin MEASUREMENT
		DownTransitionOfEngCoolantTemp
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER DownTransitionOfEngCoolantTemp 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000242a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_01[0]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_01_0_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_01[1]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_01_1_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_01[2]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_01_2_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_01[3]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_01_3_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_01[4]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_01_4_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_01[5]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_01_5_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_01[6]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_01_6_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_01[7]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_01_7_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_02[0]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_02_0_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002150 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_02[1]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_02_1_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002151 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_02[2]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_02_2_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002152 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_02[3]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_02_3_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002153 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_02[4]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_02_4_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002154 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_02[5]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_02_5_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002155 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_CANHS_RNr_02[6]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_CANHS_RNr_02_6_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002156 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_atpftou_xxxm3d_data.c' */
/begin MEASUREMENT
		ECM_MechanicalLoadRequest
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ECM_MechanicalLoadRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002422 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqreqou_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_TorqueRequestStatus
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER ECM_TorqueRequestStatus 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001adf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_VERLOG[0]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_VERLOG_0_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002157 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_VERLOG[1]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_VERLOG_1_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002158 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_VERLOG[2]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_VERLOG_2_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002159 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_VERLOG[3]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_VERLOG_3_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000215a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_VERLOG[4]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_VERLOG_4_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000215b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_VERLOG[5]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_VERLOG_5_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000215c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ECM_VERLOG[6]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ECM_VERLOG_6_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000215d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ESP_Clock
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER ESP_Clock 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001f11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ESP_TorqueControlType
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER ESP_TorqueControlType 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqecfou_xxxm3x_data.c' */
/begin MEASUREMENT
		ElectricalPowerCutFreeze
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER ElectricalPowerCutFreeze 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001adc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ElectricalPowerDrived
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		31.
    DISPLAY_IDENTIFIER ElectricalPowerDrived 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd000243d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		EmergencyEngineStop
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER EmergencyEngineStop 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001f13 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_dgwl1ou_xxxm3x_data.c' */
/begin MEASUREMENT
		EngineControlFailureLevel1
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER EngineControlFailureLevel1 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000242e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_dgwl2ou_xxxm3x_data.c' */
/begin MEASUREMENT
		EngineControlFailureLevel2
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER EngineControlFailureLevel2 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000242f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_clspoou_xxxm3x_data.c' */
/begin MEASUREMENT
		EngineCoolantRegulationTemp
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER EngineCoolantRegulationTemp 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000242b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cltoxou_xxxm3x_data.c' */
/begin MEASUREMENT
		EngineCoolantTemp
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER EngineCoolantTemp 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000242c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txp50ou_xxxm3x_data.c' */
/begin MEASUREMENT
		EngineFanSpeedRequest
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER EngineFanSpeedRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001afc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smspdou_xxxm3x_data.c' */
/begin MEASUREMENT
		EngineRPM
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER EngineRPM 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000cf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smengou_xxxm3x_data.c' */
/begin MEASUREMENT
		EngineStatus_R
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER EngineStatus_R 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ad7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txp50ou_xxxm3x_data.c' */
/begin MEASUREMENT
		EngineStopRequestOrigine
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER EngineStopRequestOrigine 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001afd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctqeou_xxxm3x_data.c' */
/begin MEASUREMENT
		EngineTorque_WithoutTMReq
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER EngineTorque_WithoutTMReq 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001888 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ExternalTemp
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER ExternalTemp 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001f14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FORCE_ECM_CANHS_R_01[0]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FORCE_ECM_CANHS_R_01_0_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000215e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FORCE_ECM_CANHS_R_01[1]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FORCE_ECM_CANHS_R_01_1_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000215f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FORCE_ECM_CANHS_R_01[2]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FORCE_ECM_CANHS_R_01_2_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002160 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FORCE_ECM_CANHS_R_01[3]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FORCE_ECM_CANHS_R_01_3_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002161 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FORCE_ECM_CANHS_R_01[4]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FORCE_ECM_CANHS_R_01_4_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002162 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FORCE_ECM_CANHS_R_01[5]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FORCE_ECM_CANHS_R_01_5_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002163 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FORCE_ECM_CANHS_R_01[6]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FORCE_ECM_CANHS_R_01_6_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002164 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FORCE_ECM_CANHS_R_01[7]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FORCE_ECM_CANHS_R_01_7_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002165 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FastTorqueRequest
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER FastTorqueRequest 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001892 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vffltou_xxxm3x_data.c' */
/begin MEASUREMENT
		FloatingInhibition
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER FloatingInhibition 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002170 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcfshou_xxxm3x_data.c' */
/begin MEASUREMENT
		FreeShift
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER FreeShift 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002436 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqlosou_xxxm3x_data.c' */
/begin MEASUREMENT
		FrictionTorque
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER FrictionTorque 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000cfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FrontDefrostEngaged
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER FrontDefrostEngaged 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f15 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbxxxou_xxxm3d_data.c' */
/begin MEASUREMENT
		FuelConsumption
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FuelConsumption 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002427 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FuelCutRequestedEngineSpeed
		"Received CAN parameter for engine speed limitation from EGB (CVT, ...)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER FuelCutRequestedEngineSpeed 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001f16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FuelLevelDisplayed
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		127.
    DISPLAY_IDENTIFIER FuelLevelDisplayed 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000243e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		FuelLow
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER FuelLow 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000243f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		GenericApplicativeDiagEnable
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER GenericApplicativeDiagEnable 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f17 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_data.c' */
/begin MEASUREMENT
		INPCIBKI_NVM.Vbx_sens_brk_pdl_open_lk_stt_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sens_brk_pdl_open_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000e10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_data.c' */
/begin MEASUREMENT
		INPCIBKI_NVM.Vxx_brk_pdl_clos_blk_off_dly_NVM
		"Close active brake switch blocked off counter delay"
		UWORD
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_brk_pdl_clos_blk_off_dly 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_data.c' */
/begin MEASUREMENT
		INPCIBKI_NVM.Vxx_brk_pdl_clos_blk_on_dly_NVM
		"Close active brake switch blocked on counter delay"
		UWORD
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_brk_pdl_clos_blk_on_dly 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_data.c' */
/begin MEASUREMENT
		INPCIBKI_NVM.Vxx_brk_pdl_open_blk_off_dly_NVM
		"Open active brake switch blocked off counter delay"
		UWORD
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_brk_pdl_open_blk_off_dly 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_data.c' */
/begin MEASUREMENT
		INPCIBKI_NVM.Vxx_brk_pdl_open_blk_on_dly_NVM
		"Open active brake switch blocked on counter delay"
		UWORD
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_brk_pdl_open_blk_on_dly 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_dgtdvcs_xxxxxx_data.c' */
/begin MEASUREMENT
		INVFIVSI_NVM.Vxx_vh_dist_NVM
		""
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_vh_dist 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004a10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smsptou_xxxm3x_data.c' */
/begin MEASUREMENT
		IdleSpeedControlInternalRequest
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER IdleSpeedControlInternalRequest 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000214b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_data.c' */
/begin MEASUREMENT
		InAsiIap_NVM.Vxx_map_dif_mem_NVM
		""
		SBYTE
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_map_dif_mem 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001be9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_data.c' */
/begin MEASUREMENT
		InAsiIap_NVM.Vxx_spg_dif_mem_NVM
		""
		SBYTE
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_spg_dif_mem 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001be8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_data.c' */
/begin MEASUREMENT
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		""
		UWORD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_ms_dp 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd00050de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_data.c' */
/begin MEASUREMENT
		InAtiPfi_NVM.Vxx_pft_tia_cor_mv_eprm_NVM
		""
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_tia_cor_mv_eprm 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd00050dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_data.c' */
/begin MEASUREMENT
		InAtiPfi_NVM.Vxx_pft_vh_dist_ofs_NVM
		""
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_ofs 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd00050d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_data.c' */
/begin MEASUREMENT
		InAtiPfi_NVM.Vxx_pft_vh_dist_rgn_tia_mv_eprm_NVM
		""
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_rgn_tia_mv_eprm 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd00050d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_data.c' */
/begin MEASUREMENT
		InAtiPfi_NVM.Vxx_rup_dif_mem_NVM
		""
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_rup_dif_mem 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00050e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_data.c' */
/begin MEASUREMENT
		InCliLui_NVM.Vxx_pft_oil_csm_NVM
		""
		UWORD
		Dweusab_Abjlppc_wagagja_kCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_oil_csm 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0007b0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		InPciApi_NVM.Vxx_acel_pdl_secu_ctr_NVM
		"Counter of accelerator pedal safety case detected failure N°1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_acel_pdl_secu_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00022f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vbx_cru_lk_stt_NVM
		"Detect cruise control option with security on configuration detection. Stored in E²PROM."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_lk_stt_NVM 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c2d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vbx_cru_swi_lk_stt_NVM
		"Detect the cruise control switch connection. Stored in E²PROM."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_swi_lk_stt_NVM 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vbx_sl_lk_stt_NVM
		"speed limiter option detection with security on configuration detection. Stored in E²PROM."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sl_lk_stt_NVM 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c2f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vbx_sl_swi_lk_stt_NVM
		"Detect the speed limiter switch connection. Stored in E²PROM."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sl_swi_lk_stt_NVM 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vbx_whl_lk_stt_NVM
		"Steering wheel switches connection detection. Stored in E²PROM."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_whl_lk_stt_NVM 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vxx_cru_sl_acel_blk_dly_max_NVM
		"Maximum duration of SET+ button press"
		UBYTE
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_acel_blk_dly_max_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vxx_cru_sl_decl_blk_dly_max_NVM
		"Maximum duration of SET- button press"
		UBYTE
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_decl_blk_dly_max_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c29 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vxx_cru_sl_resu_blk_dly_max_NVM
		"Maximum duration of RESUME button press"
		UBYTE
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_resu_blk_dly_max_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c27 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vxx_cru_sl_susp_blk_dly_max_NVM
		"Maximum duration of SUSPEND button press"
		UBYTE
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_susp_blk_dly_max 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_data.c' */
/begin MEASUREMENT
		InPciCci_NVM.Vxx_cru_sl_whl_cmd_blk_ctr_max_NVM
		"Maximum value of counter for detection of blocked button. Saved in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_whl_cmd_blk_ctr_max_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c2b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_data.c' */
/begin MEASUREMENT
		InPciDls_NVM.Vbx_sens_bgin_clu_cnt_lk_stt_NVM
		"Begin clutch contactor connection status (1 = connected; 0 = not connected). Stored in EEPROM"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sens_bgin_clu_cnt_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_data.c' */
/begin MEASUREMENT
		InPciDls_NVM.Vxx_bgin_clu_off_no_chr_ctr_NVM
		"Number of incoherencies when the begin clutch contactor is OFF"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_bgin_clu_off_no_chr_ctr_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_data.c' */
/begin MEASUREMENT
		InPciDls_NVM.Vxx_bgin_clu_on_no_chr_ctr_NVM
		"Number of incoherencies when the begin clutch contactor is ON"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_bgin_clu_on_no_chr_ctr_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vbx_clu_stal_ctr_NVM
		"Boolean to allow increment of Vxx_clu_stal_ctr"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_clu_stal_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000e4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_clu_stal_ctr_NVM
		"Counter of stalling of type: clutch, failed starting up, due to the software lock"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_clu_stal_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_crk_syn_loss_ctr_NVM
		"Counter of loss of crankshaft synchronization."
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_crk_syn_loss_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_cylr_is_vld_ctr_NVM
		"Counter of success of cylinder recognition in idle speed regulation"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_cylr_is_vld_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_cylr_ok_aftr_stal_ctr_NVM
		"Counter of confirmation of phase in using cylinder recognition (running vehicule)"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_cylr_ok_aftr_stal_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_cylr_ok_ctr_NVM
		"Failure counter for cylinder recognition"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_cylr_ok_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_err_cylr_ctr_NVM
		"cylinder recognition counter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_err_cylr_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_err_cylr_is_run_ctr_NVM
		"cylinder recognition counter in idle speed regulation"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_err_cylr_is_run_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_err_id_is_run_ctr_NVM
		"Failure counter for idle speed speed regulation (not confirmed by cylinder recognition for running vehicle)"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_err_id_is_run_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_is_cylr_ok_ctr_NVM
		"Counter of success od cylinder recognition in idle speed regulation"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_is_cylr_ok_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_no_deci_cylr_ctr_NVM
		"Counter of no decision of cylinder recognition"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_no_deci_cylr_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_no_deci_id_is_ctr_NVM
		"Counter of no decision of cylinder recognition in RR mode"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_no_deci_id_is_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_data.c' */
/begin MEASUREMENT
		InSmiSyn_NVM.Vxx_run_re_phs_ctr_NVM
		"Rephasing counter after cylinder recognition in running vehicle"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_run_re_phs_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_data.c' */
/begin MEASUREMENT
		InVfiAci_NVM.Vbx_ac_prs_lk_stt_NVM
		"Air conditioning pressure sensor detection. Stored in E²PROM."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_prs_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000280e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_data.c' */
/begin MEASUREMENT
		InVfiAci_NVM.Vbx_ac_req_lk_stt_NVM
		"Air conditioning request detection. Stored in E²PROM."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_req_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000280f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_data.c' */
/begin MEASUREMENT
		InVfiAci_NVM.Vbx_comp_cfa_lk_stt_NVM
		"Cabin fan request detection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comp_cfa_lk_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002810 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		InputShaftRevolution
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER InputShaftRevolution 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001894 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		InstantMecanicalPowerByAlt
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER InstantMecanicalPowerByAlt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001f18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		KeyVehicle
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER KeyVehicle 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002440 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcaplou_xxxm3x_data.c' */
/begin MEASUREMENT
		KickDownActivated
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER KickDownActivated 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ef0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Limit_SlowTorqueRequest
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER Limit_SlowTorqueRequest 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001896 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_dgmilou_xxxm3x_data.c' */
/begin MEASUREMENT
		MILLamp
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER MILLamp 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd000242d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		MMI_ECM_CANHS_RNr_01[0]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER MMI_ECM_CANHS_RNr_01_0_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002166 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		MMI_ECM_CANHS_RNr_01[1]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER MMI_ECM_CANHS_RNr_01_1_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002167 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		MMI_ECM_CANHS_RNr_01[2]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER MMI_ECM_CANHS_RNr_01_2_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002168 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		MMI_ECM_CANHS_RNr_01[3]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER MMI_ECM_CANHS_RNr_01_3_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002169 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		MMI_ECM_CANHS_RNr_01[4]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER MMI_ECM_CANHS_RNr_01_4_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000216a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		MMI_ECM_CANHS_RNr_01[5]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER MMI_ECM_CANHS_RNr_01_5_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000216b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		MSRTorqueRequest
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER MSRTorqueRequest 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001898 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		MSRinRegulation
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER MSRinRegulation 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f19 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqmpaou_xxxm3x_data.c' */
/begin MEASUREMENT
		MaxElectricalPowerAllowed
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		31.
    DISPLAY_IDENTIFIER MaxElectricalPowerAllowed 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001add 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smovnou_xxxm3x_data.c' */
/begin MEASUREMENT
		MaxEngineSpeedRequest
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER MaxEngineSpeedRequest 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002149 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqmaxou_xxxm3x_data.c' */
/begin MEASUREMENT
		MaximumInstantTorque
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER MaximumInstantTorque 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000cfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqestou_xxxm3x_data.c' */
/begin MEASUREMENT
		MeanEffectiveTorque
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER MeanEffectiveTorque 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000cf8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smovnou_xxxm3x_data.c' */
/begin MEASUREMENT
		MinEngineSpeedRequest
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER MinEngineSpeedRequest 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000214a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		MiniConsumptionRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER MiniConsumptionRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqminou_xxxm3x_data.c' */
/begin MEASUREMENT
		MinimumInstantTorque
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER MinimumInstantTorque 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000cfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		NeutralContact
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER NeutralContact 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f1b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbxxxou_xxxm3d_data.c' */
/begin MEASUREMENT
		NominalFuelConsumption
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER NominalFuelConsumption 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002428 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		OilDrainAlertResetRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER OilDrainAlertResetRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002441 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcbrkou_xxxm3x_data.c' */
/begin MEASUREMENT
		OpenActiveBrakeSwitch_ECM
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER OpenActiveBrakeSwitch_ECM 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ef4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vbx_emtv_ofs_clos_frst_1_NVM
		"Value of Vbx_emtv_ofs_clos_frst_1 stored in EEPROM. If 1, first learning is done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_ofs_clos_frst_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000e9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_dfctr_emtv_cutt_NVM
		""
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_cutt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000e92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_dfctr_emtv_ofs_no_norm_eprm_NVM
		""
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_ofs_no_norm_eprm 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000e94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_dfctr_emtv_reg_dirt_eprm_NVM
		""
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_reg_dirt_eprm 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000e93 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_clos_rat_h_thd_1_NVM
		""
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_h_thd_1 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0000e95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_clos_rat_h_thd_2_NVM
		""
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_h_thd_2 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0000e96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_clos_rat_l_thd_1_NVM
		""
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_l_thd_1 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0000e97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_clos_rat_l_thd_2_NVM
		""
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_l_thd_2 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0000e98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_clos_rat_val_1_NVM
		""
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_val_1 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0000e99 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_clos_rat_val_2_NVM
		""
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_emtv_clos_rat_val_2 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0000e9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_psn_err_sat_1_NVM
		""
		UWORD
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_err_sat_1 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000e88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_psn_ofs_clos_frst_NVM
		""
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ofs_clos_frst 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000e8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_psn_ofs_clos_last_NVM
		""
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ofs_clos_last 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000e90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_reg_h_thd_1_NVM
		""
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_reg_h_thd_1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000e8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_data.c' */
/begin MEASUREMENT
		OuAsoEgr_NVM.Vxx_emtv_reg_l_thd_1_NVM
		""
		UWORD
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_reg_l_thd_1 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000e8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vbx_it_ofs_clos_frst_eprm_NVM
		"Inverse value of Vbx_it_ofs_clos_frst_eprm. If 1, learning done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_clos_frst_eprm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000f46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vbx_it_ofs_open_frst_eprm_NVM
		"Inverse value of Vbx_it_ofs_open_frst_eprm. If 1, learning done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_open_frst_eprm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000f47 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_dfctr_it_cutt_NVM
		"Number of cutting presence failures noticed on successive driving cycles."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_cutt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000f41 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_dfctr_it_dirt_clos_NVM
		"Number of dirty closed thrust failures noticed on successive driving cycles."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_dirt_clos 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000f40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_dfctr_it_ofs_clos_frst_NVM
		"Number of first offset learning failures noticed on successive driving cycles (closed thrust)."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_ofs_clos_frst 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000f44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_dfctr_it_ofs_open_frst_NVM
		"Number of first offset learning failures noticed on successive driving cycles (open thrust)."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_ofs_open_frst 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000f45 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_dfctr_sit_reg_blk_open_eprm_NVM
		"Number of IT blocked open failures noticed on successives driving cycles."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_sit_reg_blk_open_eprm 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000f43 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_dfctr_sit_reg_el_eprm_NVM
		"Number of Stateline Init failures noticed on successives driving cycles."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dfctr_sit_reg_el_eprm 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0000f42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_it_psn_ofs_clos_frst_NVM
		"Value of the first closed thrust position learnt. Value stored in EEPROM."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_ofs_clos_frst 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_it_psn_ofs_clos_last_NVM
		"Value of the last closed thrust position learnt. Value stored in EEPROM."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_ofs_clos_last 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_it_psn_ofs_open_frst_NVM
		"Value of the first open thrust position learnt. Value stored in EEPROM."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_ofs_open_frst 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_data.c' */
/begin MEASUREMENT
		OuAsoIto_NVM.Vxx_it_psn_ofs_open_last_NVM
		"Value of the last open thrust position learnt. Value stored in EEPROM."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_ofs_open_last 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		OuAtoEfi_NVM.Vxx_efi_purg_fwe_NVM
		"Fuel wear estimation"
		ULONG
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_efi_purg_fwe 
    FORMAT "%9.3" 
    ECU_ADDRESS 0xd0005170 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vbx_owe_dil_req_km_2_clc_NVM
		"Boolean set if the oil dilution threshold is passed"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_dil_req_km_2_clc 
    ECU_ADDRESS 0xd00051a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vbx_owe_oil_drn_req_2_NVM
		"Oil drain requested by the strategy (level 2)"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_oil_drn_req_2 
    ECU_ADDRESS 0xd00051a5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vbx_owe_oil_drn_req_NVM
		"Oil drain requested by the strategy"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_oil_drn_req 
    ECU_ADDRESS 0xd00051a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vbx_owe_warn_req_km_mem_NVM
		"Vehicle kilometers memorisation trigger before rising edge"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_warn_req_km_mem 
    ECU_ADDRESS 0xd00051a7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_dil_NVM
		"Current oil dilution rate for oil wear estimation"
		UWORD
		RB_CONV_100_65535_Prc
		1
		100
		0
		100
    DISPLAY_IDENTIFIER Vxx_owe_dil 
    ECU_ADDRESS 0xd0005198 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_km1_NVM
		"Oil kilometer value for the first reference point"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_km1 
    ECU_ADDRESS 0xd0005190 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_km1_dil_NVM
		"Oil kilometer value for the first reference point for dilution potential kilometer calculation"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_km1_dil 
    ECU_ADDRESS 0xd00051a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_km2_NVM
		"Oil kilometer value for the second reference point"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_km2 
    ECU_ADDRESS 0xd0005194 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_km2_dil_NVM
		"Oil kilometer value for the second reference point for dilution potential kilometer calculation"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_km2_dil 
    ECU_ADDRESS 0xd000519a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_oxy_dil_fac_raw_NVM
		"Interpolation raw factor"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_oxy_dil_fac_raw 
    ECU_ADDRESS 0xd00051a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_pot_km_pot_NVM
		"Oil potential meters"
		ULONG
		RB_CONV_distance_1m
		1
		100
		0
		65535000
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_pot 
    ECU_ADDRESS 0xd0005188 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_pot_km_rnd_dil_NVM
		"Rounded oil dilution potential meters"
		ULONG
		RB_CONV_distance_1m
		1
		100
		0
		65535000
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_rnd_dil 
    ECU_ADDRESS 0xd000518c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_wea1_NVM
		"Oil wear when the first point is learned"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea1 
    ECU_ADDRESS 0xd0005192 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_wea1_dil_NVM
		"Oil dilution wear when the first point is learned"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea1_dil 
    ECU_ADDRESS 0xd000519e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_wea2_NVM
		"Oil wear when the second point is learned"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea2 
    ECU_ADDRESS 0xd0005196 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_data.c' */
/begin MEASUREMENT
		OuCloLuo_NVM.Vxx_owe_wea2_dil_NVM
		"Oil dilution wear when the second point is learned"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea2_dil 
    ECU_ADDRESS 0xd000519c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txp50ou_xxxm3x_data.c' */
/begin MEASUREMENT
		OverspeedIndicationDisplayReq
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER OverspeedIndicationDisplayReq 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000216d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		PTCEngineIdleSpeedRequest
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER PTCEngineIdleSpeedRequest 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002442 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		ParkingBrakeStatus
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER ParkingBrakeStatus 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_atpftou_xxxm3d_data.c' */
/begin MEASUREMENT
		ParticulateFilterFailureDisplay
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ParticulateFilterFailureDisplay 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002423 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_atpftou_xxxm3d_data.c' */
/begin MEASUREMENT
		ParticulateFilterState
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER ParticulateFilterState 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002424 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_data.c' */
/begin MEASUREMENT
		PcCruCtl_NVM.Vbx_cru_swi_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_swi 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001d52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_data.c' */
/begin MEASUREMENT
		PcCruCtl_NVM.Vxx_cru_cmp_diag_NVM
		""
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_cmp_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d53 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_NVM.Sxx_cru_dgn_eprm_imd_writ_ctr_NVM
		"Indicates the number of write-on-the-flight in EEPROM"
		ULONG
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dgn_eprm_imd_writ_ctr 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004af0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_NVM.Vbx_sli_buf_sf_NVM
		"1 = The 4 buffers (Sxx_sli_brk_buf, Sxx_sli_clu_buf, Sxx_sli_cru_stt_buf and Sxx_sli_vs_buf) correspond to the last shut off / 0 = the"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sli_buf_sf_NVM 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0004af9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_NVM.Vxx_cru_fail_NVM
		"Carrier of all the failures which cause CC failure"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_fail_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004af6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_NVM.Vxx_cru_sl_dacn_sys_NVM
		"Compilation of all the cru/sl normal deactivations due to system causes. Saved in E²PROM."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_dacn_sys_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004af8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_NVM.Vxx_cru_sl_fail_NVM
		"Carrier of all the failures which cause CC/SL failure"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_sl_fail_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004af7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_NVM.Vxx_fsl_km_NVM
		"Mileage recording"
		ULONG
		fttjmpc_wyufdBc_FDpbarc_kC_00oa
		1
		100
		0.
		16000000.
    DISPLAY_IDENTIFIER Vxx_fsl_km_NVM 
    FORMAT "%10.1" 
    ECU_ADDRESS 0xd0004aec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_NVM.Vxx_max_vs_NVM
		"Dynamic requested speed for FSL as read in EEPROM(default value $FFFE)."
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_max_vs_NVM 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0004af4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_brk_buf_NVM
		"Buffer of the 16 last seconds of the brake status stored in EEPROM"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_sli_brk_buf_NVM 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0004afc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_clu_buf_NVM
		"Buffer of the 16 last seconds of the clutch status stored in EEPROM"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_sli_clu_buf_NVM 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0004afe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_cru_stt_buf_NVM
		"Buffer of the 16 last seconds of the cruise control status stored in EEPROM"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_sli_cru_stt_buf_NVM 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0004b00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[0]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[0] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[10]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[10] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[11]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[11] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b0d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[12]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[12] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[13]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[13] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b0f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[14]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[14] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[15]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[15] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[1]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[1] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b03 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[2]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[2] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[3]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[3] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b05 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[4]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[4] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[5]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[5] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[6]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[6] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[7]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[7] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b09 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[8]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[8] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[9]
		"Buffer of the 16 last seconds of the vehicle speed stored in EEPROM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_sli_vs_buf[9] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b0b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Vbx_crsh_end_rec_eprm_NVM
		"A crash occured and the diagnostic add-on strategy is frozen"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_crsh_end_rec_eprm_NVM 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0004b14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Vxx_crsh_dly_ctr_NVM
		"Last shut off / activation -- crash duration counter"
		UBYTE
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_crsh_dly_ctr_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV2_NVM.Vxx_cru_dgn_diag_NVM
		"Carrier of information about the diag add on"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_cru_dgn_diag_NVM 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b13 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[0]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[0] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[10]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[10] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[11]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[11] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[12]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[12] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[13]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[13] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[14]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[14] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[15]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[15] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[16]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[16] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[17]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[17] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[18]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[18] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[19]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[19] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[1]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[1] 
